*****************************
* name drain gate source body class
mnmos vd vg vs gnd nmos w=90n l=50n

* name plus minus class
Rmem vs vc R='r'
* Rmem vs vc 1meg

Evd     vd     gnd vol='d'
Evg     vg     gnd vol='g'
Evc     vc     gnd vol='c'

****************************

* sources
* vsvd vd     gnd SIN(0.0, 1.0, 1,    0, 0, 0)
* vsvg vg     gnd SIN(0.0, 1.0, 10,   0, 0, 0)
* vsvs vscale gnd SIN(0.0, 1.0, 100,  0, 0, 0)
* vsvc vc     gnd SIN(0.0, 1.0, 1000, 0, 0, 0)

* vsvd vd     gnd pwl( 0 0 100m 0 100.1m 1 )
* vsvg vg     gnd pwl( 0 0 100m 0 100.1m 1 )
* vsvs vscale gnd pwl( 0 0 100m 0 100.1m 1 )
* vsvc vc     gnd pwl( 0 0 100m 0 100.1m 1 )

* vsvc vc     gnd pwl( 0 0 )

*****************************

.dc data=data1
.option post=1 POST_VERSION=9601 method=BDF
.probe i(Rmem) i(mnmos) r(Rmem)

* .print v(vd)

*****************************

.data data1
+ d g c r
+ 0.00 0.00 0.00 1000000
+ 0.00 0.00 0.00 8071429
+ 0.00 0.00 0.00 15142857
+ 0.00 0.00 0.00 22214286
+ 0.00 0.00 0.00 29285714
+ 0.00 0.00 0.00 36357143
+ 0.00 0.00 0.00 43428571
+ 0.00 0.00 0.00 50500000
+ 0.00 0.00 0.00 57571429
+ 0.00 0.00 0.00 64642857
+ 0.00 0.00 0.00 71714286
+ 0.00 0.00 0.00 78785714
+ 0.00 0.00 0.00 85857143
+ 0.00 0.00 0.00 92928571
+ 0.00 0.00 0.00 100000000
+ 0.00 0.00 0.07 1000000
+ 0.00 0.00 0.07 8071429
+ 0.00 0.00 0.07 15142857
+ 0.00 0.00 0.07 22214286
+ 0.00 0.00 0.07 29285714
+ 0.00 0.00 0.07 36357143
+ 0.00 0.00 0.07 43428571
+ 0.00 0.00 0.07 50500000
+ 0.00 0.00 0.07 57571429
+ 0.00 0.00 0.07 64642857
+ 0.00 0.00 0.07 71714286
+ 0.00 0.00 0.07 78785714
+ 0.00 0.00 0.07 85857143
+ 0.00 0.00 0.07 92928571
+ 0.00 0.00 0.07 100000000
+ 0.00 0.00 0.14 1000000
+ 0.00 0.00 0.14 8071429
+ 0.00 0.00 0.14 15142857
+ 0.00 0.00 0.14 22214286
+ 0.00 0.00 0.14 29285714
+ 0.00 0.00 0.14 36357143
+ 0.00 0.00 0.14 43428571
+ 0.00 0.00 0.14 50500000
+ 0.00 0.00 0.14 57571429
+ 0.00 0.00 0.14 64642857
+ 0.00 0.00 0.14 71714286
+ 0.00 0.00 0.14 78785714
+ 0.00 0.00 0.14 85857143
+ 0.00 0.00 0.14 92928571
+ 0.00 0.00 0.14 100000000
+ 0.00 0.00 0.21 1000000
+ 0.00 0.00 0.21 8071429
+ 0.00 0.00 0.21 15142857
+ 0.00 0.00 0.21 22214286
+ 0.00 0.00 0.21 29285714
+ 0.00 0.00 0.21 36357143
+ 0.00 0.00 0.21 43428571
+ 0.00 0.00 0.21 50500000
+ 0.00 0.00 0.21 57571429
+ 0.00 0.00 0.21 64642857
+ 0.00 0.00 0.21 71714286
+ 0.00 0.00 0.21 78785714
+ 0.00 0.00 0.21 85857143
+ 0.00 0.00 0.21 92928571
+ 0.00 0.00 0.21 100000000
+ 0.00 0.00 0.29 1000000
+ 0.00 0.00 0.29 8071429
+ 0.00 0.00 0.29 15142857
+ 0.00 0.00 0.29 22214286
+ 0.00 0.00 0.29 29285714
+ 0.00 0.00 0.29 36357143
+ 0.00 0.00 0.29 43428571
+ 0.00 0.00 0.29 50500000
+ 0.00 0.00 0.29 57571429
+ 0.00 0.00 0.29 64642857
+ 0.00 0.00 0.29 71714286
+ 0.00 0.00 0.29 78785714
+ 0.00 0.00 0.29 85857143
+ 0.00 0.00 0.29 92928571
+ 0.00 0.00 0.29 100000000
+ 0.00 0.00 0.36 1000000
+ 0.00 0.00 0.36 8071429
+ 0.00 0.00 0.36 15142857
+ 0.00 0.00 0.36 22214286
+ 0.00 0.00 0.36 29285714
+ 0.00 0.00 0.36 36357143
+ 0.00 0.00 0.36 43428571
+ 0.00 0.00 0.36 50500000
+ 0.00 0.00 0.36 57571429
+ 0.00 0.00 0.36 64642857
+ 0.00 0.00 0.36 71714286
+ 0.00 0.00 0.36 78785714
+ 0.00 0.00 0.36 85857143
+ 0.00 0.00 0.36 92928571
+ 0.00 0.00 0.36 100000000
+ 0.00 0.00 0.43 1000000
+ 0.00 0.00 0.43 8071429
+ 0.00 0.00 0.43 15142857
+ 0.00 0.00 0.43 22214286
+ 0.00 0.00 0.43 29285714
+ 0.00 0.00 0.43 36357143
+ 0.00 0.00 0.43 43428571
+ 0.00 0.00 0.43 50500000
+ 0.00 0.00 0.43 57571429
+ 0.00 0.00 0.43 64642857
+ 0.00 0.00 0.43 71714286
+ 0.00 0.00 0.43 78785714
+ 0.00 0.00 0.43 85857143
+ 0.00 0.00 0.43 92928571
+ 0.00 0.00 0.43 100000000
+ 0.00 0.00 0.50 1000000
+ 0.00 0.00 0.50 8071429
+ 0.00 0.00 0.50 15142857
+ 0.00 0.00 0.50 22214286
+ 0.00 0.00 0.50 29285714
+ 0.00 0.00 0.50 36357143
+ 0.00 0.00 0.50 43428571
+ 0.00 0.00 0.50 50500000
+ 0.00 0.00 0.50 57571429
+ 0.00 0.00 0.50 64642857
+ 0.00 0.00 0.50 71714286
+ 0.00 0.00 0.50 78785714
+ 0.00 0.00 0.50 85857143
+ 0.00 0.00 0.50 92928571
+ 0.00 0.00 0.50 100000000
+ 0.00 0.00 0.57 1000000
+ 0.00 0.00 0.57 8071429
+ 0.00 0.00 0.57 15142857
+ 0.00 0.00 0.57 22214286
+ 0.00 0.00 0.57 29285714
+ 0.00 0.00 0.57 36357143
+ 0.00 0.00 0.57 43428571
+ 0.00 0.00 0.57 50500000
+ 0.00 0.00 0.57 57571429
+ 0.00 0.00 0.57 64642857
+ 0.00 0.00 0.57 71714286
+ 0.00 0.00 0.57 78785714
+ 0.00 0.00 0.57 85857143
+ 0.00 0.00 0.57 92928571
+ 0.00 0.00 0.57 100000000
+ 0.00 0.00 0.64 1000000
+ 0.00 0.00 0.64 8071429
+ 0.00 0.00 0.64 15142857
+ 0.00 0.00 0.64 22214286
+ 0.00 0.00 0.64 29285714
+ 0.00 0.00 0.64 36357143
+ 0.00 0.00 0.64 43428571
+ 0.00 0.00 0.64 50500000
+ 0.00 0.00 0.64 57571429
+ 0.00 0.00 0.64 64642857
+ 0.00 0.00 0.64 71714286
+ 0.00 0.00 0.64 78785714
+ 0.00 0.00 0.64 85857143
+ 0.00 0.00 0.64 92928571
+ 0.00 0.00 0.64 100000000
+ 0.00 0.00 0.71 1000000
+ 0.00 0.00 0.71 8071429
+ 0.00 0.00 0.71 15142857
+ 0.00 0.00 0.71 22214286
+ 0.00 0.00 0.71 29285714
+ 0.00 0.00 0.71 36357143
+ 0.00 0.00 0.71 43428571
+ 0.00 0.00 0.71 50500000
+ 0.00 0.00 0.71 57571429
+ 0.00 0.00 0.71 64642857
+ 0.00 0.00 0.71 71714286
+ 0.00 0.00 0.71 78785714
+ 0.00 0.00 0.71 85857143
+ 0.00 0.00 0.71 92928571
+ 0.00 0.00 0.71 100000000
+ 0.00 0.00 0.79 1000000
+ 0.00 0.00 0.79 8071429
+ 0.00 0.00 0.79 15142857
+ 0.00 0.00 0.79 22214286
+ 0.00 0.00 0.79 29285714
+ 0.00 0.00 0.79 36357143
+ 0.00 0.00 0.79 43428571
+ 0.00 0.00 0.79 50500000
+ 0.00 0.00 0.79 57571429
+ 0.00 0.00 0.79 64642857
+ 0.00 0.00 0.79 71714286
+ 0.00 0.00 0.79 78785714
+ 0.00 0.00 0.79 85857143
+ 0.00 0.00 0.79 92928571
+ 0.00 0.00 0.79 100000000
+ 0.00 0.00 0.86 1000000
+ 0.00 0.00 0.86 8071429
+ 0.00 0.00 0.86 15142857
+ 0.00 0.00 0.86 22214286
+ 0.00 0.00 0.86 29285714
+ 0.00 0.00 0.86 36357143
+ 0.00 0.00 0.86 43428571
+ 0.00 0.00 0.86 50500000
+ 0.00 0.00 0.86 57571429
+ 0.00 0.00 0.86 64642857
+ 0.00 0.00 0.86 71714286
+ 0.00 0.00 0.86 78785714
+ 0.00 0.00 0.86 85857143
+ 0.00 0.00 0.86 92928571
+ 0.00 0.00 0.86 100000000
+ 0.00 0.00 0.93 1000000
+ 0.00 0.00 0.93 8071429
+ 0.00 0.00 0.93 15142857
+ 0.00 0.00 0.93 22214286
+ 0.00 0.00 0.93 29285714
+ 0.00 0.00 0.93 36357143
+ 0.00 0.00 0.93 43428571
+ 0.00 0.00 0.93 50500000
+ 0.00 0.00 0.93 57571429
+ 0.00 0.00 0.93 64642857
+ 0.00 0.00 0.93 71714286
+ 0.00 0.00 0.93 78785714
+ 0.00 0.00 0.93 85857143
+ 0.00 0.00 0.93 92928571
+ 0.00 0.00 0.93 100000000
+ 0.00 0.00 1.00 1000000
+ 0.00 0.00 1.00 8071429
+ 0.00 0.00 1.00 15142857
+ 0.00 0.00 1.00 22214286
+ 0.00 0.00 1.00 29285714
+ 0.00 0.00 1.00 36357143
+ 0.00 0.00 1.00 43428571
+ 0.00 0.00 1.00 50500000
+ 0.00 0.00 1.00 57571429
+ 0.00 0.00 1.00 64642857
+ 0.00 0.00 1.00 71714286
+ 0.00 0.00 1.00 78785714
+ 0.00 0.00 1.00 85857143
+ 0.00 0.00 1.00 92928571
+ 0.00 0.00 1.00 100000000
+ 0.00 0.07 0.00 1000000
+ 0.00 0.07 0.00 8071429
+ 0.00 0.07 0.00 15142857
+ 0.00 0.07 0.00 22214286
+ 0.00 0.07 0.00 29285714
+ 0.00 0.07 0.00 36357143
+ 0.00 0.07 0.00 43428571
+ 0.00 0.07 0.00 50500000
+ 0.00 0.07 0.00 57571429
+ 0.00 0.07 0.00 64642857
+ 0.00 0.07 0.00 71714286
+ 0.00 0.07 0.00 78785714
+ 0.00 0.07 0.00 85857143
+ 0.00 0.07 0.00 92928571
+ 0.00 0.07 0.00 100000000
+ 0.00 0.07 0.07 1000000
+ 0.00 0.07 0.07 8071429
+ 0.00 0.07 0.07 15142857
+ 0.00 0.07 0.07 22214286
+ 0.00 0.07 0.07 29285714
+ 0.00 0.07 0.07 36357143
+ 0.00 0.07 0.07 43428571
+ 0.00 0.07 0.07 50500000
+ 0.00 0.07 0.07 57571429
+ 0.00 0.07 0.07 64642857
+ 0.00 0.07 0.07 71714286
+ 0.00 0.07 0.07 78785714
+ 0.00 0.07 0.07 85857143
+ 0.00 0.07 0.07 92928571
+ 0.00 0.07 0.07 100000000
+ 0.00 0.07 0.14 1000000
+ 0.00 0.07 0.14 8071429
+ 0.00 0.07 0.14 15142857
+ 0.00 0.07 0.14 22214286
+ 0.00 0.07 0.14 29285714
+ 0.00 0.07 0.14 36357143
+ 0.00 0.07 0.14 43428571
+ 0.00 0.07 0.14 50500000
+ 0.00 0.07 0.14 57571429
+ 0.00 0.07 0.14 64642857
+ 0.00 0.07 0.14 71714286
+ 0.00 0.07 0.14 78785714
+ 0.00 0.07 0.14 85857143
+ 0.00 0.07 0.14 92928571
+ 0.00 0.07 0.14 100000000
+ 0.00 0.07 0.21 1000000
+ 0.00 0.07 0.21 8071429
+ 0.00 0.07 0.21 15142857
+ 0.00 0.07 0.21 22214286
+ 0.00 0.07 0.21 29285714
+ 0.00 0.07 0.21 36357143
+ 0.00 0.07 0.21 43428571
+ 0.00 0.07 0.21 50500000
+ 0.00 0.07 0.21 57571429
+ 0.00 0.07 0.21 64642857
+ 0.00 0.07 0.21 71714286
+ 0.00 0.07 0.21 78785714
+ 0.00 0.07 0.21 85857143
+ 0.00 0.07 0.21 92928571
+ 0.00 0.07 0.21 100000000
+ 0.00 0.07 0.29 1000000
+ 0.00 0.07 0.29 8071429
+ 0.00 0.07 0.29 15142857
+ 0.00 0.07 0.29 22214286
+ 0.00 0.07 0.29 29285714
+ 0.00 0.07 0.29 36357143
+ 0.00 0.07 0.29 43428571
+ 0.00 0.07 0.29 50500000
+ 0.00 0.07 0.29 57571429
+ 0.00 0.07 0.29 64642857
+ 0.00 0.07 0.29 71714286
+ 0.00 0.07 0.29 78785714
+ 0.00 0.07 0.29 85857143
+ 0.00 0.07 0.29 92928571
+ 0.00 0.07 0.29 100000000
+ 0.00 0.07 0.36 1000000
+ 0.00 0.07 0.36 8071429
+ 0.00 0.07 0.36 15142857
+ 0.00 0.07 0.36 22214286
+ 0.00 0.07 0.36 29285714
+ 0.00 0.07 0.36 36357143
+ 0.00 0.07 0.36 43428571
+ 0.00 0.07 0.36 50500000
+ 0.00 0.07 0.36 57571429
+ 0.00 0.07 0.36 64642857
+ 0.00 0.07 0.36 71714286
+ 0.00 0.07 0.36 78785714
+ 0.00 0.07 0.36 85857143
+ 0.00 0.07 0.36 92928571
+ 0.00 0.07 0.36 100000000
+ 0.00 0.07 0.43 1000000
+ 0.00 0.07 0.43 8071429
+ 0.00 0.07 0.43 15142857
+ 0.00 0.07 0.43 22214286
+ 0.00 0.07 0.43 29285714
+ 0.00 0.07 0.43 36357143
+ 0.00 0.07 0.43 43428571
+ 0.00 0.07 0.43 50500000
+ 0.00 0.07 0.43 57571429
+ 0.00 0.07 0.43 64642857
+ 0.00 0.07 0.43 71714286
+ 0.00 0.07 0.43 78785714
+ 0.00 0.07 0.43 85857143
+ 0.00 0.07 0.43 92928571
+ 0.00 0.07 0.43 100000000
+ 0.00 0.07 0.50 1000000
+ 0.00 0.07 0.50 8071429
+ 0.00 0.07 0.50 15142857
+ 0.00 0.07 0.50 22214286
+ 0.00 0.07 0.50 29285714
+ 0.00 0.07 0.50 36357143
+ 0.00 0.07 0.50 43428571
+ 0.00 0.07 0.50 50500000
+ 0.00 0.07 0.50 57571429
+ 0.00 0.07 0.50 64642857
+ 0.00 0.07 0.50 71714286
+ 0.00 0.07 0.50 78785714
+ 0.00 0.07 0.50 85857143
+ 0.00 0.07 0.50 92928571
+ 0.00 0.07 0.50 100000000
+ 0.00 0.07 0.57 1000000
+ 0.00 0.07 0.57 8071429
+ 0.00 0.07 0.57 15142857
+ 0.00 0.07 0.57 22214286
+ 0.00 0.07 0.57 29285714
+ 0.00 0.07 0.57 36357143
+ 0.00 0.07 0.57 43428571
+ 0.00 0.07 0.57 50500000
+ 0.00 0.07 0.57 57571429
+ 0.00 0.07 0.57 64642857
+ 0.00 0.07 0.57 71714286
+ 0.00 0.07 0.57 78785714
+ 0.00 0.07 0.57 85857143
+ 0.00 0.07 0.57 92928571
+ 0.00 0.07 0.57 100000000
+ 0.00 0.07 0.64 1000000
+ 0.00 0.07 0.64 8071429
+ 0.00 0.07 0.64 15142857
+ 0.00 0.07 0.64 22214286
+ 0.00 0.07 0.64 29285714
+ 0.00 0.07 0.64 36357143
+ 0.00 0.07 0.64 43428571
+ 0.00 0.07 0.64 50500000
+ 0.00 0.07 0.64 57571429
+ 0.00 0.07 0.64 64642857
+ 0.00 0.07 0.64 71714286
+ 0.00 0.07 0.64 78785714
+ 0.00 0.07 0.64 85857143
+ 0.00 0.07 0.64 92928571
+ 0.00 0.07 0.64 100000000
+ 0.00 0.07 0.71 1000000
+ 0.00 0.07 0.71 8071429
+ 0.00 0.07 0.71 15142857
+ 0.00 0.07 0.71 22214286
+ 0.00 0.07 0.71 29285714
+ 0.00 0.07 0.71 36357143
+ 0.00 0.07 0.71 43428571
+ 0.00 0.07 0.71 50500000
+ 0.00 0.07 0.71 57571429
+ 0.00 0.07 0.71 64642857
+ 0.00 0.07 0.71 71714286
+ 0.00 0.07 0.71 78785714
+ 0.00 0.07 0.71 85857143
+ 0.00 0.07 0.71 92928571
+ 0.00 0.07 0.71 100000000
+ 0.00 0.07 0.79 1000000
+ 0.00 0.07 0.79 8071429
+ 0.00 0.07 0.79 15142857
+ 0.00 0.07 0.79 22214286
+ 0.00 0.07 0.79 29285714
+ 0.00 0.07 0.79 36357143
+ 0.00 0.07 0.79 43428571
+ 0.00 0.07 0.79 50500000
+ 0.00 0.07 0.79 57571429
+ 0.00 0.07 0.79 64642857
+ 0.00 0.07 0.79 71714286
+ 0.00 0.07 0.79 78785714
+ 0.00 0.07 0.79 85857143
+ 0.00 0.07 0.79 92928571
+ 0.00 0.07 0.79 100000000
+ 0.00 0.07 0.86 1000000
+ 0.00 0.07 0.86 8071429
+ 0.00 0.07 0.86 15142857
+ 0.00 0.07 0.86 22214286
+ 0.00 0.07 0.86 29285714
+ 0.00 0.07 0.86 36357143
+ 0.00 0.07 0.86 43428571
+ 0.00 0.07 0.86 50500000
+ 0.00 0.07 0.86 57571429
+ 0.00 0.07 0.86 64642857
+ 0.00 0.07 0.86 71714286
+ 0.00 0.07 0.86 78785714
+ 0.00 0.07 0.86 85857143
+ 0.00 0.07 0.86 92928571
+ 0.00 0.07 0.86 100000000
+ 0.00 0.07 0.93 1000000
+ 0.00 0.07 0.93 8071429
+ 0.00 0.07 0.93 15142857
+ 0.00 0.07 0.93 22214286
+ 0.00 0.07 0.93 29285714
+ 0.00 0.07 0.93 36357143
+ 0.00 0.07 0.93 43428571
+ 0.00 0.07 0.93 50500000
+ 0.00 0.07 0.93 57571429
+ 0.00 0.07 0.93 64642857
+ 0.00 0.07 0.93 71714286
+ 0.00 0.07 0.93 78785714
+ 0.00 0.07 0.93 85857143
+ 0.00 0.07 0.93 92928571
+ 0.00 0.07 0.93 100000000
+ 0.00 0.07 1.00 1000000
+ 0.00 0.07 1.00 8071429
+ 0.00 0.07 1.00 15142857
+ 0.00 0.07 1.00 22214286
+ 0.00 0.07 1.00 29285714
+ 0.00 0.07 1.00 36357143
+ 0.00 0.07 1.00 43428571
+ 0.00 0.07 1.00 50500000
+ 0.00 0.07 1.00 57571429
+ 0.00 0.07 1.00 64642857
+ 0.00 0.07 1.00 71714286
+ 0.00 0.07 1.00 78785714
+ 0.00 0.07 1.00 85857143
+ 0.00 0.07 1.00 92928571
+ 0.00 0.07 1.00 100000000
+ 0.00 0.14 0.00 1000000
+ 0.00 0.14 0.00 8071429
+ 0.00 0.14 0.00 15142857
+ 0.00 0.14 0.00 22214286
+ 0.00 0.14 0.00 29285714
+ 0.00 0.14 0.00 36357143
+ 0.00 0.14 0.00 43428571
+ 0.00 0.14 0.00 50500000
+ 0.00 0.14 0.00 57571429
+ 0.00 0.14 0.00 64642857
+ 0.00 0.14 0.00 71714286
+ 0.00 0.14 0.00 78785714
+ 0.00 0.14 0.00 85857143
+ 0.00 0.14 0.00 92928571
+ 0.00 0.14 0.00 100000000
+ 0.00 0.14 0.07 1000000
+ 0.00 0.14 0.07 8071429
+ 0.00 0.14 0.07 15142857
+ 0.00 0.14 0.07 22214286
+ 0.00 0.14 0.07 29285714
+ 0.00 0.14 0.07 36357143
+ 0.00 0.14 0.07 43428571
+ 0.00 0.14 0.07 50500000
+ 0.00 0.14 0.07 57571429
+ 0.00 0.14 0.07 64642857
+ 0.00 0.14 0.07 71714286
+ 0.00 0.14 0.07 78785714
+ 0.00 0.14 0.07 85857143
+ 0.00 0.14 0.07 92928571
+ 0.00 0.14 0.07 100000000
+ 0.00 0.14 0.14 1000000
+ 0.00 0.14 0.14 8071429
+ 0.00 0.14 0.14 15142857
+ 0.00 0.14 0.14 22214286
+ 0.00 0.14 0.14 29285714
+ 0.00 0.14 0.14 36357143
+ 0.00 0.14 0.14 43428571
+ 0.00 0.14 0.14 50500000
+ 0.00 0.14 0.14 57571429
+ 0.00 0.14 0.14 64642857
+ 0.00 0.14 0.14 71714286
+ 0.00 0.14 0.14 78785714
+ 0.00 0.14 0.14 85857143
+ 0.00 0.14 0.14 92928571
+ 0.00 0.14 0.14 100000000
+ 0.00 0.14 0.21 1000000
+ 0.00 0.14 0.21 8071429
+ 0.00 0.14 0.21 15142857
+ 0.00 0.14 0.21 22214286
+ 0.00 0.14 0.21 29285714
+ 0.00 0.14 0.21 36357143
+ 0.00 0.14 0.21 43428571
+ 0.00 0.14 0.21 50500000
+ 0.00 0.14 0.21 57571429
+ 0.00 0.14 0.21 64642857
+ 0.00 0.14 0.21 71714286
+ 0.00 0.14 0.21 78785714
+ 0.00 0.14 0.21 85857143
+ 0.00 0.14 0.21 92928571
+ 0.00 0.14 0.21 100000000
+ 0.00 0.14 0.29 1000000
+ 0.00 0.14 0.29 8071429
+ 0.00 0.14 0.29 15142857
+ 0.00 0.14 0.29 22214286
+ 0.00 0.14 0.29 29285714
+ 0.00 0.14 0.29 36357143
+ 0.00 0.14 0.29 43428571
+ 0.00 0.14 0.29 50500000
+ 0.00 0.14 0.29 57571429
+ 0.00 0.14 0.29 64642857
+ 0.00 0.14 0.29 71714286
+ 0.00 0.14 0.29 78785714
+ 0.00 0.14 0.29 85857143
+ 0.00 0.14 0.29 92928571
+ 0.00 0.14 0.29 100000000
+ 0.00 0.14 0.36 1000000
+ 0.00 0.14 0.36 8071429
+ 0.00 0.14 0.36 15142857
+ 0.00 0.14 0.36 22214286
+ 0.00 0.14 0.36 29285714
+ 0.00 0.14 0.36 36357143
+ 0.00 0.14 0.36 43428571
+ 0.00 0.14 0.36 50500000
+ 0.00 0.14 0.36 57571429
+ 0.00 0.14 0.36 64642857
+ 0.00 0.14 0.36 71714286
+ 0.00 0.14 0.36 78785714
+ 0.00 0.14 0.36 85857143
+ 0.00 0.14 0.36 92928571
+ 0.00 0.14 0.36 100000000
+ 0.00 0.14 0.43 1000000
+ 0.00 0.14 0.43 8071429
+ 0.00 0.14 0.43 15142857
+ 0.00 0.14 0.43 22214286
+ 0.00 0.14 0.43 29285714
+ 0.00 0.14 0.43 36357143
+ 0.00 0.14 0.43 43428571
+ 0.00 0.14 0.43 50500000
+ 0.00 0.14 0.43 57571429
+ 0.00 0.14 0.43 64642857
+ 0.00 0.14 0.43 71714286
+ 0.00 0.14 0.43 78785714
+ 0.00 0.14 0.43 85857143
+ 0.00 0.14 0.43 92928571
+ 0.00 0.14 0.43 100000000
+ 0.00 0.14 0.50 1000000
+ 0.00 0.14 0.50 8071429
+ 0.00 0.14 0.50 15142857
+ 0.00 0.14 0.50 22214286
+ 0.00 0.14 0.50 29285714
+ 0.00 0.14 0.50 36357143
+ 0.00 0.14 0.50 43428571
+ 0.00 0.14 0.50 50500000
+ 0.00 0.14 0.50 57571429
+ 0.00 0.14 0.50 64642857
+ 0.00 0.14 0.50 71714286
+ 0.00 0.14 0.50 78785714
+ 0.00 0.14 0.50 85857143
+ 0.00 0.14 0.50 92928571
+ 0.00 0.14 0.50 100000000
+ 0.00 0.14 0.57 1000000
+ 0.00 0.14 0.57 8071429
+ 0.00 0.14 0.57 15142857
+ 0.00 0.14 0.57 22214286
+ 0.00 0.14 0.57 29285714
+ 0.00 0.14 0.57 36357143
+ 0.00 0.14 0.57 43428571
+ 0.00 0.14 0.57 50500000
+ 0.00 0.14 0.57 57571429
+ 0.00 0.14 0.57 64642857
+ 0.00 0.14 0.57 71714286
+ 0.00 0.14 0.57 78785714
+ 0.00 0.14 0.57 85857143
+ 0.00 0.14 0.57 92928571
+ 0.00 0.14 0.57 100000000
+ 0.00 0.14 0.64 1000000
+ 0.00 0.14 0.64 8071429
+ 0.00 0.14 0.64 15142857
+ 0.00 0.14 0.64 22214286
+ 0.00 0.14 0.64 29285714
+ 0.00 0.14 0.64 36357143
+ 0.00 0.14 0.64 43428571
+ 0.00 0.14 0.64 50500000
+ 0.00 0.14 0.64 57571429
+ 0.00 0.14 0.64 64642857
+ 0.00 0.14 0.64 71714286
+ 0.00 0.14 0.64 78785714
+ 0.00 0.14 0.64 85857143
+ 0.00 0.14 0.64 92928571
+ 0.00 0.14 0.64 100000000
+ 0.00 0.14 0.71 1000000
+ 0.00 0.14 0.71 8071429
+ 0.00 0.14 0.71 15142857
+ 0.00 0.14 0.71 22214286
+ 0.00 0.14 0.71 29285714
+ 0.00 0.14 0.71 36357143
+ 0.00 0.14 0.71 43428571
+ 0.00 0.14 0.71 50500000
+ 0.00 0.14 0.71 57571429
+ 0.00 0.14 0.71 64642857
+ 0.00 0.14 0.71 71714286
+ 0.00 0.14 0.71 78785714
+ 0.00 0.14 0.71 85857143
+ 0.00 0.14 0.71 92928571
+ 0.00 0.14 0.71 100000000
+ 0.00 0.14 0.79 1000000
+ 0.00 0.14 0.79 8071429
+ 0.00 0.14 0.79 15142857
+ 0.00 0.14 0.79 22214286
+ 0.00 0.14 0.79 29285714
+ 0.00 0.14 0.79 36357143
+ 0.00 0.14 0.79 43428571
+ 0.00 0.14 0.79 50500000
+ 0.00 0.14 0.79 57571429
+ 0.00 0.14 0.79 64642857
+ 0.00 0.14 0.79 71714286
+ 0.00 0.14 0.79 78785714
+ 0.00 0.14 0.79 85857143
+ 0.00 0.14 0.79 92928571
+ 0.00 0.14 0.79 100000000
+ 0.00 0.14 0.86 1000000
+ 0.00 0.14 0.86 8071429
+ 0.00 0.14 0.86 15142857
+ 0.00 0.14 0.86 22214286
+ 0.00 0.14 0.86 29285714
+ 0.00 0.14 0.86 36357143
+ 0.00 0.14 0.86 43428571
+ 0.00 0.14 0.86 50500000
+ 0.00 0.14 0.86 57571429
+ 0.00 0.14 0.86 64642857
+ 0.00 0.14 0.86 71714286
+ 0.00 0.14 0.86 78785714
+ 0.00 0.14 0.86 85857143
+ 0.00 0.14 0.86 92928571
+ 0.00 0.14 0.86 100000000
+ 0.00 0.14 0.93 1000000
+ 0.00 0.14 0.93 8071429
+ 0.00 0.14 0.93 15142857
+ 0.00 0.14 0.93 22214286
+ 0.00 0.14 0.93 29285714
+ 0.00 0.14 0.93 36357143
+ 0.00 0.14 0.93 43428571
+ 0.00 0.14 0.93 50500000
+ 0.00 0.14 0.93 57571429
+ 0.00 0.14 0.93 64642857
+ 0.00 0.14 0.93 71714286
+ 0.00 0.14 0.93 78785714
+ 0.00 0.14 0.93 85857143
+ 0.00 0.14 0.93 92928571
+ 0.00 0.14 0.93 100000000
+ 0.00 0.14 1.00 1000000
+ 0.00 0.14 1.00 8071429
+ 0.00 0.14 1.00 15142857
+ 0.00 0.14 1.00 22214286
+ 0.00 0.14 1.00 29285714
+ 0.00 0.14 1.00 36357143
+ 0.00 0.14 1.00 43428571
+ 0.00 0.14 1.00 50500000
+ 0.00 0.14 1.00 57571429
+ 0.00 0.14 1.00 64642857
+ 0.00 0.14 1.00 71714286
+ 0.00 0.14 1.00 78785714
+ 0.00 0.14 1.00 85857143
+ 0.00 0.14 1.00 92928571
+ 0.00 0.14 1.00 100000000
+ 0.00 0.21 0.00 1000000
+ 0.00 0.21 0.00 8071429
+ 0.00 0.21 0.00 15142857
+ 0.00 0.21 0.00 22214286
+ 0.00 0.21 0.00 29285714
+ 0.00 0.21 0.00 36357143
+ 0.00 0.21 0.00 43428571
+ 0.00 0.21 0.00 50500000
+ 0.00 0.21 0.00 57571429
+ 0.00 0.21 0.00 64642857
+ 0.00 0.21 0.00 71714286
+ 0.00 0.21 0.00 78785714
+ 0.00 0.21 0.00 85857143
+ 0.00 0.21 0.00 92928571
+ 0.00 0.21 0.00 100000000
+ 0.00 0.21 0.07 1000000
+ 0.00 0.21 0.07 8071429
+ 0.00 0.21 0.07 15142857
+ 0.00 0.21 0.07 22214286
+ 0.00 0.21 0.07 29285714
+ 0.00 0.21 0.07 36357143
+ 0.00 0.21 0.07 43428571
+ 0.00 0.21 0.07 50500000
+ 0.00 0.21 0.07 57571429
+ 0.00 0.21 0.07 64642857
+ 0.00 0.21 0.07 71714286
+ 0.00 0.21 0.07 78785714
+ 0.00 0.21 0.07 85857143
+ 0.00 0.21 0.07 92928571
+ 0.00 0.21 0.07 100000000
+ 0.00 0.21 0.14 1000000
+ 0.00 0.21 0.14 8071429
+ 0.00 0.21 0.14 15142857
+ 0.00 0.21 0.14 22214286
+ 0.00 0.21 0.14 29285714
+ 0.00 0.21 0.14 36357143
+ 0.00 0.21 0.14 43428571
+ 0.00 0.21 0.14 50500000
+ 0.00 0.21 0.14 57571429
+ 0.00 0.21 0.14 64642857
+ 0.00 0.21 0.14 71714286
+ 0.00 0.21 0.14 78785714
+ 0.00 0.21 0.14 85857143
+ 0.00 0.21 0.14 92928571
+ 0.00 0.21 0.14 100000000
+ 0.00 0.21 0.21 1000000
+ 0.00 0.21 0.21 8071429
+ 0.00 0.21 0.21 15142857
+ 0.00 0.21 0.21 22214286
+ 0.00 0.21 0.21 29285714
+ 0.00 0.21 0.21 36357143
+ 0.00 0.21 0.21 43428571
+ 0.00 0.21 0.21 50500000
+ 0.00 0.21 0.21 57571429
+ 0.00 0.21 0.21 64642857
+ 0.00 0.21 0.21 71714286
+ 0.00 0.21 0.21 78785714
+ 0.00 0.21 0.21 85857143
+ 0.00 0.21 0.21 92928571
+ 0.00 0.21 0.21 100000000
+ 0.00 0.21 0.29 1000000
+ 0.00 0.21 0.29 8071429
+ 0.00 0.21 0.29 15142857
+ 0.00 0.21 0.29 22214286
+ 0.00 0.21 0.29 29285714
+ 0.00 0.21 0.29 36357143
+ 0.00 0.21 0.29 43428571
+ 0.00 0.21 0.29 50500000
+ 0.00 0.21 0.29 57571429
+ 0.00 0.21 0.29 64642857
+ 0.00 0.21 0.29 71714286
+ 0.00 0.21 0.29 78785714
+ 0.00 0.21 0.29 85857143
+ 0.00 0.21 0.29 92928571
+ 0.00 0.21 0.29 100000000
+ 0.00 0.21 0.36 1000000
+ 0.00 0.21 0.36 8071429
+ 0.00 0.21 0.36 15142857
+ 0.00 0.21 0.36 22214286
+ 0.00 0.21 0.36 29285714
+ 0.00 0.21 0.36 36357143
+ 0.00 0.21 0.36 43428571
+ 0.00 0.21 0.36 50500000
+ 0.00 0.21 0.36 57571429
+ 0.00 0.21 0.36 64642857
+ 0.00 0.21 0.36 71714286
+ 0.00 0.21 0.36 78785714
+ 0.00 0.21 0.36 85857143
+ 0.00 0.21 0.36 92928571
+ 0.00 0.21 0.36 100000000
+ 0.00 0.21 0.43 1000000
+ 0.00 0.21 0.43 8071429
+ 0.00 0.21 0.43 15142857
+ 0.00 0.21 0.43 22214286
+ 0.00 0.21 0.43 29285714
+ 0.00 0.21 0.43 36357143
+ 0.00 0.21 0.43 43428571
+ 0.00 0.21 0.43 50500000
+ 0.00 0.21 0.43 57571429
+ 0.00 0.21 0.43 64642857
+ 0.00 0.21 0.43 71714286
+ 0.00 0.21 0.43 78785714
+ 0.00 0.21 0.43 85857143
+ 0.00 0.21 0.43 92928571
+ 0.00 0.21 0.43 100000000
+ 0.00 0.21 0.50 1000000
+ 0.00 0.21 0.50 8071429
+ 0.00 0.21 0.50 15142857
+ 0.00 0.21 0.50 22214286
+ 0.00 0.21 0.50 29285714
+ 0.00 0.21 0.50 36357143
+ 0.00 0.21 0.50 43428571
+ 0.00 0.21 0.50 50500000
+ 0.00 0.21 0.50 57571429
+ 0.00 0.21 0.50 64642857
+ 0.00 0.21 0.50 71714286
+ 0.00 0.21 0.50 78785714
+ 0.00 0.21 0.50 85857143
+ 0.00 0.21 0.50 92928571
+ 0.00 0.21 0.50 100000000
+ 0.00 0.21 0.57 1000000
+ 0.00 0.21 0.57 8071429
+ 0.00 0.21 0.57 15142857
+ 0.00 0.21 0.57 22214286
+ 0.00 0.21 0.57 29285714
+ 0.00 0.21 0.57 36357143
+ 0.00 0.21 0.57 43428571
+ 0.00 0.21 0.57 50500000
+ 0.00 0.21 0.57 57571429
+ 0.00 0.21 0.57 64642857
+ 0.00 0.21 0.57 71714286
+ 0.00 0.21 0.57 78785714
+ 0.00 0.21 0.57 85857143
+ 0.00 0.21 0.57 92928571
+ 0.00 0.21 0.57 100000000
+ 0.00 0.21 0.64 1000000
+ 0.00 0.21 0.64 8071429
+ 0.00 0.21 0.64 15142857
+ 0.00 0.21 0.64 22214286
+ 0.00 0.21 0.64 29285714
+ 0.00 0.21 0.64 36357143
+ 0.00 0.21 0.64 43428571
+ 0.00 0.21 0.64 50500000
+ 0.00 0.21 0.64 57571429
+ 0.00 0.21 0.64 64642857
+ 0.00 0.21 0.64 71714286
+ 0.00 0.21 0.64 78785714
+ 0.00 0.21 0.64 85857143
+ 0.00 0.21 0.64 92928571
+ 0.00 0.21 0.64 100000000
+ 0.00 0.21 0.71 1000000
+ 0.00 0.21 0.71 8071429
+ 0.00 0.21 0.71 15142857
+ 0.00 0.21 0.71 22214286
+ 0.00 0.21 0.71 29285714
+ 0.00 0.21 0.71 36357143
+ 0.00 0.21 0.71 43428571
+ 0.00 0.21 0.71 50500000
+ 0.00 0.21 0.71 57571429
+ 0.00 0.21 0.71 64642857
+ 0.00 0.21 0.71 71714286
+ 0.00 0.21 0.71 78785714
+ 0.00 0.21 0.71 85857143
+ 0.00 0.21 0.71 92928571
+ 0.00 0.21 0.71 100000000
+ 0.00 0.21 0.79 1000000
+ 0.00 0.21 0.79 8071429
+ 0.00 0.21 0.79 15142857
+ 0.00 0.21 0.79 22214286
+ 0.00 0.21 0.79 29285714
+ 0.00 0.21 0.79 36357143
+ 0.00 0.21 0.79 43428571
+ 0.00 0.21 0.79 50500000
+ 0.00 0.21 0.79 57571429
+ 0.00 0.21 0.79 64642857
+ 0.00 0.21 0.79 71714286
+ 0.00 0.21 0.79 78785714
+ 0.00 0.21 0.79 85857143
+ 0.00 0.21 0.79 92928571
+ 0.00 0.21 0.79 100000000
+ 0.00 0.21 0.86 1000000
+ 0.00 0.21 0.86 8071429
+ 0.00 0.21 0.86 15142857
+ 0.00 0.21 0.86 22214286
+ 0.00 0.21 0.86 29285714
+ 0.00 0.21 0.86 36357143
+ 0.00 0.21 0.86 43428571
+ 0.00 0.21 0.86 50500000
+ 0.00 0.21 0.86 57571429
+ 0.00 0.21 0.86 64642857
+ 0.00 0.21 0.86 71714286
+ 0.00 0.21 0.86 78785714
+ 0.00 0.21 0.86 85857143
+ 0.00 0.21 0.86 92928571
+ 0.00 0.21 0.86 100000000
+ 0.00 0.21 0.93 1000000
+ 0.00 0.21 0.93 8071429
+ 0.00 0.21 0.93 15142857
+ 0.00 0.21 0.93 22214286
+ 0.00 0.21 0.93 29285714
+ 0.00 0.21 0.93 36357143
+ 0.00 0.21 0.93 43428571
+ 0.00 0.21 0.93 50500000
+ 0.00 0.21 0.93 57571429
+ 0.00 0.21 0.93 64642857
+ 0.00 0.21 0.93 71714286
+ 0.00 0.21 0.93 78785714
+ 0.00 0.21 0.93 85857143
+ 0.00 0.21 0.93 92928571
+ 0.00 0.21 0.93 100000000
+ 0.00 0.21 1.00 1000000
+ 0.00 0.21 1.00 8071429
+ 0.00 0.21 1.00 15142857
+ 0.00 0.21 1.00 22214286
+ 0.00 0.21 1.00 29285714
+ 0.00 0.21 1.00 36357143
+ 0.00 0.21 1.00 43428571
+ 0.00 0.21 1.00 50500000
+ 0.00 0.21 1.00 57571429
+ 0.00 0.21 1.00 64642857
+ 0.00 0.21 1.00 71714286
+ 0.00 0.21 1.00 78785714
+ 0.00 0.21 1.00 85857143
+ 0.00 0.21 1.00 92928571
+ 0.00 0.21 1.00 100000000
+ 0.00 0.29 0.00 1000000
+ 0.00 0.29 0.00 8071429
+ 0.00 0.29 0.00 15142857
+ 0.00 0.29 0.00 22214286
+ 0.00 0.29 0.00 29285714
+ 0.00 0.29 0.00 36357143
+ 0.00 0.29 0.00 43428571
+ 0.00 0.29 0.00 50500000
+ 0.00 0.29 0.00 57571429
+ 0.00 0.29 0.00 64642857
+ 0.00 0.29 0.00 71714286
+ 0.00 0.29 0.00 78785714
+ 0.00 0.29 0.00 85857143
+ 0.00 0.29 0.00 92928571
+ 0.00 0.29 0.00 100000000
+ 0.00 0.29 0.07 1000000
+ 0.00 0.29 0.07 8071429
+ 0.00 0.29 0.07 15142857
+ 0.00 0.29 0.07 22214286
+ 0.00 0.29 0.07 29285714
+ 0.00 0.29 0.07 36357143
+ 0.00 0.29 0.07 43428571
+ 0.00 0.29 0.07 50500000
+ 0.00 0.29 0.07 57571429
+ 0.00 0.29 0.07 64642857
+ 0.00 0.29 0.07 71714286
+ 0.00 0.29 0.07 78785714
+ 0.00 0.29 0.07 85857143
+ 0.00 0.29 0.07 92928571
+ 0.00 0.29 0.07 100000000
+ 0.00 0.29 0.14 1000000
+ 0.00 0.29 0.14 8071429
+ 0.00 0.29 0.14 15142857
+ 0.00 0.29 0.14 22214286
+ 0.00 0.29 0.14 29285714
+ 0.00 0.29 0.14 36357143
+ 0.00 0.29 0.14 43428571
+ 0.00 0.29 0.14 50500000
+ 0.00 0.29 0.14 57571429
+ 0.00 0.29 0.14 64642857
+ 0.00 0.29 0.14 71714286
+ 0.00 0.29 0.14 78785714
+ 0.00 0.29 0.14 85857143
+ 0.00 0.29 0.14 92928571
+ 0.00 0.29 0.14 100000000
+ 0.00 0.29 0.21 1000000
+ 0.00 0.29 0.21 8071429
+ 0.00 0.29 0.21 15142857
+ 0.00 0.29 0.21 22214286
+ 0.00 0.29 0.21 29285714
+ 0.00 0.29 0.21 36357143
+ 0.00 0.29 0.21 43428571
+ 0.00 0.29 0.21 50500000
+ 0.00 0.29 0.21 57571429
+ 0.00 0.29 0.21 64642857
+ 0.00 0.29 0.21 71714286
+ 0.00 0.29 0.21 78785714
+ 0.00 0.29 0.21 85857143
+ 0.00 0.29 0.21 92928571
+ 0.00 0.29 0.21 100000000
+ 0.00 0.29 0.29 1000000
+ 0.00 0.29 0.29 8071429
+ 0.00 0.29 0.29 15142857
+ 0.00 0.29 0.29 22214286
+ 0.00 0.29 0.29 29285714
+ 0.00 0.29 0.29 36357143
+ 0.00 0.29 0.29 43428571
+ 0.00 0.29 0.29 50500000
+ 0.00 0.29 0.29 57571429
+ 0.00 0.29 0.29 64642857
+ 0.00 0.29 0.29 71714286
+ 0.00 0.29 0.29 78785714
+ 0.00 0.29 0.29 85857143
+ 0.00 0.29 0.29 92928571
+ 0.00 0.29 0.29 100000000
+ 0.00 0.29 0.36 1000000
+ 0.00 0.29 0.36 8071429
+ 0.00 0.29 0.36 15142857
+ 0.00 0.29 0.36 22214286
+ 0.00 0.29 0.36 29285714
+ 0.00 0.29 0.36 36357143
+ 0.00 0.29 0.36 43428571
+ 0.00 0.29 0.36 50500000
+ 0.00 0.29 0.36 57571429
+ 0.00 0.29 0.36 64642857
+ 0.00 0.29 0.36 71714286
+ 0.00 0.29 0.36 78785714
+ 0.00 0.29 0.36 85857143
+ 0.00 0.29 0.36 92928571
+ 0.00 0.29 0.36 100000000
+ 0.00 0.29 0.43 1000000
+ 0.00 0.29 0.43 8071429
+ 0.00 0.29 0.43 15142857
+ 0.00 0.29 0.43 22214286
+ 0.00 0.29 0.43 29285714
+ 0.00 0.29 0.43 36357143
+ 0.00 0.29 0.43 43428571
+ 0.00 0.29 0.43 50500000
+ 0.00 0.29 0.43 57571429
+ 0.00 0.29 0.43 64642857
+ 0.00 0.29 0.43 71714286
+ 0.00 0.29 0.43 78785714
+ 0.00 0.29 0.43 85857143
+ 0.00 0.29 0.43 92928571
+ 0.00 0.29 0.43 100000000
+ 0.00 0.29 0.50 1000000
+ 0.00 0.29 0.50 8071429
+ 0.00 0.29 0.50 15142857
+ 0.00 0.29 0.50 22214286
+ 0.00 0.29 0.50 29285714
+ 0.00 0.29 0.50 36357143
+ 0.00 0.29 0.50 43428571
+ 0.00 0.29 0.50 50500000
+ 0.00 0.29 0.50 57571429
+ 0.00 0.29 0.50 64642857
+ 0.00 0.29 0.50 71714286
+ 0.00 0.29 0.50 78785714
+ 0.00 0.29 0.50 85857143
+ 0.00 0.29 0.50 92928571
+ 0.00 0.29 0.50 100000000
+ 0.00 0.29 0.57 1000000
+ 0.00 0.29 0.57 8071429
+ 0.00 0.29 0.57 15142857
+ 0.00 0.29 0.57 22214286
+ 0.00 0.29 0.57 29285714
+ 0.00 0.29 0.57 36357143
+ 0.00 0.29 0.57 43428571
+ 0.00 0.29 0.57 50500000
+ 0.00 0.29 0.57 57571429
+ 0.00 0.29 0.57 64642857
+ 0.00 0.29 0.57 71714286
+ 0.00 0.29 0.57 78785714
+ 0.00 0.29 0.57 85857143
+ 0.00 0.29 0.57 92928571
+ 0.00 0.29 0.57 100000000
+ 0.00 0.29 0.64 1000000
+ 0.00 0.29 0.64 8071429
+ 0.00 0.29 0.64 15142857
+ 0.00 0.29 0.64 22214286
+ 0.00 0.29 0.64 29285714
+ 0.00 0.29 0.64 36357143
+ 0.00 0.29 0.64 43428571
+ 0.00 0.29 0.64 50500000
+ 0.00 0.29 0.64 57571429
+ 0.00 0.29 0.64 64642857
+ 0.00 0.29 0.64 71714286
+ 0.00 0.29 0.64 78785714
+ 0.00 0.29 0.64 85857143
+ 0.00 0.29 0.64 92928571
+ 0.00 0.29 0.64 100000000
+ 0.00 0.29 0.71 1000000
+ 0.00 0.29 0.71 8071429
+ 0.00 0.29 0.71 15142857
+ 0.00 0.29 0.71 22214286
+ 0.00 0.29 0.71 29285714
+ 0.00 0.29 0.71 36357143
+ 0.00 0.29 0.71 43428571
+ 0.00 0.29 0.71 50500000
+ 0.00 0.29 0.71 57571429
+ 0.00 0.29 0.71 64642857
+ 0.00 0.29 0.71 71714286
+ 0.00 0.29 0.71 78785714
+ 0.00 0.29 0.71 85857143
+ 0.00 0.29 0.71 92928571
+ 0.00 0.29 0.71 100000000
+ 0.00 0.29 0.79 1000000
+ 0.00 0.29 0.79 8071429
+ 0.00 0.29 0.79 15142857
+ 0.00 0.29 0.79 22214286
+ 0.00 0.29 0.79 29285714
+ 0.00 0.29 0.79 36357143
+ 0.00 0.29 0.79 43428571
+ 0.00 0.29 0.79 50500000
+ 0.00 0.29 0.79 57571429
+ 0.00 0.29 0.79 64642857
+ 0.00 0.29 0.79 71714286
+ 0.00 0.29 0.79 78785714
+ 0.00 0.29 0.79 85857143
+ 0.00 0.29 0.79 92928571
+ 0.00 0.29 0.79 100000000
+ 0.00 0.29 0.86 1000000
+ 0.00 0.29 0.86 8071429
+ 0.00 0.29 0.86 15142857
+ 0.00 0.29 0.86 22214286
+ 0.00 0.29 0.86 29285714
+ 0.00 0.29 0.86 36357143
+ 0.00 0.29 0.86 43428571
+ 0.00 0.29 0.86 50500000
+ 0.00 0.29 0.86 57571429
+ 0.00 0.29 0.86 64642857
+ 0.00 0.29 0.86 71714286
+ 0.00 0.29 0.86 78785714
+ 0.00 0.29 0.86 85857143
+ 0.00 0.29 0.86 92928571
+ 0.00 0.29 0.86 100000000
+ 0.00 0.29 0.93 1000000
+ 0.00 0.29 0.93 8071429
+ 0.00 0.29 0.93 15142857
+ 0.00 0.29 0.93 22214286
+ 0.00 0.29 0.93 29285714
+ 0.00 0.29 0.93 36357143
+ 0.00 0.29 0.93 43428571
+ 0.00 0.29 0.93 50500000
+ 0.00 0.29 0.93 57571429
+ 0.00 0.29 0.93 64642857
+ 0.00 0.29 0.93 71714286
+ 0.00 0.29 0.93 78785714
+ 0.00 0.29 0.93 85857143
+ 0.00 0.29 0.93 92928571
+ 0.00 0.29 0.93 100000000
+ 0.00 0.29 1.00 1000000
+ 0.00 0.29 1.00 8071429
+ 0.00 0.29 1.00 15142857
+ 0.00 0.29 1.00 22214286
+ 0.00 0.29 1.00 29285714
+ 0.00 0.29 1.00 36357143
+ 0.00 0.29 1.00 43428571
+ 0.00 0.29 1.00 50500000
+ 0.00 0.29 1.00 57571429
+ 0.00 0.29 1.00 64642857
+ 0.00 0.29 1.00 71714286
+ 0.00 0.29 1.00 78785714
+ 0.00 0.29 1.00 85857143
+ 0.00 0.29 1.00 92928571
+ 0.00 0.29 1.00 100000000
+ 0.00 0.36 0.00 1000000
+ 0.00 0.36 0.00 8071429
+ 0.00 0.36 0.00 15142857
+ 0.00 0.36 0.00 22214286
+ 0.00 0.36 0.00 29285714
+ 0.00 0.36 0.00 36357143
+ 0.00 0.36 0.00 43428571
+ 0.00 0.36 0.00 50500000
+ 0.00 0.36 0.00 57571429
+ 0.00 0.36 0.00 64642857
+ 0.00 0.36 0.00 71714286
+ 0.00 0.36 0.00 78785714
+ 0.00 0.36 0.00 85857143
+ 0.00 0.36 0.00 92928571
+ 0.00 0.36 0.00 100000000
+ 0.00 0.36 0.07 1000000
+ 0.00 0.36 0.07 8071429
+ 0.00 0.36 0.07 15142857
+ 0.00 0.36 0.07 22214286
+ 0.00 0.36 0.07 29285714
+ 0.00 0.36 0.07 36357143
+ 0.00 0.36 0.07 43428571
+ 0.00 0.36 0.07 50500000
+ 0.00 0.36 0.07 57571429
+ 0.00 0.36 0.07 64642857
+ 0.00 0.36 0.07 71714286
+ 0.00 0.36 0.07 78785714
+ 0.00 0.36 0.07 85857143
+ 0.00 0.36 0.07 92928571
+ 0.00 0.36 0.07 100000000
+ 0.00 0.36 0.14 1000000
+ 0.00 0.36 0.14 8071429
+ 0.00 0.36 0.14 15142857
+ 0.00 0.36 0.14 22214286
+ 0.00 0.36 0.14 29285714
+ 0.00 0.36 0.14 36357143
+ 0.00 0.36 0.14 43428571
+ 0.00 0.36 0.14 50500000
+ 0.00 0.36 0.14 57571429
+ 0.00 0.36 0.14 64642857
+ 0.00 0.36 0.14 71714286
+ 0.00 0.36 0.14 78785714
+ 0.00 0.36 0.14 85857143
+ 0.00 0.36 0.14 92928571
+ 0.00 0.36 0.14 100000000
+ 0.00 0.36 0.21 1000000
+ 0.00 0.36 0.21 8071429
+ 0.00 0.36 0.21 15142857
+ 0.00 0.36 0.21 22214286
+ 0.00 0.36 0.21 29285714
+ 0.00 0.36 0.21 36357143
+ 0.00 0.36 0.21 43428571
+ 0.00 0.36 0.21 50500000
+ 0.00 0.36 0.21 57571429
+ 0.00 0.36 0.21 64642857
+ 0.00 0.36 0.21 71714286
+ 0.00 0.36 0.21 78785714
+ 0.00 0.36 0.21 85857143
+ 0.00 0.36 0.21 92928571
+ 0.00 0.36 0.21 100000000
+ 0.00 0.36 0.29 1000000
+ 0.00 0.36 0.29 8071429
+ 0.00 0.36 0.29 15142857
+ 0.00 0.36 0.29 22214286
+ 0.00 0.36 0.29 29285714
+ 0.00 0.36 0.29 36357143
+ 0.00 0.36 0.29 43428571
+ 0.00 0.36 0.29 50500000
+ 0.00 0.36 0.29 57571429
+ 0.00 0.36 0.29 64642857
+ 0.00 0.36 0.29 71714286
+ 0.00 0.36 0.29 78785714
+ 0.00 0.36 0.29 85857143
+ 0.00 0.36 0.29 92928571
+ 0.00 0.36 0.29 100000000
+ 0.00 0.36 0.36 1000000
+ 0.00 0.36 0.36 8071429
+ 0.00 0.36 0.36 15142857
+ 0.00 0.36 0.36 22214286
+ 0.00 0.36 0.36 29285714
+ 0.00 0.36 0.36 36357143
+ 0.00 0.36 0.36 43428571
+ 0.00 0.36 0.36 50500000
+ 0.00 0.36 0.36 57571429
+ 0.00 0.36 0.36 64642857
+ 0.00 0.36 0.36 71714286
+ 0.00 0.36 0.36 78785714
+ 0.00 0.36 0.36 85857143
+ 0.00 0.36 0.36 92928571
+ 0.00 0.36 0.36 100000000
+ 0.00 0.36 0.43 1000000
+ 0.00 0.36 0.43 8071429
+ 0.00 0.36 0.43 15142857
+ 0.00 0.36 0.43 22214286
+ 0.00 0.36 0.43 29285714
+ 0.00 0.36 0.43 36357143
+ 0.00 0.36 0.43 43428571
+ 0.00 0.36 0.43 50500000
+ 0.00 0.36 0.43 57571429
+ 0.00 0.36 0.43 64642857
+ 0.00 0.36 0.43 71714286
+ 0.00 0.36 0.43 78785714
+ 0.00 0.36 0.43 85857143
+ 0.00 0.36 0.43 92928571
+ 0.00 0.36 0.43 100000000
+ 0.00 0.36 0.50 1000000
+ 0.00 0.36 0.50 8071429
+ 0.00 0.36 0.50 15142857
+ 0.00 0.36 0.50 22214286
+ 0.00 0.36 0.50 29285714
+ 0.00 0.36 0.50 36357143
+ 0.00 0.36 0.50 43428571
+ 0.00 0.36 0.50 50500000
+ 0.00 0.36 0.50 57571429
+ 0.00 0.36 0.50 64642857
+ 0.00 0.36 0.50 71714286
+ 0.00 0.36 0.50 78785714
+ 0.00 0.36 0.50 85857143
+ 0.00 0.36 0.50 92928571
+ 0.00 0.36 0.50 100000000
+ 0.00 0.36 0.57 1000000
+ 0.00 0.36 0.57 8071429
+ 0.00 0.36 0.57 15142857
+ 0.00 0.36 0.57 22214286
+ 0.00 0.36 0.57 29285714
+ 0.00 0.36 0.57 36357143
+ 0.00 0.36 0.57 43428571
+ 0.00 0.36 0.57 50500000
+ 0.00 0.36 0.57 57571429
+ 0.00 0.36 0.57 64642857
+ 0.00 0.36 0.57 71714286
+ 0.00 0.36 0.57 78785714
+ 0.00 0.36 0.57 85857143
+ 0.00 0.36 0.57 92928571
+ 0.00 0.36 0.57 100000000
+ 0.00 0.36 0.64 1000000
+ 0.00 0.36 0.64 8071429
+ 0.00 0.36 0.64 15142857
+ 0.00 0.36 0.64 22214286
+ 0.00 0.36 0.64 29285714
+ 0.00 0.36 0.64 36357143
+ 0.00 0.36 0.64 43428571
+ 0.00 0.36 0.64 50500000
+ 0.00 0.36 0.64 57571429
+ 0.00 0.36 0.64 64642857
+ 0.00 0.36 0.64 71714286
+ 0.00 0.36 0.64 78785714
+ 0.00 0.36 0.64 85857143
+ 0.00 0.36 0.64 92928571
+ 0.00 0.36 0.64 100000000
+ 0.00 0.36 0.71 1000000
+ 0.00 0.36 0.71 8071429
+ 0.00 0.36 0.71 15142857
+ 0.00 0.36 0.71 22214286
+ 0.00 0.36 0.71 29285714
+ 0.00 0.36 0.71 36357143
+ 0.00 0.36 0.71 43428571
+ 0.00 0.36 0.71 50500000
+ 0.00 0.36 0.71 57571429
+ 0.00 0.36 0.71 64642857
+ 0.00 0.36 0.71 71714286
+ 0.00 0.36 0.71 78785714
+ 0.00 0.36 0.71 85857143
+ 0.00 0.36 0.71 92928571
+ 0.00 0.36 0.71 100000000
+ 0.00 0.36 0.79 1000000
+ 0.00 0.36 0.79 8071429
+ 0.00 0.36 0.79 15142857
+ 0.00 0.36 0.79 22214286
+ 0.00 0.36 0.79 29285714
+ 0.00 0.36 0.79 36357143
+ 0.00 0.36 0.79 43428571
+ 0.00 0.36 0.79 50500000
+ 0.00 0.36 0.79 57571429
+ 0.00 0.36 0.79 64642857
+ 0.00 0.36 0.79 71714286
+ 0.00 0.36 0.79 78785714
+ 0.00 0.36 0.79 85857143
+ 0.00 0.36 0.79 92928571
+ 0.00 0.36 0.79 100000000
+ 0.00 0.36 0.86 1000000
+ 0.00 0.36 0.86 8071429
+ 0.00 0.36 0.86 15142857
+ 0.00 0.36 0.86 22214286
+ 0.00 0.36 0.86 29285714
+ 0.00 0.36 0.86 36357143
+ 0.00 0.36 0.86 43428571
+ 0.00 0.36 0.86 50500000
+ 0.00 0.36 0.86 57571429
+ 0.00 0.36 0.86 64642857
+ 0.00 0.36 0.86 71714286
+ 0.00 0.36 0.86 78785714
+ 0.00 0.36 0.86 85857143
+ 0.00 0.36 0.86 92928571
+ 0.00 0.36 0.86 100000000
+ 0.00 0.36 0.93 1000000
+ 0.00 0.36 0.93 8071429
+ 0.00 0.36 0.93 15142857
+ 0.00 0.36 0.93 22214286
+ 0.00 0.36 0.93 29285714
+ 0.00 0.36 0.93 36357143
+ 0.00 0.36 0.93 43428571
+ 0.00 0.36 0.93 50500000
+ 0.00 0.36 0.93 57571429
+ 0.00 0.36 0.93 64642857
+ 0.00 0.36 0.93 71714286
+ 0.00 0.36 0.93 78785714
+ 0.00 0.36 0.93 85857143
+ 0.00 0.36 0.93 92928571
+ 0.00 0.36 0.93 100000000
+ 0.00 0.36 1.00 1000000
+ 0.00 0.36 1.00 8071429
+ 0.00 0.36 1.00 15142857
+ 0.00 0.36 1.00 22214286
+ 0.00 0.36 1.00 29285714
+ 0.00 0.36 1.00 36357143
+ 0.00 0.36 1.00 43428571
+ 0.00 0.36 1.00 50500000
+ 0.00 0.36 1.00 57571429
+ 0.00 0.36 1.00 64642857
+ 0.00 0.36 1.00 71714286
+ 0.00 0.36 1.00 78785714
+ 0.00 0.36 1.00 85857143
+ 0.00 0.36 1.00 92928571
+ 0.00 0.36 1.00 100000000
+ 0.00 0.43 0.00 1000000
+ 0.00 0.43 0.00 8071429
+ 0.00 0.43 0.00 15142857
+ 0.00 0.43 0.00 22214286
+ 0.00 0.43 0.00 29285714
+ 0.00 0.43 0.00 36357143
+ 0.00 0.43 0.00 43428571
+ 0.00 0.43 0.00 50500000
+ 0.00 0.43 0.00 57571429
+ 0.00 0.43 0.00 64642857
+ 0.00 0.43 0.00 71714286
+ 0.00 0.43 0.00 78785714
+ 0.00 0.43 0.00 85857143
+ 0.00 0.43 0.00 92928571
+ 0.00 0.43 0.00 100000000
+ 0.00 0.43 0.07 1000000
+ 0.00 0.43 0.07 8071429
+ 0.00 0.43 0.07 15142857
+ 0.00 0.43 0.07 22214286
+ 0.00 0.43 0.07 29285714
+ 0.00 0.43 0.07 36357143
+ 0.00 0.43 0.07 43428571
+ 0.00 0.43 0.07 50500000
+ 0.00 0.43 0.07 57571429
+ 0.00 0.43 0.07 64642857
+ 0.00 0.43 0.07 71714286
+ 0.00 0.43 0.07 78785714
+ 0.00 0.43 0.07 85857143
+ 0.00 0.43 0.07 92928571
+ 0.00 0.43 0.07 100000000
+ 0.00 0.43 0.14 1000000
+ 0.00 0.43 0.14 8071429
+ 0.00 0.43 0.14 15142857
+ 0.00 0.43 0.14 22214286
+ 0.00 0.43 0.14 29285714
+ 0.00 0.43 0.14 36357143
+ 0.00 0.43 0.14 43428571
+ 0.00 0.43 0.14 50500000
+ 0.00 0.43 0.14 57571429
+ 0.00 0.43 0.14 64642857
+ 0.00 0.43 0.14 71714286
+ 0.00 0.43 0.14 78785714
+ 0.00 0.43 0.14 85857143
+ 0.00 0.43 0.14 92928571
+ 0.00 0.43 0.14 100000000
+ 0.00 0.43 0.21 1000000
+ 0.00 0.43 0.21 8071429
+ 0.00 0.43 0.21 15142857
+ 0.00 0.43 0.21 22214286
+ 0.00 0.43 0.21 29285714
+ 0.00 0.43 0.21 36357143
+ 0.00 0.43 0.21 43428571
+ 0.00 0.43 0.21 50500000
+ 0.00 0.43 0.21 57571429
+ 0.00 0.43 0.21 64642857
+ 0.00 0.43 0.21 71714286
+ 0.00 0.43 0.21 78785714
+ 0.00 0.43 0.21 85857143
+ 0.00 0.43 0.21 92928571
+ 0.00 0.43 0.21 100000000
+ 0.00 0.43 0.29 1000000
+ 0.00 0.43 0.29 8071429
+ 0.00 0.43 0.29 15142857
+ 0.00 0.43 0.29 22214286
+ 0.00 0.43 0.29 29285714
+ 0.00 0.43 0.29 36357143
+ 0.00 0.43 0.29 43428571
+ 0.00 0.43 0.29 50500000
+ 0.00 0.43 0.29 57571429
+ 0.00 0.43 0.29 64642857
+ 0.00 0.43 0.29 71714286
+ 0.00 0.43 0.29 78785714
+ 0.00 0.43 0.29 85857143
+ 0.00 0.43 0.29 92928571
+ 0.00 0.43 0.29 100000000
+ 0.00 0.43 0.36 1000000
+ 0.00 0.43 0.36 8071429
+ 0.00 0.43 0.36 15142857
+ 0.00 0.43 0.36 22214286
+ 0.00 0.43 0.36 29285714
+ 0.00 0.43 0.36 36357143
+ 0.00 0.43 0.36 43428571
+ 0.00 0.43 0.36 50500000
+ 0.00 0.43 0.36 57571429
+ 0.00 0.43 0.36 64642857
+ 0.00 0.43 0.36 71714286
+ 0.00 0.43 0.36 78785714
+ 0.00 0.43 0.36 85857143
+ 0.00 0.43 0.36 92928571
+ 0.00 0.43 0.36 100000000
+ 0.00 0.43 0.43 1000000
+ 0.00 0.43 0.43 8071429
+ 0.00 0.43 0.43 15142857
+ 0.00 0.43 0.43 22214286
+ 0.00 0.43 0.43 29285714
+ 0.00 0.43 0.43 36357143
+ 0.00 0.43 0.43 43428571
+ 0.00 0.43 0.43 50500000
+ 0.00 0.43 0.43 57571429
+ 0.00 0.43 0.43 64642857
+ 0.00 0.43 0.43 71714286
+ 0.00 0.43 0.43 78785714
+ 0.00 0.43 0.43 85857143
+ 0.00 0.43 0.43 92928571
+ 0.00 0.43 0.43 100000000
+ 0.00 0.43 0.50 1000000
+ 0.00 0.43 0.50 8071429
+ 0.00 0.43 0.50 15142857
+ 0.00 0.43 0.50 22214286
+ 0.00 0.43 0.50 29285714
+ 0.00 0.43 0.50 36357143
+ 0.00 0.43 0.50 43428571
+ 0.00 0.43 0.50 50500000
+ 0.00 0.43 0.50 57571429
+ 0.00 0.43 0.50 64642857
+ 0.00 0.43 0.50 71714286
+ 0.00 0.43 0.50 78785714
+ 0.00 0.43 0.50 85857143
+ 0.00 0.43 0.50 92928571
+ 0.00 0.43 0.50 100000000
+ 0.00 0.43 0.57 1000000
+ 0.00 0.43 0.57 8071429
+ 0.00 0.43 0.57 15142857
+ 0.00 0.43 0.57 22214286
+ 0.00 0.43 0.57 29285714
+ 0.00 0.43 0.57 36357143
+ 0.00 0.43 0.57 43428571
+ 0.00 0.43 0.57 50500000
+ 0.00 0.43 0.57 57571429
+ 0.00 0.43 0.57 64642857
+ 0.00 0.43 0.57 71714286
+ 0.00 0.43 0.57 78785714
+ 0.00 0.43 0.57 85857143
+ 0.00 0.43 0.57 92928571
+ 0.00 0.43 0.57 100000000
+ 0.00 0.43 0.64 1000000
+ 0.00 0.43 0.64 8071429
+ 0.00 0.43 0.64 15142857
+ 0.00 0.43 0.64 22214286
+ 0.00 0.43 0.64 29285714
+ 0.00 0.43 0.64 36357143
+ 0.00 0.43 0.64 43428571
+ 0.00 0.43 0.64 50500000
+ 0.00 0.43 0.64 57571429
+ 0.00 0.43 0.64 64642857
+ 0.00 0.43 0.64 71714286
+ 0.00 0.43 0.64 78785714
+ 0.00 0.43 0.64 85857143
+ 0.00 0.43 0.64 92928571
+ 0.00 0.43 0.64 100000000
+ 0.00 0.43 0.71 1000000
+ 0.00 0.43 0.71 8071429
+ 0.00 0.43 0.71 15142857
+ 0.00 0.43 0.71 22214286
+ 0.00 0.43 0.71 29285714
+ 0.00 0.43 0.71 36357143
+ 0.00 0.43 0.71 43428571
+ 0.00 0.43 0.71 50500000
+ 0.00 0.43 0.71 57571429
+ 0.00 0.43 0.71 64642857
+ 0.00 0.43 0.71 71714286
+ 0.00 0.43 0.71 78785714
+ 0.00 0.43 0.71 85857143
+ 0.00 0.43 0.71 92928571
+ 0.00 0.43 0.71 100000000
+ 0.00 0.43 0.79 1000000
+ 0.00 0.43 0.79 8071429
+ 0.00 0.43 0.79 15142857
+ 0.00 0.43 0.79 22214286
+ 0.00 0.43 0.79 29285714
+ 0.00 0.43 0.79 36357143
+ 0.00 0.43 0.79 43428571
+ 0.00 0.43 0.79 50500000
+ 0.00 0.43 0.79 57571429
+ 0.00 0.43 0.79 64642857
+ 0.00 0.43 0.79 71714286
+ 0.00 0.43 0.79 78785714
+ 0.00 0.43 0.79 85857143
+ 0.00 0.43 0.79 92928571
+ 0.00 0.43 0.79 100000000
+ 0.00 0.43 0.86 1000000
+ 0.00 0.43 0.86 8071429
+ 0.00 0.43 0.86 15142857
+ 0.00 0.43 0.86 22214286
+ 0.00 0.43 0.86 29285714
+ 0.00 0.43 0.86 36357143
+ 0.00 0.43 0.86 43428571
+ 0.00 0.43 0.86 50500000
+ 0.00 0.43 0.86 57571429
+ 0.00 0.43 0.86 64642857
+ 0.00 0.43 0.86 71714286
+ 0.00 0.43 0.86 78785714
+ 0.00 0.43 0.86 85857143
+ 0.00 0.43 0.86 92928571
+ 0.00 0.43 0.86 100000000
+ 0.00 0.43 0.93 1000000
+ 0.00 0.43 0.93 8071429
+ 0.00 0.43 0.93 15142857
+ 0.00 0.43 0.93 22214286
+ 0.00 0.43 0.93 29285714
+ 0.00 0.43 0.93 36357143
+ 0.00 0.43 0.93 43428571
+ 0.00 0.43 0.93 50500000
+ 0.00 0.43 0.93 57571429
+ 0.00 0.43 0.93 64642857
+ 0.00 0.43 0.93 71714286
+ 0.00 0.43 0.93 78785714
+ 0.00 0.43 0.93 85857143
+ 0.00 0.43 0.93 92928571
+ 0.00 0.43 0.93 100000000
+ 0.00 0.43 1.00 1000000
+ 0.00 0.43 1.00 8071429
+ 0.00 0.43 1.00 15142857
+ 0.00 0.43 1.00 22214286
+ 0.00 0.43 1.00 29285714
+ 0.00 0.43 1.00 36357143
+ 0.00 0.43 1.00 43428571
+ 0.00 0.43 1.00 50500000
+ 0.00 0.43 1.00 57571429
+ 0.00 0.43 1.00 64642857
+ 0.00 0.43 1.00 71714286
+ 0.00 0.43 1.00 78785714
+ 0.00 0.43 1.00 85857143
+ 0.00 0.43 1.00 92928571
+ 0.00 0.43 1.00 100000000
+ 0.00 0.50 0.00 1000000
+ 0.00 0.50 0.00 8071429
+ 0.00 0.50 0.00 15142857
+ 0.00 0.50 0.00 22214286
+ 0.00 0.50 0.00 29285714
+ 0.00 0.50 0.00 36357143
+ 0.00 0.50 0.00 43428571
+ 0.00 0.50 0.00 50500000
+ 0.00 0.50 0.00 57571429
+ 0.00 0.50 0.00 64642857
+ 0.00 0.50 0.00 71714286
+ 0.00 0.50 0.00 78785714
+ 0.00 0.50 0.00 85857143
+ 0.00 0.50 0.00 92928571
+ 0.00 0.50 0.00 100000000
+ 0.00 0.50 0.07 1000000
+ 0.00 0.50 0.07 8071429
+ 0.00 0.50 0.07 15142857
+ 0.00 0.50 0.07 22214286
+ 0.00 0.50 0.07 29285714
+ 0.00 0.50 0.07 36357143
+ 0.00 0.50 0.07 43428571
+ 0.00 0.50 0.07 50500000
+ 0.00 0.50 0.07 57571429
+ 0.00 0.50 0.07 64642857
+ 0.00 0.50 0.07 71714286
+ 0.00 0.50 0.07 78785714
+ 0.00 0.50 0.07 85857143
+ 0.00 0.50 0.07 92928571
+ 0.00 0.50 0.07 100000000
+ 0.00 0.50 0.14 1000000
+ 0.00 0.50 0.14 8071429
+ 0.00 0.50 0.14 15142857
+ 0.00 0.50 0.14 22214286
+ 0.00 0.50 0.14 29285714
+ 0.00 0.50 0.14 36357143
+ 0.00 0.50 0.14 43428571
+ 0.00 0.50 0.14 50500000
+ 0.00 0.50 0.14 57571429
+ 0.00 0.50 0.14 64642857
+ 0.00 0.50 0.14 71714286
+ 0.00 0.50 0.14 78785714
+ 0.00 0.50 0.14 85857143
+ 0.00 0.50 0.14 92928571
+ 0.00 0.50 0.14 100000000
+ 0.00 0.50 0.21 1000000
+ 0.00 0.50 0.21 8071429
+ 0.00 0.50 0.21 15142857
+ 0.00 0.50 0.21 22214286
+ 0.00 0.50 0.21 29285714
+ 0.00 0.50 0.21 36357143
+ 0.00 0.50 0.21 43428571
+ 0.00 0.50 0.21 50500000
+ 0.00 0.50 0.21 57571429
+ 0.00 0.50 0.21 64642857
+ 0.00 0.50 0.21 71714286
+ 0.00 0.50 0.21 78785714
+ 0.00 0.50 0.21 85857143
+ 0.00 0.50 0.21 92928571
+ 0.00 0.50 0.21 100000000
+ 0.00 0.50 0.29 1000000
+ 0.00 0.50 0.29 8071429
+ 0.00 0.50 0.29 15142857
+ 0.00 0.50 0.29 22214286
+ 0.00 0.50 0.29 29285714
+ 0.00 0.50 0.29 36357143
+ 0.00 0.50 0.29 43428571
+ 0.00 0.50 0.29 50500000
+ 0.00 0.50 0.29 57571429
+ 0.00 0.50 0.29 64642857
+ 0.00 0.50 0.29 71714286
+ 0.00 0.50 0.29 78785714
+ 0.00 0.50 0.29 85857143
+ 0.00 0.50 0.29 92928571
+ 0.00 0.50 0.29 100000000
+ 0.00 0.50 0.36 1000000
+ 0.00 0.50 0.36 8071429
+ 0.00 0.50 0.36 15142857
+ 0.00 0.50 0.36 22214286
+ 0.00 0.50 0.36 29285714
+ 0.00 0.50 0.36 36357143
+ 0.00 0.50 0.36 43428571
+ 0.00 0.50 0.36 50500000
+ 0.00 0.50 0.36 57571429
+ 0.00 0.50 0.36 64642857
+ 0.00 0.50 0.36 71714286
+ 0.00 0.50 0.36 78785714
+ 0.00 0.50 0.36 85857143
+ 0.00 0.50 0.36 92928571
+ 0.00 0.50 0.36 100000000
+ 0.00 0.50 0.43 1000000
+ 0.00 0.50 0.43 8071429
+ 0.00 0.50 0.43 15142857
+ 0.00 0.50 0.43 22214286
+ 0.00 0.50 0.43 29285714
+ 0.00 0.50 0.43 36357143
+ 0.00 0.50 0.43 43428571
+ 0.00 0.50 0.43 50500000
+ 0.00 0.50 0.43 57571429
+ 0.00 0.50 0.43 64642857
+ 0.00 0.50 0.43 71714286
+ 0.00 0.50 0.43 78785714
+ 0.00 0.50 0.43 85857143
+ 0.00 0.50 0.43 92928571
+ 0.00 0.50 0.43 100000000
+ 0.00 0.50 0.50 1000000
+ 0.00 0.50 0.50 8071429
+ 0.00 0.50 0.50 15142857
+ 0.00 0.50 0.50 22214286
+ 0.00 0.50 0.50 29285714
+ 0.00 0.50 0.50 36357143
+ 0.00 0.50 0.50 43428571
+ 0.00 0.50 0.50 50500000
+ 0.00 0.50 0.50 57571429
+ 0.00 0.50 0.50 64642857
+ 0.00 0.50 0.50 71714286
+ 0.00 0.50 0.50 78785714
+ 0.00 0.50 0.50 85857143
+ 0.00 0.50 0.50 92928571
+ 0.00 0.50 0.50 100000000
+ 0.00 0.50 0.57 1000000
+ 0.00 0.50 0.57 8071429
+ 0.00 0.50 0.57 15142857
+ 0.00 0.50 0.57 22214286
+ 0.00 0.50 0.57 29285714
+ 0.00 0.50 0.57 36357143
+ 0.00 0.50 0.57 43428571
+ 0.00 0.50 0.57 50500000
+ 0.00 0.50 0.57 57571429
+ 0.00 0.50 0.57 64642857
+ 0.00 0.50 0.57 71714286
+ 0.00 0.50 0.57 78785714
+ 0.00 0.50 0.57 85857143
+ 0.00 0.50 0.57 92928571
+ 0.00 0.50 0.57 100000000
+ 0.00 0.50 0.64 1000000
+ 0.00 0.50 0.64 8071429
+ 0.00 0.50 0.64 15142857
+ 0.00 0.50 0.64 22214286
+ 0.00 0.50 0.64 29285714
+ 0.00 0.50 0.64 36357143
+ 0.00 0.50 0.64 43428571
+ 0.00 0.50 0.64 50500000
+ 0.00 0.50 0.64 57571429
+ 0.00 0.50 0.64 64642857
+ 0.00 0.50 0.64 71714286
+ 0.00 0.50 0.64 78785714
+ 0.00 0.50 0.64 85857143
+ 0.00 0.50 0.64 92928571
+ 0.00 0.50 0.64 100000000
+ 0.00 0.50 0.71 1000000
+ 0.00 0.50 0.71 8071429
+ 0.00 0.50 0.71 15142857
+ 0.00 0.50 0.71 22214286
+ 0.00 0.50 0.71 29285714
+ 0.00 0.50 0.71 36357143
+ 0.00 0.50 0.71 43428571
+ 0.00 0.50 0.71 50500000
+ 0.00 0.50 0.71 57571429
+ 0.00 0.50 0.71 64642857
+ 0.00 0.50 0.71 71714286
+ 0.00 0.50 0.71 78785714
+ 0.00 0.50 0.71 85857143
+ 0.00 0.50 0.71 92928571
+ 0.00 0.50 0.71 100000000
+ 0.00 0.50 0.79 1000000
+ 0.00 0.50 0.79 8071429
+ 0.00 0.50 0.79 15142857
+ 0.00 0.50 0.79 22214286
+ 0.00 0.50 0.79 29285714
+ 0.00 0.50 0.79 36357143
+ 0.00 0.50 0.79 43428571
+ 0.00 0.50 0.79 50500000
+ 0.00 0.50 0.79 57571429
+ 0.00 0.50 0.79 64642857
+ 0.00 0.50 0.79 71714286
+ 0.00 0.50 0.79 78785714
+ 0.00 0.50 0.79 85857143
+ 0.00 0.50 0.79 92928571
+ 0.00 0.50 0.79 100000000
+ 0.00 0.50 0.86 1000000
+ 0.00 0.50 0.86 8071429
+ 0.00 0.50 0.86 15142857
+ 0.00 0.50 0.86 22214286
+ 0.00 0.50 0.86 29285714
+ 0.00 0.50 0.86 36357143
+ 0.00 0.50 0.86 43428571
+ 0.00 0.50 0.86 50500000
+ 0.00 0.50 0.86 57571429
+ 0.00 0.50 0.86 64642857
+ 0.00 0.50 0.86 71714286
+ 0.00 0.50 0.86 78785714
+ 0.00 0.50 0.86 85857143
+ 0.00 0.50 0.86 92928571
+ 0.00 0.50 0.86 100000000
+ 0.00 0.50 0.93 1000000
+ 0.00 0.50 0.93 8071429
+ 0.00 0.50 0.93 15142857
+ 0.00 0.50 0.93 22214286
+ 0.00 0.50 0.93 29285714
+ 0.00 0.50 0.93 36357143
+ 0.00 0.50 0.93 43428571
+ 0.00 0.50 0.93 50500000
+ 0.00 0.50 0.93 57571429
+ 0.00 0.50 0.93 64642857
+ 0.00 0.50 0.93 71714286
+ 0.00 0.50 0.93 78785714
+ 0.00 0.50 0.93 85857143
+ 0.00 0.50 0.93 92928571
+ 0.00 0.50 0.93 100000000
+ 0.00 0.50 1.00 1000000
+ 0.00 0.50 1.00 8071429
+ 0.00 0.50 1.00 15142857
+ 0.00 0.50 1.00 22214286
+ 0.00 0.50 1.00 29285714
+ 0.00 0.50 1.00 36357143
+ 0.00 0.50 1.00 43428571
+ 0.00 0.50 1.00 50500000
+ 0.00 0.50 1.00 57571429
+ 0.00 0.50 1.00 64642857
+ 0.00 0.50 1.00 71714286
+ 0.00 0.50 1.00 78785714
+ 0.00 0.50 1.00 85857143
+ 0.00 0.50 1.00 92928571
+ 0.00 0.50 1.00 100000000
+ 0.00 0.57 0.00 1000000
+ 0.00 0.57 0.00 8071429
+ 0.00 0.57 0.00 15142857
+ 0.00 0.57 0.00 22214286
+ 0.00 0.57 0.00 29285714
+ 0.00 0.57 0.00 36357143
+ 0.00 0.57 0.00 43428571
+ 0.00 0.57 0.00 50500000
+ 0.00 0.57 0.00 57571429
+ 0.00 0.57 0.00 64642857
+ 0.00 0.57 0.00 71714286
+ 0.00 0.57 0.00 78785714
+ 0.00 0.57 0.00 85857143
+ 0.00 0.57 0.00 92928571
+ 0.00 0.57 0.00 100000000
+ 0.00 0.57 0.07 1000000
+ 0.00 0.57 0.07 8071429
+ 0.00 0.57 0.07 15142857
+ 0.00 0.57 0.07 22214286
+ 0.00 0.57 0.07 29285714
+ 0.00 0.57 0.07 36357143
+ 0.00 0.57 0.07 43428571
+ 0.00 0.57 0.07 50500000
+ 0.00 0.57 0.07 57571429
+ 0.00 0.57 0.07 64642857
+ 0.00 0.57 0.07 71714286
+ 0.00 0.57 0.07 78785714
+ 0.00 0.57 0.07 85857143
+ 0.00 0.57 0.07 92928571
+ 0.00 0.57 0.07 100000000
+ 0.00 0.57 0.14 1000000
+ 0.00 0.57 0.14 8071429
+ 0.00 0.57 0.14 15142857
+ 0.00 0.57 0.14 22214286
+ 0.00 0.57 0.14 29285714
+ 0.00 0.57 0.14 36357143
+ 0.00 0.57 0.14 43428571
+ 0.00 0.57 0.14 50500000
+ 0.00 0.57 0.14 57571429
+ 0.00 0.57 0.14 64642857
+ 0.00 0.57 0.14 71714286
+ 0.00 0.57 0.14 78785714
+ 0.00 0.57 0.14 85857143
+ 0.00 0.57 0.14 92928571
+ 0.00 0.57 0.14 100000000
+ 0.00 0.57 0.21 1000000
+ 0.00 0.57 0.21 8071429
+ 0.00 0.57 0.21 15142857
+ 0.00 0.57 0.21 22214286
+ 0.00 0.57 0.21 29285714
+ 0.00 0.57 0.21 36357143
+ 0.00 0.57 0.21 43428571
+ 0.00 0.57 0.21 50500000
+ 0.00 0.57 0.21 57571429
+ 0.00 0.57 0.21 64642857
+ 0.00 0.57 0.21 71714286
+ 0.00 0.57 0.21 78785714
+ 0.00 0.57 0.21 85857143
+ 0.00 0.57 0.21 92928571
+ 0.00 0.57 0.21 100000000
+ 0.00 0.57 0.29 1000000
+ 0.00 0.57 0.29 8071429
+ 0.00 0.57 0.29 15142857
+ 0.00 0.57 0.29 22214286
+ 0.00 0.57 0.29 29285714
+ 0.00 0.57 0.29 36357143
+ 0.00 0.57 0.29 43428571
+ 0.00 0.57 0.29 50500000
+ 0.00 0.57 0.29 57571429
+ 0.00 0.57 0.29 64642857
+ 0.00 0.57 0.29 71714286
+ 0.00 0.57 0.29 78785714
+ 0.00 0.57 0.29 85857143
+ 0.00 0.57 0.29 92928571
+ 0.00 0.57 0.29 100000000
+ 0.00 0.57 0.36 1000000
+ 0.00 0.57 0.36 8071429
+ 0.00 0.57 0.36 15142857
+ 0.00 0.57 0.36 22214286
+ 0.00 0.57 0.36 29285714
+ 0.00 0.57 0.36 36357143
+ 0.00 0.57 0.36 43428571
+ 0.00 0.57 0.36 50500000
+ 0.00 0.57 0.36 57571429
+ 0.00 0.57 0.36 64642857
+ 0.00 0.57 0.36 71714286
+ 0.00 0.57 0.36 78785714
+ 0.00 0.57 0.36 85857143
+ 0.00 0.57 0.36 92928571
+ 0.00 0.57 0.36 100000000
+ 0.00 0.57 0.43 1000000
+ 0.00 0.57 0.43 8071429
+ 0.00 0.57 0.43 15142857
+ 0.00 0.57 0.43 22214286
+ 0.00 0.57 0.43 29285714
+ 0.00 0.57 0.43 36357143
+ 0.00 0.57 0.43 43428571
+ 0.00 0.57 0.43 50500000
+ 0.00 0.57 0.43 57571429
+ 0.00 0.57 0.43 64642857
+ 0.00 0.57 0.43 71714286
+ 0.00 0.57 0.43 78785714
+ 0.00 0.57 0.43 85857143
+ 0.00 0.57 0.43 92928571
+ 0.00 0.57 0.43 100000000
+ 0.00 0.57 0.50 1000000
+ 0.00 0.57 0.50 8071429
+ 0.00 0.57 0.50 15142857
+ 0.00 0.57 0.50 22214286
+ 0.00 0.57 0.50 29285714
+ 0.00 0.57 0.50 36357143
+ 0.00 0.57 0.50 43428571
+ 0.00 0.57 0.50 50500000
+ 0.00 0.57 0.50 57571429
+ 0.00 0.57 0.50 64642857
+ 0.00 0.57 0.50 71714286
+ 0.00 0.57 0.50 78785714
+ 0.00 0.57 0.50 85857143
+ 0.00 0.57 0.50 92928571
+ 0.00 0.57 0.50 100000000
+ 0.00 0.57 0.57 1000000
+ 0.00 0.57 0.57 8071429
+ 0.00 0.57 0.57 15142857
+ 0.00 0.57 0.57 22214286
+ 0.00 0.57 0.57 29285714
+ 0.00 0.57 0.57 36357143
+ 0.00 0.57 0.57 43428571
+ 0.00 0.57 0.57 50500000
+ 0.00 0.57 0.57 57571429
+ 0.00 0.57 0.57 64642857
+ 0.00 0.57 0.57 71714286
+ 0.00 0.57 0.57 78785714
+ 0.00 0.57 0.57 85857143
+ 0.00 0.57 0.57 92928571
+ 0.00 0.57 0.57 100000000
+ 0.00 0.57 0.64 1000000
+ 0.00 0.57 0.64 8071429
+ 0.00 0.57 0.64 15142857
+ 0.00 0.57 0.64 22214286
+ 0.00 0.57 0.64 29285714
+ 0.00 0.57 0.64 36357143
+ 0.00 0.57 0.64 43428571
+ 0.00 0.57 0.64 50500000
+ 0.00 0.57 0.64 57571429
+ 0.00 0.57 0.64 64642857
+ 0.00 0.57 0.64 71714286
+ 0.00 0.57 0.64 78785714
+ 0.00 0.57 0.64 85857143
+ 0.00 0.57 0.64 92928571
+ 0.00 0.57 0.64 100000000
+ 0.00 0.57 0.71 1000000
+ 0.00 0.57 0.71 8071429
+ 0.00 0.57 0.71 15142857
+ 0.00 0.57 0.71 22214286
+ 0.00 0.57 0.71 29285714
+ 0.00 0.57 0.71 36357143
+ 0.00 0.57 0.71 43428571
+ 0.00 0.57 0.71 50500000
+ 0.00 0.57 0.71 57571429
+ 0.00 0.57 0.71 64642857
+ 0.00 0.57 0.71 71714286
+ 0.00 0.57 0.71 78785714
+ 0.00 0.57 0.71 85857143
+ 0.00 0.57 0.71 92928571
+ 0.00 0.57 0.71 100000000
+ 0.00 0.57 0.79 1000000
+ 0.00 0.57 0.79 8071429
+ 0.00 0.57 0.79 15142857
+ 0.00 0.57 0.79 22214286
+ 0.00 0.57 0.79 29285714
+ 0.00 0.57 0.79 36357143
+ 0.00 0.57 0.79 43428571
+ 0.00 0.57 0.79 50500000
+ 0.00 0.57 0.79 57571429
+ 0.00 0.57 0.79 64642857
+ 0.00 0.57 0.79 71714286
+ 0.00 0.57 0.79 78785714
+ 0.00 0.57 0.79 85857143
+ 0.00 0.57 0.79 92928571
+ 0.00 0.57 0.79 100000000
+ 0.00 0.57 0.86 1000000
+ 0.00 0.57 0.86 8071429
+ 0.00 0.57 0.86 15142857
+ 0.00 0.57 0.86 22214286
+ 0.00 0.57 0.86 29285714
+ 0.00 0.57 0.86 36357143
+ 0.00 0.57 0.86 43428571
+ 0.00 0.57 0.86 50500000
+ 0.00 0.57 0.86 57571429
+ 0.00 0.57 0.86 64642857
+ 0.00 0.57 0.86 71714286
+ 0.00 0.57 0.86 78785714
+ 0.00 0.57 0.86 85857143
+ 0.00 0.57 0.86 92928571
+ 0.00 0.57 0.86 100000000
+ 0.00 0.57 0.93 1000000
+ 0.00 0.57 0.93 8071429
+ 0.00 0.57 0.93 15142857
+ 0.00 0.57 0.93 22214286
+ 0.00 0.57 0.93 29285714
+ 0.00 0.57 0.93 36357143
+ 0.00 0.57 0.93 43428571
+ 0.00 0.57 0.93 50500000
+ 0.00 0.57 0.93 57571429
+ 0.00 0.57 0.93 64642857
+ 0.00 0.57 0.93 71714286
+ 0.00 0.57 0.93 78785714
+ 0.00 0.57 0.93 85857143
+ 0.00 0.57 0.93 92928571
+ 0.00 0.57 0.93 100000000
+ 0.00 0.57 1.00 1000000
+ 0.00 0.57 1.00 8071429
+ 0.00 0.57 1.00 15142857
+ 0.00 0.57 1.00 22214286
+ 0.00 0.57 1.00 29285714
+ 0.00 0.57 1.00 36357143
+ 0.00 0.57 1.00 43428571
+ 0.00 0.57 1.00 50500000
+ 0.00 0.57 1.00 57571429
+ 0.00 0.57 1.00 64642857
+ 0.00 0.57 1.00 71714286
+ 0.00 0.57 1.00 78785714
+ 0.00 0.57 1.00 85857143
+ 0.00 0.57 1.00 92928571
+ 0.00 0.57 1.00 100000000
+ 0.00 0.64 0.00 1000000
+ 0.00 0.64 0.00 8071429
+ 0.00 0.64 0.00 15142857
+ 0.00 0.64 0.00 22214286
+ 0.00 0.64 0.00 29285714
+ 0.00 0.64 0.00 36357143
+ 0.00 0.64 0.00 43428571
+ 0.00 0.64 0.00 50500000
+ 0.00 0.64 0.00 57571429
+ 0.00 0.64 0.00 64642857
+ 0.00 0.64 0.00 71714286
+ 0.00 0.64 0.00 78785714
+ 0.00 0.64 0.00 85857143
+ 0.00 0.64 0.00 92928571
+ 0.00 0.64 0.00 100000000
+ 0.00 0.64 0.07 1000000
+ 0.00 0.64 0.07 8071429
+ 0.00 0.64 0.07 15142857
+ 0.00 0.64 0.07 22214286
+ 0.00 0.64 0.07 29285714
+ 0.00 0.64 0.07 36357143
+ 0.00 0.64 0.07 43428571
+ 0.00 0.64 0.07 50500000
+ 0.00 0.64 0.07 57571429
+ 0.00 0.64 0.07 64642857
+ 0.00 0.64 0.07 71714286
+ 0.00 0.64 0.07 78785714
+ 0.00 0.64 0.07 85857143
+ 0.00 0.64 0.07 92928571
+ 0.00 0.64 0.07 100000000
+ 0.00 0.64 0.14 1000000
+ 0.00 0.64 0.14 8071429
+ 0.00 0.64 0.14 15142857
+ 0.00 0.64 0.14 22214286
+ 0.00 0.64 0.14 29285714
+ 0.00 0.64 0.14 36357143
+ 0.00 0.64 0.14 43428571
+ 0.00 0.64 0.14 50500000
+ 0.00 0.64 0.14 57571429
+ 0.00 0.64 0.14 64642857
+ 0.00 0.64 0.14 71714286
+ 0.00 0.64 0.14 78785714
+ 0.00 0.64 0.14 85857143
+ 0.00 0.64 0.14 92928571
+ 0.00 0.64 0.14 100000000
+ 0.00 0.64 0.21 1000000
+ 0.00 0.64 0.21 8071429
+ 0.00 0.64 0.21 15142857
+ 0.00 0.64 0.21 22214286
+ 0.00 0.64 0.21 29285714
+ 0.00 0.64 0.21 36357143
+ 0.00 0.64 0.21 43428571
+ 0.00 0.64 0.21 50500000
+ 0.00 0.64 0.21 57571429
+ 0.00 0.64 0.21 64642857
+ 0.00 0.64 0.21 71714286
+ 0.00 0.64 0.21 78785714
+ 0.00 0.64 0.21 85857143
+ 0.00 0.64 0.21 92928571
+ 0.00 0.64 0.21 100000000
+ 0.00 0.64 0.29 1000000
+ 0.00 0.64 0.29 8071429
+ 0.00 0.64 0.29 15142857
+ 0.00 0.64 0.29 22214286
+ 0.00 0.64 0.29 29285714
+ 0.00 0.64 0.29 36357143
+ 0.00 0.64 0.29 43428571
+ 0.00 0.64 0.29 50500000
+ 0.00 0.64 0.29 57571429
+ 0.00 0.64 0.29 64642857
+ 0.00 0.64 0.29 71714286
+ 0.00 0.64 0.29 78785714
+ 0.00 0.64 0.29 85857143
+ 0.00 0.64 0.29 92928571
+ 0.00 0.64 0.29 100000000
+ 0.00 0.64 0.36 1000000
+ 0.00 0.64 0.36 8071429
+ 0.00 0.64 0.36 15142857
+ 0.00 0.64 0.36 22214286
+ 0.00 0.64 0.36 29285714
+ 0.00 0.64 0.36 36357143
+ 0.00 0.64 0.36 43428571
+ 0.00 0.64 0.36 50500000
+ 0.00 0.64 0.36 57571429
+ 0.00 0.64 0.36 64642857
+ 0.00 0.64 0.36 71714286
+ 0.00 0.64 0.36 78785714
+ 0.00 0.64 0.36 85857143
+ 0.00 0.64 0.36 92928571
+ 0.00 0.64 0.36 100000000
+ 0.00 0.64 0.43 1000000
+ 0.00 0.64 0.43 8071429
+ 0.00 0.64 0.43 15142857
+ 0.00 0.64 0.43 22214286
+ 0.00 0.64 0.43 29285714
+ 0.00 0.64 0.43 36357143
+ 0.00 0.64 0.43 43428571
+ 0.00 0.64 0.43 50500000
+ 0.00 0.64 0.43 57571429
+ 0.00 0.64 0.43 64642857
+ 0.00 0.64 0.43 71714286
+ 0.00 0.64 0.43 78785714
+ 0.00 0.64 0.43 85857143
+ 0.00 0.64 0.43 92928571
+ 0.00 0.64 0.43 100000000
+ 0.00 0.64 0.50 1000000
+ 0.00 0.64 0.50 8071429
+ 0.00 0.64 0.50 15142857
+ 0.00 0.64 0.50 22214286
+ 0.00 0.64 0.50 29285714
+ 0.00 0.64 0.50 36357143
+ 0.00 0.64 0.50 43428571
+ 0.00 0.64 0.50 50500000
+ 0.00 0.64 0.50 57571429
+ 0.00 0.64 0.50 64642857
+ 0.00 0.64 0.50 71714286
+ 0.00 0.64 0.50 78785714
+ 0.00 0.64 0.50 85857143
+ 0.00 0.64 0.50 92928571
+ 0.00 0.64 0.50 100000000
+ 0.00 0.64 0.57 1000000
+ 0.00 0.64 0.57 8071429
+ 0.00 0.64 0.57 15142857
+ 0.00 0.64 0.57 22214286
+ 0.00 0.64 0.57 29285714
+ 0.00 0.64 0.57 36357143
+ 0.00 0.64 0.57 43428571
+ 0.00 0.64 0.57 50500000
+ 0.00 0.64 0.57 57571429
+ 0.00 0.64 0.57 64642857
+ 0.00 0.64 0.57 71714286
+ 0.00 0.64 0.57 78785714
+ 0.00 0.64 0.57 85857143
+ 0.00 0.64 0.57 92928571
+ 0.00 0.64 0.57 100000000
+ 0.00 0.64 0.64 1000000
+ 0.00 0.64 0.64 8071429
+ 0.00 0.64 0.64 15142857
+ 0.00 0.64 0.64 22214286
+ 0.00 0.64 0.64 29285714
+ 0.00 0.64 0.64 36357143
+ 0.00 0.64 0.64 43428571
+ 0.00 0.64 0.64 50500000
+ 0.00 0.64 0.64 57571429
+ 0.00 0.64 0.64 64642857
+ 0.00 0.64 0.64 71714286
+ 0.00 0.64 0.64 78785714
+ 0.00 0.64 0.64 85857143
+ 0.00 0.64 0.64 92928571
+ 0.00 0.64 0.64 100000000
+ 0.00 0.64 0.71 1000000
+ 0.00 0.64 0.71 8071429
+ 0.00 0.64 0.71 15142857
+ 0.00 0.64 0.71 22214286
+ 0.00 0.64 0.71 29285714
+ 0.00 0.64 0.71 36357143
+ 0.00 0.64 0.71 43428571
+ 0.00 0.64 0.71 50500000
+ 0.00 0.64 0.71 57571429
+ 0.00 0.64 0.71 64642857
+ 0.00 0.64 0.71 71714286
+ 0.00 0.64 0.71 78785714
+ 0.00 0.64 0.71 85857143
+ 0.00 0.64 0.71 92928571
+ 0.00 0.64 0.71 100000000
+ 0.00 0.64 0.79 1000000
+ 0.00 0.64 0.79 8071429
+ 0.00 0.64 0.79 15142857
+ 0.00 0.64 0.79 22214286
+ 0.00 0.64 0.79 29285714
+ 0.00 0.64 0.79 36357143
+ 0.00 0.64 0.79 43428571
+ 0.00 0.64 0.79 50500000
+ 0.00 0.64 0.79 57571429
+ 0.00 0.64 0.79 64642857
+ 0.00 0.64 0.79 71714286
+ 0.00 0.64 0.79 78785714
+ 0.00 0.64 0.79 85857143
+ 0.00 0.64 0.79 92928571
+ 0.00 0.64 0.79 100000000
+ 0.00 0.64 0.86 1000000
+ 0.00 0.64 0.86 8071429
+ 0.00 0.64 0.86 15142857
+ 0.00 0.64 0.86 22214286
+ 0.00 0.64 0.86 29285714
+ 0.00 0.64 0.86 36357143
+ 0.00 0.64 0.86 43428571
+ 0.00 0.64 0.86 50500000
+ 0.00 0.64 0.86 57571429
+ 0.00 0.64 0.86 64642857
+ 0.00 0.64 0.86 71714286
+ 0.00 0.64 0.86 78785714
+ 0.00 0.64 0.86 85857143
+ 0.00 0.64 0.86 92928571
+ 0.00 0.64 0.86 100000000
+ 0.00 0.64 0.93 1000000
+ 0.00 0.64 0.93 8071429
+ 0.00 0.64 0.93 15142857
+ 0.00 0.64 0.93 22214286
+ 0.00 0.64 0.93 29285714
+ 0.00 0.64 0.93 36357143
+ 0.00 0.64 0.93 43428571
+ 0.00 0.64 0.93 50500000
+ 0.00 0.64 0.93 57571429
+ 0.00 0.64 0.93 64642857
+ 0.00 0.64 0.93 71714286
+ 0.00 0.64 0.93 78785714
+ 0.00 0.64 0.93 85857143
+ 0.00 0.64 0.93 92928571
+ 0.00 0.64 0.93 100000000
+ 0.00 0.64 1.00 1000000
+ 0.00 0.64 1.00 8071429
+ 0.00 0.64 1.00 15142857
+ 0.00 0.64 1.00 22214286
+ 0.00 0.64 1.00 29285714
+ 0.00 0.64 1.00 36357143
+ 0.00 0.64 1.00 43428571
+ 0.00 0.64 1.00 50500000
+ 0.00 0.64 1.00 57571429
+ 0.00 0.64 1.00 64642857
+ 0.00 0.64 1.00 71714286
+ 0.00 0.64 1.00 78785714
+ 0.00 0.64 1.00 85857143
+ 0.00 0.64 1.00 92928571
+ 0.00 0.64 1.00 100000000
+ 0.00 0.71 0.00 1000000
+ 0.00 0.71 0.00 8071429
+ 0.00 0.71 0.00 15142857
+ 0.00 0.71 0.00 22214286
+ 0.00 0.71 0.00 29285714
+ 0.00 0.71 0.00 36357143
+ 0.00 0.71 0.00 43428571
+ 0.00 0.71 0.00 50500000
+ 0.00 0.71 0.00 57571429
+ 0.00 0.71 0.00 64642857
+ 0.00 0.71 0.00 71714286
+ 0.00 0.71 0.00 78785714
+ 0.00 0.71 0.00 85857143
+ 0.00 0.71 0.00 92928571
+ 0.00 0.71 0.00 100000000
+ 0.00 0.71 0.07 1000000
+ 0.00 0.71 0.07 8071429
+ 0.00 0.71 0.07 15142857
+ 0.00 0.71 0.07 22214286
+ 0.00 0.71 0.07 29285714
+ 0.00 0.71 0.07 36357143
+ 0.00 0.71 0.07 43428571
+ 0.00 0.71 0.07 50500000
+ 0.00 0.71 0.07 57571429
+ 0.00 0.71 0.07 64642857
+ 0.00 0.71 0.07 71714286
+ 0.00 0.71 0.07 78785714
+ 0.00 0.71 0.07 85857143
+ 0.00 0.71 0.07 92928571
+ 0.00 0.71 0.07 100000000
+ 0.00 0.71 0.14 1000000
+ 0.00 0.71 0.14 8071429
+ 0.00 0.71 0.14 15142857
+ 0.00 0.71 0.14 22214286
+ 0.00 0.71 0.14 29285714
+ 0.00 0.71 0.14 36357143
+ 0.00 0.71 0.14 43428571
+ 0.00 0.71 0.14 50500000
+ 0.00 0.71 0.14 57571429
+ 0.00 0.71 0.14 64642857
+ 0.00 0.71 0.14 71714286
+ 0.00 0.71 0.14 78785714
+ 0.00 0.71 0.14 85857143
+ 0.00 0.71 0.14 92928571
+ 0.00 0.71 0.14 100000000
+ 0.00 0.71 0.21 1000000
+ 0.00 0.71 0.21 8071429
+ 0.00 0.71 0.21 15142857
+ 0.00 0.71 0.21 22214286
+ 0.00 0.71 0.21 29285714
+ 0.00 0.71 0.21 36357143
+ 0.00 0.71 0.21 43428571
+ 0.00 0.71 0.21 50500000
+ 0.00 0.71 0.21 57571429
+ 0.00 0.71 0.21 64642857
+ 0.00 0.71 0.21 71714286
+ 0.00 0.71 0.21 78785714
+ 0.00 0.71 0.21 85857143
+ 0.00 0.71 0.21 92928571
+ 0.00 0.71 0.21 100000000
+ 0.00 0.71 0.29 1000000
+ 0.00 0.71 0.29 8071429
+ 0.00 0.71 0.29 15142857
+ 0.00 0.71 0.29 22214286
+ 0.00 0.71 0.29 29285714
+ 0.00 0.71 0.29 36357143
+ 0.00 0.71 0.29 43428571
+ 0.00 0.71 0.29 50500000
+ 0.00 0.71 0.29 57571429
+ 0.00 0.71 0.29 64642857
+ 0.00 0.71 0.29 71714286
+ 0.00 0.71 0.29 78785714
+ 0.00 0.71 0.29 85857143
+ 0.00 0.71 0.29 92928571
+ 0.00 0.71 0.29 100000000
+ 0.00 0.71 0.36 1000000
+ 0.00 0.71 0.36 8071429
+ 0.00 0.71 0.36 15142857
+ 0.00 0.71 0.36 22214286
+ 0.00 0.71 0.36 29285714
+ 0.00 0.71 0.36 36357143
+ 0.00 0.71 0.36 43428571
+ 0.00 0.71 0.36 50500000
+ 0.00 0.71 0.36 57571429
+ 0.00 0.71 0.36 64642857
+ 0.00 0.71 0.36 71714286
+ 0.00 0.71 0.36 78785714
+ 0.00 0.71 0.36 85857143
+ 0.00 0.71 0.36 92928571
+ 0.00 0.71 0.36 100000000
+ 0.00 0.71 0.43 1000000
+ 0.00 0.71 0.43 8071429
+ 0.00 0.71 0.43 15142857
+ 0.00 0.71 0.43 22214286
+ 0.00 0.71 0.43 29285714
+ 0.00 0.71 0.43 36357143
+ 0.00 0.71 0.43 43428571
+ 0.00 0.71 0.43 50500000
+ 0.00 0.71 0.43 57571429
+ 0.00 0.71 0.43 64642857
+ 0.00 0.71 0.43 71714286
+ 0.00 0.71 0.43 78785714
+ 0.00 0.71 0.43 85857143
+ 0.00 0.71 0.43 92928571
+ 0.00 0.71 0.43 100000000
+ 0.00 0.71 0.50 1000000
+ 0.00 0.71 0.50 8071429
+ 0.00 0.71 0.50 15142857
+ 0.00 0.71 0.50 22214286
+ 0.00 0.71 0.50 29285714
+ 0.00 0.71 0.50 36357143
+ 0.00 0.71 0.50 43428571
+ 0.00 0.71 0.50 50500000
+ 0.00 0.71 0.50 57571429
+ 0.00 0.71 0.50 64642857
+ 0.00 0.71 0.50 71714286
+ 0.00 0.71 0.50 78785714
+ 0.00 0.71 0.50 85857143
+ 0.00 0.71 0.50 92928571
+ 0.00 0.71 0.50 100000000
+ 0.00 0.71 0.57 1000000
+ 0.00 0.71 0.57 8071429
+ 0.00 0.71 0.57 15142857
+ 0.00 0.71 0.57 22214286
+ 0.00 0.71 0.57 29285714
+ 0.00 0.71 0.57 36357143
+ 0.00 0.71 0.57 43428571
+ 0.00 0.71 0.57 50500000
+ 0.00 0.71 0.57 57571429
+ 0.00 0.71 0.57 64642857
+ 0.00 0.71 0.57 71714286
+ 0.00 0.71 0.57 78785714
+ 0.00 0.71 0.57 85857143
+ 0.00 0.71 0.57 92928571
+ 0.00 0.71 0.57 100000000
+ 0.00 0.71 0.64 1000000
+ 0.00 0.71 0.64 8071429
+ 0.00 0.71 0.64 15142857
+ 0.00 0.71 0.64 22214286
+ 0.00 0.71 0.64 29285714
+ 0.00 0.71 0.64 36357143
+ 0.00 0.71 0.64 43428571
+ 0.00 0.71 0.64 50500000
+ 0.00 0.71 0.64 57571429
+ 0.00 0.71 0.64 64642857
+ 0.00 0.71 0.64 71714286
+ 0.00 0.71 0.64 78785714
+ 0.00 0.71 0.64 85857143
+ 0.00 0.71 0.64 92928571
+ 0.00 0.71 0.64 100000000
+ 0.00 0.71 0.71 1000000
+ 0.00 0.71 0.71 8071429
+ 0.00 0.71 0.71 15142857
+ 0.00 0.71 0.71 22214286
+ 0.00 0.71 0.71 29285714
+ 0.00 0.71 0.71 36357143
+ 0.00 0.71 0.71 43428571
+ 0.00 0.71 0.71 50500000
+ 0.00 0.71 0.71 57571429
+ 0.00 0.71 0.71 64642857
+ 0.00 0.71 0.71 71714286
+ 0.00 0.71 0.71 78785714
+ 0.00 0.71 0.71 85857143
+ 0.00 0.71 0.71 92928571
+ 0.00 0.71 0.71 100000000
+ 0.00 0.71 0.79 1000000
+ 0.00 0.71 0.79 8071429
+ 0.00 0.71 0.79 15142857
+ 0.00 0.71 0.79 22214286
+ 0.00 0.71 0.79 29285714
+ 0.00 0.71 0.79 36357143
+ 0.00 0.71 0.79 43428571
+ 0.00 0.71 0.79 50500000
+ 0.00 0.71 0.79 57571429
+ 0.00 0.71 0.79 64642857
+ 0.00 0.71 0.79 71714286
+ 0.00 0.71 0.79 78785714
+ 0.00 0.71 0.79 85857143
+ 0.00 0.71 0.79 92928571
+ 0.00 0.71 0.79 100000000
+ 0.00 0.71 0.86 1000000
+ 0.00 0.71 0.86 8071429
+ 0.00 0.71 0.86 15142857
+ 0.00 0.71 0.86 22214286
+ 0.00 0.71 0.86 29285714
+ 0.00 0.71 0.86 36357143
+ 0.00 0.71 0.86 43428571
+ 0.00 0.71 0.86 50500000
+ 0.00 0.71 0.86 57571429
+ 0.00 0.71 0.86 64642857
+ 0.00 0.71 0.86 71714286
+ 0.00 0.71 0.86 78785714
+ 0.00 0.71 0.86 85857143
+ 0.00 0.71 0.86 92928571
+ 0.00 0.71 0.86 100000000
+ 0.00 0.71 0.93 1000000
+ 0.00 0.71 0.93 8071429
+ 0.00 0.71 0.93 15142857
+ 0.00 0.71 0.93 22214286
+ 0.00 0.71 0.93 29285714
+ 0.00 0.71 0.93 36357143
+ 0.00 0.71 0.93 43428571
+ 0.00 0.71 0.93 50500000
+ 0.00 0.71 0.93 57571429
+ 0.00 0.71 0.93 64642857
+ 0.00 0.71 0.93 71714286
+ 0.00 0.71 0.93 78785714
+ 0.00 0.71 0.93 85857143
+ 0.00 0.71 0.93 92928571
+ 0.00 0.71 0.93 100000000
+ 0.00 0.71 1.00 1000000
+ 0.00 0.71 1.00 8071429
+ 0.00 0.71 1.00 15142857
+ 0.00 0.71 1.00 22214286
+ 0.00 0.71 1.00 29285714
+ 0.00 0.71 1.00 36357143
+ 0.00 0.71 1.00 43428571
+ 0.00 0.71 1.00 50500000
+ 0.00 0.71 1.00 57571429
+ 0.00 0.71 1.00 64642857
+ 0.00 0.71 1.00 71714286
+ 0.00 0.71 1.00 78785714
+ 0.00 0.71 1.00 85857143
+ 0.00 0.71 1.00 92928571
+ 0.00 0.71 1.00 100000000
+ 0.00 0.79 0.00 1000000
+ 0.00 0.79 0.00 8071429
+ 0.00 0.79 0.00 15142857
+ 0.00 0.79 0.00 22214286
+ 0.00 0.79 0.00 29285714
+ 0.00 0.79 0.00 36357143
+ 0.00 0.79 0.00 43428571
+ 0.00 0.79 0.00 50500000
+ 0.00 0.79 0.00 57571429
+ 0.00 0.79 0.00 64642857
+ 0.00 0.79 0.00 71714286
+ 0.00 0.79 0.00 78785714
+ 0.00 0.79 0.00 85857143
+ 0.00 0.79 0.00 92928571
+ 0.00 0.79 0.00 100000000
+ 0.00 0.79 0.07 1000000
+ 0.00 0.79 0.07 8071429
+ 0.00 0.79 0.07 15142857
+ 0.00 0.79 0.07 22214286
+ 0.00 0.79 0.07 29285714
+ 0.00 0.79 0.07 36357143
+ 0.00 0.79 0.07 43428571
+ 0.00 0.79 0.07 50500000
+ 0.00 0.79 0.07 57571429
+ 0.00 0.79 0.07 64642857
+ 0.00 0.79 0.07 71714286
+ 0.00 0.79 0.07 78785714
+ 0.00 0.79 0.07 85857143
+ 0.00 0.79 0.07 92928571
+ 0.00 0.79 0.07 100000000
+ 0.00 0.79 0.14 1000000
+ 0.00 0.79 0.14 8071429
+ 0.00 0.79 0.14 15142857
+ 0.00 0.79 0.14 22214286
+ 0.00 0.79 0.14 29285714
+ 0.00 0.79 0.14 36357143
+ 0.00 0.79 0.14 43428571
+ 0.00 0.79 0.14 50500000
+ 0.00 0.79 0.14 57571429
+ 0.00 0.79 0.14 64642857
+ 0.00 0.79 0.14 71714286
+ 0.00 0.79 0.14 78785714
+ 0.00 0.79 0.14 85857143
+ 0.00 0.79 0.14 92928571
+ 0.00 0.79 0.14 100000000
+ 0.00 0.79 0.21 1000000
+ 0.00 0.79 0.21 8071429
+ 0.00 0.79 0.21 15142857
+ 0.00 0.79 0.21 22214286
+ 0.00 0.79 0.21 29285714
+ 0.00 0.79 0.21 36357143
+ 0.00 0.79 0.21 43428571
+ 0.00 0.79 0.21 50500000
+ 0.00 0.79 0.21 57571429
+ 0.00 0.79 0.21 64642857
+ 0.00 0.79 0.21 71714286
+ 0.00 0.79 0.21 78785714
+ 0.00 0.79 0.21 85857143
+ 0.00 0.79 0.21 92928571
+ 0.00 0.79 0.21 100000000
+ 0.00 0.79 0.29 1000000
+ 0.00 0.79 0.29 8071429
+ 0.00 0.79 0.29 15142857
+ 0.00 0.79 0.29 22214286
+ 0.00 0.79 0.29 29285714
+ 0.00 0.79 0.29 36357143
+ 0.00 0.79 0.29 43428571
+ 0.00 0.79 0.29 50500000
+ 0.00 0.79 0.29 57571429
+ 0.00 0.79 0.29 64642857
+ 0.00 0.79 0.29 71714286
+ 0.00 0.79 0.29 78785714
+ 0.00 0.79 0.29 85857143
+ 0.00 0.79 0.29 92928571
+ 0.00 0.79 0.29 100000000
+ 0.00 0.79 0.36 1000000
+ 0.00 0.79 0.36 8071429
+ 0.00 0.79 0.36 15142857
+ 0.00 0.79 0.36 22214286
+ 0.00 0.79 0.36 29285714
+ 0.00 0.79 0.36 36357143
+ 0.00 0.79 0.36 43428571
+ 0.00 0.79 0.36 50500000
+ 0.00 0.79 0.36 57571429
+ 0.00 0.79 0.36 64642857
+ 0.00 0.79 0.36 71714286
+ 0.00 0.79 0.36 78785714
+ 0.00 0.79 0.36 85857143
+ 0.00 0.79 0.36 92928571
+ 0.00 0.79 0.36 100000000
+ 0.00 0.79 0.43 1000000
+ 0.00 0.79 0.43 8071429
+ 0.00 0.79 0.43 15142857
+ 0.00 0.79 0.43 22214286
+ 0.00 0.79 0.43 29285714
+ 0.00 0.79 0.43 36357143
+ 0.00 0.79 0.43 43428571
+ 0.00 0.79 0.43 50500000
+ 0.00 0.79 0.43 57571429
+ 0.00 0.79 0.43 64642857
+ 0.00 0.79 0.43 71714286
+ 0.00 0.79 0.43 78785714
+ 0.00 0.79 0.43 85857143
+ 0.00 0.79 0.43 92928571
+ 0.00 0.79 0.43 100000000
+ 0.00 0.79 0.50 1000000
+ 0.00 0.79 0.50 8071429
+ 0.00 0.79 0.50 15142857
+ 0.00 0.79 0.50 22214286
+ 0.00 0.79 0.50 29285714
+ 0.00 0.79 0.50 36357143
+ 0.00 0.79 0.50 43428571
+ 0.00 0.79 0.50 50500000
+ 0.00 0.79 0.50 57571429
+ 0.00 0.79 0.50 64642857
+ 0.00 0.79 0.50 71714286
+ 0.00 0.79 0.50 78785714
+ 0.00 0.79 0.50 85857143
+ 0.00 0.79 0.50 92928571
+ 0.00 0.79 0.50 100000000
+ 0.00 0.79 0.57 1000000
+ 0.00 0.79 0.57 8071429
+ 0.00 0.79 0.57 15142857
+ 0.00 0.79 0.57 22214286
+ 0.00 0.79 0.57 29285714
+ 0.00 0.79 0.57 36357143
+ 0.00 0.79 0.57 43428571
+ 0.00 0.79 0.57 50500000
+ 0.00 0.79 0.57 57571429
+ 0.00 0.79 0.57 64642857
+ 0.00 0.79 0.57 71714286
+ 0.00 0.79 0.57 78785714
+ 0.00 0.79 0.57 85857143
+ 0.00 0.79 0.57 92928571
+ 0.00 0.79 0.57 100000000
+ 0.00 0.79 0.64 1000000
+ 0.00 0.79 0.64 8071429
+ 0.00 0.79 0.64 15142857
+ 0.00 0.79 0.64 22214286
+ 0.00 0.79 0.64 29285714
+ 0.00 0.79 0.64 36357143
+ 0.00 0.79 0.64 43428571
+ 0.00 0.79 0.64 50500000
+ 0.00 0.79 0.64 57571429
+ 0.00 0.79 0.64 64642857
+ 0.00 0.79 0.64 71714286
+ 0.00 0.79 0.64 78785714
+ 0.00 0.79 0.64 85857143
+ 0.00 0.79 0.64 92928571
+ 0.00 0.79 0.64 100000000
+ 0.00 0.79 0.71 1000000
+ 0.00 0.79 0.71 8071429
+ 0.00 0.79 0.71 15142857
+ 0.00 0.79 0.71 22214286
+ 0.00 0.79 0.71 29285714
+ 0.00 0.79 0.71 36357143
+ 0.00 0.79 0.71 43428571
+ 0.00 0.79 0.71 50500000
+ 0.00 0.79 0.71 57571429
+ 0.00 0.79 0.71 64642857
+ 0.00 0.79 0.71 71714286
+ 0.00 0.79 0.71 78785714
+ 0.00 0.79 0.71 85857143
+ 0.00 0.79 0.71 92928571
+ 0.00 0.79 0.71 100000000
+ 0.00 0.79 0.79 1000000
+ 0.00 0.79 0.79 8071429
+ 0.00 0.79 0.79 15142857
+ 0.00 0.79 0.79 22214286
+ 0.00 0.79 0.79 29285714
+ 0.00 0.79 0.79 36357143
+ 0.00 0.79 0.79 43428571
+ 0.00 0.79 0.79 50500000
+ 0.00 0.79 0.79 57571429
+ 0.00 0.79 0.79 64642857
+ 0.00 0.79 0.79 71714286
+ 0.00 0.79 0.79 78785714
+ 0.00 0.79 0.79 85857143
+ 0.00 0.79 0.79 92928571
+ 0.00 0.79 0.79 100000000
+ 0.00 0.79 0.86 1000000
+ 0.00 0.79 0.86 8071429
+ 0.00 0.79 0.86 15142857
+ 0.00 0.79 0.86 22214286
+ 0.00 0.79 0.86 29285714
+ 0.00 0.79 0.86 36357143
+ 0.00 0.79 0.86 43428571
+ 0.00 0.79 0.86 50500000
+ 0.00 0.79 0.86 57571429
+ 0.00 0.79 0.86 64642857
+ 0.00 0.79 0.86 71714286
+ 0.00 0.79 0.86 78785714
+ 0.00 0.79 0.86 85857143
+ 0.00 0.79 0.86 92928571
+ 0.00 0.79 0.86 100000000
+ 0.00 0.79 0.93 1000000
+ 0.00 0.79 0.93 8071429
+ 0.00 0.79 0.93 15142857
+ 0.00 0.79 0.93 22214286
+ 0.00 0.79 0.93 29285714
+ 0.00 0.79 0.93 36357143
+ 0.00 0.79 0.93 43428571
+ 0.00 0.79 0.93 50500000
+ 0.00 0.79 0.93 57571429
+ 0.00 0.79 0.93 64642857
+ 0.00 0.79 0.93 71714286
+ 0.00 0.79 0.93 78785714
+ 0.00 0.79 0.93 85857143
+ 0.00 0.79 0.93 92928571
+ 0.00 0.79 0.93 100000000
+ 0.00 0.79 1.00 1000000
+ 0.00 0.79 1.00 8071429
+ 0.00 0.79 1.00 15142857
+ 0.00 0.79 1.00 22214286
+ 0.00 0.79 1.00 29285714
+ 0.00 0.79 1.00 36357143
+ 0.00 0.79 1.00 43428571
+ 0.00 0.79 1.00 50500000
+ 0.00 0.79 1.00 57571429
+ 0.00 0.79 1.00 64642857
+ 0.00 0.79 1.00 71714286
+ 0.00 0.79 1.00 78785714
+ 0.00 0.79 1.00 85857143
+ 0.00 0.79 1.00 92928571
+ 0.00 0.79 1.00 100000000
+ 0.00 0.86 0.00 1000000
+ 0.00 0.86 0.00 8071429
+ 0.00 0.86 0.00 15142857
+ 0.00 0.86 0.00 22214286
+ 0.00 0.86 0.00 29285714
+ 0.00 0.86 0.00 36357143
+ 0.00 0.86 0.00 43428571
+ 0.00 0.86 0.00 50500000
+ 0.00 0.86 0.00 57571429
+ 0.00 0.86 0.00 64642857
+ 0.00 0.86 0.00 71714286
+ 0.00 0.86 0.00 78785714
+ 0.00 0.86 0.00 85857143
+ 0.00 0.86 0.00 92928571
+ 0.00 0.86 0.00 100000000
+ 0.00 0.86 0.07 1000000
+ 0.00 0.86 0.07 8071429
+ 0.00 0.86 0.07 15142857
+ 0.00 0.86 0.07 22214286
+ 0.00 0.86 0.07 29285714
+ 0.00 0.86 0.07 36357143
+ 0.00 0.86 0.07 43428571
+ 0.00 0.86 0.07 50500000
+ 0.00 0.86 0.07 57571429
+ 0.00 0.86 0.07 64642857
+ 0.00 0.86 0.07 71714286
+ 0.00 0.86 0.07 78785714
+ 0.00 0.86 0.07 85857143
+ 0.00 0.86 0.07 92928571
+ 0.00 0.86 0.07 100000000
+ 0.00 0.86 0.14 1000000
+ 0.00 0.86 0.14 8071429
+ 0.00 0.86 0.14 15142857
+ 0.00 0.86 0.14 22214286
+ 0.00 0.86 0.14 29285714
+ 0.00 0.86 0.14 36357143
+ 0.00 0.86 0.14 43428571
+ 0.00 0.86 0.14 50500000
+ 0.00 0.86 0.14 57571429
+ 0.00 0.86 0.14 64642857
+ 0.00 0.86 0.14 71714286
+ 0.00 0.86 0.14 78785714
+ 0.00 0.86 0.14 85857143
+ 0.00 0.86 0.14 92928571
+ 0.00 0.86 0.14 100000000
+ 0.00 0.86 0.21 1000000
+ 0.00 0.86 0.21 8071429
+ 0.00 0.86 0.21 15142857
+ 0.00 0.86 0.21 22214286
+ 0.00 0.86 0.21 29285714
+ 0.00 0.86 0.21 36357143
+ 0.00 0.86 0.21 43428571
+ 0.00 0.86 0.21 50500000
+ 0.00 0.86 0.21 57571429
+ 0.00 0.86 0.21 64642857
+ 0.00 0.86 0.21 71714286
+ 0.00 0.86 0.21 78785714
+ 0.00 0.86 0.21 85857143
+ 0.00 0.86 0.21 92928571
+ 0.00 0.86 0.21 100000000
+ 0.00 0.86 0.29 1000000
+ 0.00 0.86 0.29 8071429
+ 0.00 0.86 0.29 15142857
+ 0.00 0.86 0.29 22214286
+ 0.00 0.86 0.29 29285714
+ 0.00 0.86 0.29 36357143
+ 0.00 0.86 0.29 43428571
+ 0.00 0.86 0.29 50500000
+ 0.00 0.86 0.29 57571429
+ 0.00 0.86 0.29 64642857
+ 0.00 0.86 0.29 71714286
+ 0.00 0.86 0.29 78785714
+ 0.00 0.86 0.29 85857143
+ 0.00 0.86 0.29 92928571
+ 0.00 0.86 0.29 100000000
+ 0.00 0.86 0.36 1000000
+ 0.00 0.86 0.36 8071429
+ 0.00 0.86 0.36 15142857
+ 0.00 0.86 0.36 22214286
+ 0.00 0.86 0.36 29285714
+ 0.00 0.86 0.36 36357143
+ 0.00 0.86 0.36 43428571
+ 0.00 0.86 0.36 50500000
+ 0.00 0.86 0.36 57571429
+ 0.00 0.86 0.36 64642857
+ 0.00 0.86 0.36 71714286
+ 0.00 0.86 0.36 78785714
+ 0.00 0.86 0.36 85857143
+ 0.00 0.86 0.36 92928571
+ 0.00 0.86 0.36 100000000
+ 0.00 0.86 0.43 1000000
+ 0.00 0.86 0.43 8071429
+ 0.00 0.86 0.43 15142857
+ 0.00 0.86 0.43 22214286
+ 0.00 0.86 0.43 29285714
+ 0.00 0.86 0.43 36357143
+ 0.00 0.86 0.43 43428571
+ 0.00 0.86 0.43 50500000
+ 0.00 0.86 0.43 57571429
+ 0.00 0.86 0.43 64642857
+ 0.00 0.86 0.43 71714286
+ 0.00 0.86 0.43 78785714
+ 0.00 0.86 0.43 85857143
+ 0.00 0.86 0.43 92928571
+ 0.00 0.86 0.43 100000000
+ 0.00 0.86 0.50 1000000
+ 0.00 0.86 0.50 8071429
+ 0.00 0.86 0.50 15142857
+ 0.00 0.86 0.50 22214286
+ 0.00 0.86 0.50 29285714
+ 0.00 0.86 0.50 36357143
+ 0.00 0.86 0.50 43428571
+ 0.00 0.86 0.50 50500000
+ 0.00 0.86 0.50 57571429
+ 0.00 0.86 0.50 64642857
+ 0.00 0.86 0.50 71714286
+ 0.00 0.86 0.50 78785714
+ 0.00 0.86 0.50 85857143
+ 0.00 0.86 0.50 92928571
+ 0.00 0.86 0.50 100000000
+ 0.00 0.86 0.57 1000000
+ 0.00 0.86 0.57 8071429
+ 0.00 0.86 0.57 15142857
+ 0.00 0.86 0.57 22214286
+ 0.00 0.86 0.57 29285714
+ 0.00 0.86 0.57 36357143
+ 0.00 0.86 0.57 43428571
+ 0.00 0.86 0.57 50500000
+ 0.00 0.86 0.57 57571429
+ 0.00 0.86 0.57 64642857
+ 0.00 0.86 0.57 71714286
+ 0.00 0.86 0.57 78785714
+ 0.00 0.86 0.57 85857143
+ 0.00 0.86 0.57 92928571
+ 0.00 0.86 0.57 100000000
+ 0.00 0.86 0.64 1000000
+ 0.00 0.86 0.64 8071429
+ 0.00 0.86 0.64 15142857
+ 0.00 0.86 0.64 22214286
+ 0.00 0.86 0.64 29285714
+ 0.00 0.86 0.64 36357143
+ 0.00 0.86 0.64 43428571
+ 0.00 0.86 0.64 50500000
+ 0.00 0.86 0.64 57571429
+ 0.00 0.86 0.64 64642857
+ 0.00 0.86 0.64 71714286
+ 0.00 0.86 0.64 78785714
+ 0.00 0.86 0.64 85857143
+ 0.00 0.86 0.64 92928571
+ 0.00 0.86 0.64 100000000
+ 0.00 0.86 0.71 1000000
+ 0.00 0.86 0.71 8071429
+ 0.00 0.86 0.71 15142857
+ 0.00 0.86 0.71 22214286
+ 0.00 0.86 0.71 29285714
+ 0.00 0.86 0.71 36357143
+ 0.00 0.86 0.71 43428571
+ 0.00 0.86 0.71 50500000
+ 0.00 0.86 0.71 57571429
+ 0.00 0.86 0.71 64642857
+ 0.00 0.86 0.71 71714286
+ 0.00 0.86 0.71 78785714
+ 0.00 0.86 0.71 85857143
+ 0.00 0.86 0.71 92928571
+ 0.00 0.86 0.71 100000000
+ 0.00 0.86 0.79 1000000
+ 0.00 0.86 0.79 8071429
+ 0.00 0.86 0.79 15142857
+ 0.00 0.86 0.79 22214286
+ 0.00 0.86 0.79 29285714
+ 0.00 0.86 0.79 36357143
+ 0.00 0.86 0.79 43428571
+ 0.00 0.86 0.79 50500000
+ 0.00 0.86 0.79 57571429
+ 0.00 0.86 0.79 64642857
+ 0.00 0.86 0.79 71714286
+ 0.00 0.86 0.79 78785714
+ 0.00 0.86 0.79 85857143
+ 0.00 0.86 0.79 92928571
+ 0.00 0.86 0.79 100000000
+ 0.00 0.86 0.86 1000000
+ 0.00 0.86 0.86 8071429
+ 0.00 0.86 0.86 15142857
+ 0.00 0.86 0.86 22214286
+ 0.00 0.86 0.86 29285714
+ 0.00 0.86 0.86 36357143
+ 0.00 0.86 0.86 43428571
+ 0.00 0.86 0.86 50500000
+ 0.00 0.86 0.86 57571429
+ 0.00 0.86 0.86 64642857
+ 0.00 0.86 0.86 71714286
+ 0.00 0.86 0.86 78785714
+ 0.00 0.86 0.86 85857143
+ 0.00 0.86 0.86 92928571
+ 0.00 0.86 0.86 100000000
+ 0.00 0.86 0.93 1000000
+ 0.00 0.86 0.93 8071429
+ 0.00 0.86 0.93 15142857
+ 0.00 0.86 0.93 22214286
+ 0.00 0.86 0.93 29285714
+ 0.00 0.86 0.93 36357143
+ 0.00 0.86 0.93 43428571
+ 0.00 0.86 0.93 50500000
+ 0.00 0.86 0.93 57571429
+ 0.00 0.86 0.93 64642857
+ 0.00 0.86 0.93 71714286
+ 0.00 0.86 0.93 78785714
+ 0.00 0.86 0.93 85857143
+ 0.00 0.86 0.93 92928571
+ 0.00 0.86 0.93 100000000
+ 0.00 0.86 1.00 1000000
+ 0.00 0.86 1.00 8071429
+ 0.00 0.86 1.00 15142857
+ 0.00 0.86 1.00 22214286
+ 0.00 0.86 1.00 29285714
+ 0.00 0.86 1.00 36357143
+ 0.00 0.86 1.00 43428571
+ 0.00 0.86 1.00 50500000
+ 0.00 0.86 1.00 57571429
+ 0.00 0.86 1.00 64642857
+ 0.00 0.86 1.00 71714286
+ 0.00 0.86 1.00 78785714
+ 0.00 0.86 1.00 85857143
+ 0.00 0.86 1.00 92928571
+ 0.00 0.86 1.00 100000000
+ 0.00 0.93 0.00 1000000
+ 0.00 0.93 0.00 8071429
+ 0.00 0.93 0.00 15142857
+ 0.00 0.93 0.00 22214286
+ 0.00 0.93 0.00 29285714
+ 0.00 0.93 0.00 36357143
+ 0.00 0.93 0.00 43428571
+ 0.00 0.93 0.00 50500000
+ 0.00 0.93 0.00 57571429
+ 0.00 0.93 0.00 64642857
+ 0.00 0.93 0.00 71714286
+ 0.00 0.93 0.00 78785714
+ 0.00 0.93 0.00 85857143
+ 0.00 0.93 0.00 92928571
+ 0.00 0.93 0.00 100000000
+ 0.00 0.93 0.07 1000000
+ 0.00 0.93 0.07 8071429
+ 0.00 0.93 0.07 15142857
+ 0.00 0.93 0.07 22214286
+ 0.00 0.93 0.07 29285714
+ 0.00 0.93 0.07 36357143
+ 0.00 0.93 0.07 43428571
+ 0.00 0.93 0.07 50500000
+ 0.00 0.93 0.07 57571429
+ 0.00 0.93 0.07 64642857
+ 0.00 0.93 0.07 71714286
+ 0.00 0.93 0.07 78785714
+ 0.00 0.93 0.07 85857143
+ 0.00 0.93 0.07 92928571
+ 0.00 0.93 0.07 100000000
+ 0.00 0.93 0.14 1000000
+ 0.00 0.93 0.14 8071429
+ 0.00 0.93 0.14 15142857
+ 0.00 0.93 0.14 22214286
+ 0.00 0.93 0.14 29285714
+ 0.00 0.93 0.14 36357143
+ 0.00 0.93 0.14 43428571
+ 0.00 0.93 0.14 50500000
+ 0.00 0.93 0.14 57571429
+ 0.00 0.93 0.14 64642857
+ 0.00 0.93 0.14 71714286
+ 0.00 0.93 0.14 78785714
+ 0.00 0.93 0.14 85857143
+ 0.00 0.93 0.14 92928571
+ 0.00 0.93 0.14 100000000
+ 0.00 0.93 0.21 1000000
+ 0.00 0.93 0.21 8071429
+ 0.00 0.93 0.21 15142857
+ 0.00 0.93 0.21 22214286
+ 0.00 0.93 0.21 29285714
+ 0.00 0.93 0.21 36357143
+ 0.00 0.93 0.21 43428571
+ 0.00 0.93 0.21 50500000
+ 0.00 0.93 0.21 57571429
+ 0.00 0.93 0.21 64642857
+ 0.00 0.93 0.21 71714286
+ 0.00 0.93 0.21 78785714
+ 0.00 0.93 0.21 85857143
+ 0.00 0.93 0.21 92928571
+ 0.00 0.93 0.21 100000000
+ 0.00 0.93 0.29 1000000
+ 0.00 0.93 0.29 8071429
+ 0.00 0.93 0.29 15142857
+ 0.00 0.93 0.29 22214286
+ 0.00 0.93 0.29 29285714
+ 0.00 0.93 0.29 36357143
+ 0.00 0.93 0.29 43428571
+ 0.00 0.93 0.29 50500000
+ 0.00 0.93 0.29 57571429
+ 0.00 0.93 0.29 64642857
+ 0.00 0.93 0.29 71714286
+ 0.00 0.93 0.29 78785714
+ 0.00 0.93 0.29 85857143
+ 0.00 0.93 0.29 92928571
+ 0.00 0.93 0.29 100000000
+ 0.00 0.93 0.36 1000000
+ 0.00 0.93 0.36 8071429
+ 0.00 0.93 0.36 15142857
+ 0.00 0.93 0.36 22214286
+ 0.00 0.93 0.36 29285714
+ 0.00 0.93 0.36 36357143
+ 0.00 0.93 0.36 43428571
+ 0.00 0.93 0.36 50500000
+ 0.00 0.93 0.36 57571429
+ 0.00 0.93 0.36 64642857
+ 0.00 0.93 0.36 71714286
+ 0.00 0.93 0.36 78785714
+ 0.00 0.93 0.36 85857143
+ 0.00 0.93 0.36 92928571
+ 0.00 0.93 0.36 100000000
+ 0.00 0.93 0.43 1000000
+ 0.00 0.93 0.43 8071429
+ 0.00 0.93 0.43 15142857
+ 0.00 0.93 0.43 22214286
+ 0.00 0.93 0.43 29285714
+ 0.00 0.93 0.43 36357143
+ 0.00 0.93 0.43 43428571
+ 0.00 0.93 0.43 50500000
+ 0.00 0.93 0.43 57571429
+ 0.00 0.93 0.43 64642857
+ 0.00 0.93 0.43 71714286
+ 0.00 0.93 0.43 78785714
+ 0.00 0.93 0.43 85857143
+ 0.00 0.93 0.43 92928571
+ 0.00 0.93 0.43 100000000
+ 0.00 0.93 0.50 1000000
+ 0.00 0.93 0.50 8071429
+ 0.00 0.93 0.50 15142857
+ 0.00 0.93 0.50 22214286
+ 0.00 0.93 0.50 29285714
+ 0.00 0.93 0.50 36357143
+ 0.00 0.93 0.50 43428571
+ 0.00 0.93 0.50 50500000
+ 0.00 0.93 0.50 57571429
+ 0.00 0.93 0.50 64642857
+ 0.00 0.93 0.50 71714286
+ 0.00 0.93 0.50 78785714
+ 0.00 0.93 0.50 85857143
+ 0.00 0.93 0.50 92928571
+ 0.00 0.93 0.50 100000000
+ 0.00 0.93 0.57 1000000
+ 0.00 0.93 0.57 8071429
+ 0.00 0.93 0.57 15142857
+ 0.00 0.93 0.57 22214286
+ 0.00 0.93 0.57 29285714
+ 0.00 0.93 0.57 36357143
+ 0.00 0.93 0.57 43428571
+ 0.00 0.93 0.57 50500000
+ 0.00 0.93 0.57 57571429
+ 0.00 0.93 0.57 64642857
+ 0.00 0.93 0.57 71714286
+ 0.00 0.93 0.57 78785714
+ 0.00 0.93 0.57 85857143
+ 0.00 0.93 0.57 92928571
+ 0.00 0.93 0.57 100000000
+ 0.00 0.93 0.64 1000000
+ 0.00 0.93 0.64 8071429
+ 0.00 0.93 0.64 15142857
+ 0.00 0.93 0.64 22214286
+ 0.00 0.93 0.64 29285714
+ 0.00 0.93 0.64 36357143
+ 0.00 0.93 0.64 43428571
+ 0.00 0.93 0.64 50500000
+ 0.00 0.93 0.64 57571429
+ 0.00 0.93 0.64 64642857
+ 0.00 0.93 0.64 71714286
+ 0.00 0.93 0.64 78785714
+ 0.00 0.93 0.64 85857143
+ 0.00 0.93 0.64 92928571
+ 0.00 0.93 0.64 100000000
+ 0.00 0.93 0.71 1000000
+ 0.00 0.93 0.71 8071429
+ 0.00 0.93 0.71 15142857
+ 0.00 0.93 0.71 22214286
+ 0.00 0.93 0.71 29285714
+ 0.00 0.93 0.71 36357143
+ 0.00 0.93 0.71 43428571
+ 0.00 0.93 0.71 50500000
+ 0.00 0.93 0.71 57571429
+ 0.00 0.93 0.71 64642857
+ 0.00 0.93 0.71 71714286
+ 0.00 0.93 0.71 78785714
+ 0.00 0.93 0.71 85857143
+ 0.00 0.93 0.71 92928571
+ 0.00 0.93 0.71 100000000
+ 0.00 0.93 0.79 1000000
+ 0.00 0.93 0.79 8071429
+ 0.00 0.93 0.79 15142857
+ 0.00 0.93 0.79 22214286
+ 0.00 0.93 0.79 29285714
+ 0.00 0.93 0.79 36357143
+ 0.00 0.93 0.79 43428571
+ 0.00 0.93 0.79 50500000
+ 0.00 0.93 0.79 57571429
+ 0.00 0.93 0.79 64642857
+ 0.00 0.93 0.79 71714286
+ 0.00 0.93 0.79 78785714
+ 0.00 0.93 0.79 85857143
+ 0.00 0.93 0.79 92928571
+ 0.00 0.93 0.79 100000000
+ 0.00 0.93 0.86 1000000
+ 0.00 0.93 0.86 8071429
+ 0.00 0.93 0.86 15142857
+ 0.00 0.93 0.86 22214286
+ 0.00 0.93 0.86 29285714
+ 0.00 0.93 0.86 36357143
+ 0.00 0.93 0.86 43428571
+ 0.00 0.93 0.86 50500000
+ 0.00 0.93 0.86 57571429
+ 0.00 0.93 0.86 64642857
+ 0.00 0.93 0.86 71714286
+ 0.00 0.93 0.86 78785714
+ 0.00 0.93 0.86 85857143
+ 0.00 0.93 0.86 92928571
+ 0.00 0.93 0.86 100000000
+ 0.00 0.93 0.93 1000000
+ 0.00 0.93 0.93 8071429
+ 0.00 0.93 0.93 15142857
+ 0.00 0.93 0.93 22214286
+ 0.00 0.93 0.93 29285714
+ 0.00 0.93 0.93 36357143
+ 0.00 0.93 0.93 43428571
+ 0.00 0.93 0.93 50500000
+ 0.00 0.93 0.93 57571429
+ 0.00 0.93 0.93 64642857
+ 0.00 0.93 0.93 71714286
+ 0.00 0.93 0.93 78785714
+ 0.00 0.93 0.93 85857143
+ 0.00 0.93 0.93 92928571
+ 0.00 0.93 0.93 100000000
+ 0.00 0.93 1.00 1000000
+ 0.00 0.93 1.00 8071429
+ 0.00 0.93 1.00 15142857
+ 0.00 0.93 1.00 22214286
+ 0.00 0.93 1.00 29285714
+ 0.00 0.93 1.00 36357143
+ 0.00 0.93 1.00 43428571
+ 0.00 0.93 1.00 50500000
+ 0.00 0.93 1.00 57571429
+ 0.00 0.93 1.00 64642857
+ 0.00 0.93 1.00 71714286
+ 0.00 0.93 1.00 78785714
+ 0.00 0.93 1.00 85857143
+ 0.00 0.93 1.00 92928571
+ 0.00 0.93 1.00 100000000
+ 0.00 1.00 0.00 1000000
+ 0.00 1.00 0.00 8071429
+ 0.00 1.00 0.00 15142857
+ 0.00 1.00 0.00 22214286
+ 0.00 1.00 0.00 29285714
+ 0.00 1.00 0.00 36357143
+ 0.00 1.00 0.00 43428571
+ 0.00 1.00 0.00 50500000
+ 0.00 1.00 0.00 57571429
+ 0.00 1.00 0.00 64642857
+ 0.00 1.00 0.00 71714286
+ 0.00 1.00 0.00 78785714
+ 0.00 1.00 0.00 85857143
+ 0.00 1.00 0.00 92928571
+ 0.00 1.00 0.00 100000000
+ 0.00 1.00 0.07 1000000
+ 0.00 1.00 0.07 8071429
+ 0.00 1.00 0.07 15142857
+ 0.00 1.00 0.07 22214286
+ 0.00 1.00 0.07 29285714
+ 0.00 1.00 0.07 36357143
+ 0.00 1.00 0.07 43428571
+ 0.00 1.00 0.07 50500000
+ 0.00 1.00 0.07 57571429
+ 0.00 1.00 0.07 64642857
+ 0.00 1.00 0.07 71714286
+ 0.00 1.00 0.07 78785714
+ 0.00 1.00 0.07 85857143
+ 0.00 1.00 0.07 92928571
+ 0.00 1.00 0.07 100000000
+ 0.00 1.00 0.14 1000000
+ 0.00 1.00 0.14 8071429
+ 0.00 1.00 0.14 15142857
+ 0.00 1.00 0.14 22214286
+ 0.00 1.00 0.14 29285714
+ 0.00 1.00 0.14 36357143
+ 0.00 1.00 0.14 43428571
+ 0.00 1.00 0.14 50500000
+ 0.00 1.00 0.14 57571429
+ 0.00 1.00 0.14 64642857
+ 0.00 1.00 0.14 71714286
+ 0.00 1.00 0.14 78785714
+ 0.00 1.00 0.14 85857143
+ 0.00 1.00 0.14 92928571
+ 0.00 1.00 0.14 100000000
+ 0.00 1.00 0.21 1000000
+ 0.00 1.00 0.21 8071429
+ 0.00 1.00 0.21 15142857
+ 0.00 1.00 0.21 22214286
+ 0.00 1.00 0.21 29285714
+ 0.00 1.00 0.21 36357143
+ 0.00 1.00 0.21 43428571
+ 0.00 1.00 0.21 50500000
+ 0.00 1.00 0.21 57571429
+ 0.00 1.00 0.21 64642857
+ 0.00 1.00 0.21 71714286
+ 0.00 1.00 0.21 78785714
+ 0.00 1.00 0.21 85857143
+ 0.00 1.00 0.21 92928571
+ 0.00 1.00 0.21 100000000
+ 0.00 1.00 0.29 1000000
+ 0.00 1.00 0.29 8071429
+ 0.00 1.00 0.29 15142857
+ 0.00 1.00 0.29 22214286
+ 0.00 1.00 0.29 29285714
+ 0.00 1.00 0.29 36357143
+ 0.00 1.00 0.29 43428571
+ 0.00 1.00 0.29 50500000
+ 0.00 1.00 0.29 57571429
+ 0.00 1.00 0.29 64642857
+ 0.00 1.00 0.29 71714286
+ 0.00 1.00 0.29 78785714
+ 0.00 1.00 0.29 85857143
+ 0.00 1.00 0.29 92928571
+ 0.00 1.00 0.29 100000000
+ 0.00 1.00 0.36 1000000
+ 0.00 1.00 0.36 8071429
+ 0.00 1.00 0.36 15142857
+ 0.00 1.00 0.36 22214286
+ 0.00 1.00 0.36 29285714
+ 0.00 1.00 0.36 36357143
+ 0.00 1.00 0.36 43428571
+ 0.00 1.00 0.36 50500000
+ 0.00 1.00 0.36 57571429
+ 0.00 1.00 0.36 64642857
+ 0.00 1.00 0.36 71714286
+ 0.00 1.00 0.36 78785714
+ 0.00 1.00 0.36 85857143
+ 0.00 1.00 0.36 92928571
+ 0.00 1.00 0.36 100000000
+ 0.00 1.00 0.43 1000000
+ 0.00 1.00 0.43 8071429
+ 0.00 1.00 0.43 15142857
+ 0.00 1.00 0.43 22214286
+ 0.00 1.00 0.43 29285714
+ 0.00 1.00 0.43 36357143
+ 0.00 1.00 0.43 43428571
+ 0.00 1.00 0.43 50500000
+ 0.00 1.00 0.43 57571429
+ 0.00 1.00 0.43 64642857
+ 0.00 1.00 0.43 71714286
+ 0.00 1.00 0.43 78785714
+ 0.00 1.00 0.43 85857143
+ 0.00 1.00 0.43 92928571
+ 0.00 1.00 0.43 100000000
+ 0.00 1.00 0.50 1000000
+ 0.00 1.00 0.50 8071429
+ 0.00 1.00 0.50 15142857
+ 0.00 1.00 0.50 22214286
+ 0.00 1.00 0.50 29285714
+ 0.00 1.00 0.50 36357143
+ 0.00 1.00 0.50 43428571
+ 0.00 1.00 0.50 50500000
+ 0.00 1.00 0.50 57571429
+ 0.00 1.00 0.50 64642857
+ 0.00 1.00 0.50 71714286
+ 0.00 1.00 0.50 78785714
+ 0.00 1.00 0.50 85857143
+ 0.00 1.00 0.50 92928571
+ 0.00 1.00 0.50 100000000
+ 0.00 1.00 0.57 1000000
+ 0.00 1.00 0.57 8071429
+ 0.00 1.00 0.57 15142857
+ 0.00 1.00 0.57 22214286
+ 0.00 1.00 0.57 29285714
+ 0.00 1.00 0.57 36357143
+ 0.00 1.00 0.57 43428571
+ 0.00 1.00 0.57 50500000
+ 0.00 1.00 0.57 57571429
+ 0.00 1.00 0.57 64642857
+ 0.00 1.00 0.57 71714286
+ 0.00 1.00 0.57 78785714
+ 0.00 1.00 0.57 85857143
+ 0.00 1.00 0.57 92928571
+ 0.00 1.00 0.57 100000000
+ 0.00 1.00 0.64 1000000
+ 0.00 1.00 0.64 8071429
+ 0.00 1.00 0.64 15142857
+ 0.00 1.00 0.64 22214286
+ 0.00 1.00 0.64 29285714
+ 0.00 1.00 0.64 36357143
+ 0.00 1.00 0.64 43428571
+ 0.00 1.00 0.64 50500000
+ 0.00 1.00 0.64 57571429
+ 0.00 1.00 0.64 64642857
+ 0.00 1.00 0.64 71714286
+ 0.00 1.00 0.64 78785714
+ 0.00 1.00 0.64 85857143
+ 0.00 1.00 0.64 92928571
+ 0.00 1.00 0.64 100000000
+ 0.00 1.00 0.71 1000000
+ 0.00 1.00 0.71 8071429
+ 0.00 1.00 0.71 15142857
+ 0.00 1.00 0.71 22214286
+ 0.00 1.00 0.71 29285714
+ 0.00 1.00 0.71 36357143
+ 0.00 1.00 0.71 43428571
+ 0.00 1.00 0.71 50500000
+ 0.00 1.00 0.71 57571429
+ 0.00 1.00 0.71 64642857
+ 0.00 1.00 0.71 71714286
+ 0.00 1.00 0.71 78785714
+ 0.00 1.00 0.71 85857143
+ 0.00 1.00 0.71 92928571
+ 0.00 1.00 0.71 100000000
+ 0.00 1.00 0.79 1000000
+ 0.00 1.00 0.79 8071429
+ 0.00 1.00 0.79 15142857
+ 0.00 1.00 0.79 22214286
+ 0.00 1.00 0.79 29285714
+ 0.00 1.00 0.79 36357143
+ 0.00 1.00 0.79 43428571
+ 0.00 1.00 0.79 50500000
+ 0.00 1.00 0.79 57571429
+ 0.00 1.00 0.79 64642857
+ 0.00 1.00 0.79 71714286
+ 0.00 1.00 0.79 78785714
+ 0.00 1.00 0.79 85857143
+ 0.00 1.00 0.79 92928571
+ 0.00 1.00 0.79 100000000
+ 0.00 1.00 0.86 1000000
+ 0.00 1.00 0.86 8071429
+ 0.00 1.00 0.86 15142857
+ 0.00 1.00 0.86 22214286
+ 0.00 1.00 0.86 29285714
+ 0.00 1.00 0.86 36357143
+ 0.00 1.00 0.86 43428571
+ 0.00 1.00 0.86 50500000
+ 0.00 1.00 0.86 57571429
+ 0.00 1.00 0.86 64642857
+ 0.00 1.00 0.86 71714286
+ 0.00 1.00 0.86 78785714
+ 0.00 1.00 0.86 85857143
+ 0.00 1.00 0.86 92928571
+ 0.00 1.00 0.86 100000000
+ 0.00 1.00 0.93 1000000
+ 0.00 1.00 0.93 8071429
+ 0.00 1.00 0.93 15142857
+ 0.00 1.00 0.93 22214286
+ 0.00 1.00 0.93 29285714
+ 0.00 1.00 0.93 36357143
+ 0.00 1.00 0.93 43428571
+ 0.00 1.00 0.93 50500000
+ 0.00 1.00 0.93 57571429
+ 0.00 1.00 0.93 64642857
+ 0.00 1.00 0.93 71714286
+ 0.00 1.00 0.93 78785714
+ 0.00 1.00 0.93 85857143
+ 0.00 1.00 0.93 92928571
+ 0.00 1.00 0.93 100000000
+ 0.00 1.00 1.00 1000000
+ 0.00 1.00 1.00 8071429
+ 0.00 1.00 1.00 15142857
+ 0.00 1.00 1.00 22214286
+ 0.00 1.00 1.00 29285714
+ 0.00 1.00 1.00 36357143
+ 0.00 1.00 1.00 43428571
+ 0.00 1.00 1.00 50500000
+ 0.00 1.00 1.00 57571429
+ 0.00 1.00 1.00 64642857
+ 0.00 1.00 1.00 71714286
+ 0.00 1.00 1.00 78785714
+ 0.00 1.00 1.00 85857143
+ 0.00 1.00 1.00 92928571
+ 0.00 1.00 1.00 100000000
+ 0.07 0.00 0.00 1000000
+ 0.07 0.00 0.00 8071429
+ 0.07 0.00 0.00 15142857
+ 0.07 0.00 0.00 22214286
+ 0.07 0.00 0.00 29285714
+ 0.07 0.00 0.00 36357143
+ 0.07 0.00 0.00 43428571
+ 0.07 0.00 0.00 50500000
+ 0.07 0.00 0.00 57571429
+ 0.07 0.00 0.00 64642857
+ 0.07 0.00 0.00 71714286
+ 0.07 0.00 0.00 78785714
+ 0.07 0.00 0.00 85857143
+ 0.07 0.00 0.00 92928571
+ 0.07 0.00 0.00 100000000
+ 0.07 0.00 0.07 1000000
+ 0.07 0.00 0.07 8071429
+ 0.07 0.00 0.07 15142857
+ 0.07 0.00 0.07 22214286
+ 0.07 0.00 0.07 29285714
+ 0.07 0.00 0.07 36357143
+ 0.07 0.00 0.07 43428571
+ 0.07 0.00 0.07 50500000
+ 0.07 0.00 0.07 57571429
+ 0.07 0.00 0.07 64642857
+ 0.07 0.00 0.07 71714286
+ 0.07 0.00 0.07 78785714
+ 0.07 0.00 0.07 85857143
+ 0.07 0.00 0.07 92928571
+ 0.07 0.00 0.07 100000000
+ 0.07 0.00 0.14 1000000
+ 0.07 0.00 0.14 8071429
+ 0.07 0.00 0.14 15142857
+ 0.07 0.00 0.14 22214286
+ 0.07 0.00 0.14 29285714
+ 0.07 0.00 0.14 36357143
+ 0.07 0.00 0.14 43428571
+ 0.07 0.00 0.14 50500000
+ 0.07 0.00 0.14 57571429
+ 0.07 0.00 0.14 64642857
+ 0.07 0.00 0.14 71714286
+ 0.07 0.00 0.14 78785714
+ 0.07 0.00 0.14 85857143
+ 0.07 0.00 0.14 92928571
+ 0.07 0.00 0.14 100000000
+ 0.07 0.00 0.21 1000000
+ 0.07 0.00 0.21 8071429
+ 0.07 0.00 0.21 15142857
+ 0.07 0.00 0.21 22214286
+ 0.07 0.00 0.21 29285714
+ 0.07 0.00 0.21 36357143
+ 0.07 0.00 0.21 43428571
+ 0.07 0.00 0.21 50500000
+ 0.07 0.00 0.21 57571429
+ 0.07 0.00 0.21 64642857
+ 0.07 0.00 0.21 71714286
+ 0.07 0.00 0.21 78785714
+ 0.07 0.00 0.21 85857143
+ 0.07 0.00 0.21 92928571
+ 0.07 0.00 0.21 100000000
+ 0.07 0.00 0.29 1000000
+ 0.07 0.00 0.29 8071429
+ 0.07 0.00 0.29 15142857
+ 0.07 0.00 0.29 22214286
+ 0.07 0.00 0.29 29285714
+ 0.07 0.00 0.29 36357143
+ 0.07 0.00 0.29 43428571
+ 0.07 0.00 0.29 50500000
+ 0.07 0.00 0.29 57571429
+ 0.07 0.00 0.29 64642857
+ 0.07 0.00 0.29 71714286
+ 0.07 0.00 0.29 78785714
+ 0.07 0.00 0.29 85857143
+ 0.07 0.00 0.29 92928571
+ 0.07 0.00 0.29 100000000
+ 0.07 0.00 0.36 1000000
+ 0.07 0.00 0.36 8071429
+ 0.07 0.00 0.36 15142857
+ 0.07 0.00 0.36 22214286
+ 0.07 0.00 0.36 29285714
+ 0.07 0.00 0.36 36357143
+ 0.07 0.00 0.36 43428571
+ 0.07 0.00 0.36 50500000
+ 0.07 0.00 0.36 57571429
+ 0.07 0.00 0.36 64642857
+ 0.07 0.00 0.36 71714286
+ 0.07 0.00 0.36 78785714
+ 0.07 0.00 0.36 85857143
+ 0.07 0.00 0.36 92928571
+ 0.07 0.00 0.36 100000000
+ 0.07 0.00 0.43 1000000
+ 0.07 0.00 0.43 8071429
+ 0.07 0.00 0.43 15142857
+ 0.07 0.00 0.43 22214286
+ 0.07 0.00 0.43 29285714
+ 0.07 0.00 0.43 36357143
+ 0.07 0.00 0.43 43428571
+ 0.07 0.00 0.43 50500000
+ 0.07 0.00 0.43 57571429
+ 0.07 0.00 0.43 64642857
+ 0.07 0.00 0.43 71714286
+ 0.07 0.00 0.43 78785714
+ 0.07 0.00 0.43 85857143
+ 0.07 0.00 0.43 92928571
+ 0.07 0.00 0.43 100000000
+ 0.07 0.00 0.50 1000000
+ 0.07 0.00 0.50 8071429
+ 0.07 0.00 0.50 15142857
+ 0.07 0.00 0.50 22214286
+ 0.07 0.00 0.50 29285714
+ 0.07 0.00 0.50 36357143
+ 0.07 0.00 0.50 43428571
+ 0.07 0.00 0.50 50500000
+ 0.07 0.00 0.50 57571429
+ 0.07 0.00 0.50 64642857
+ 0.07 0.00 0.50 71714286
+ 0.07 0.00 0.50 78785714
+ 0.07 0.00 0.50 85857143
+ 0.07 0.00 0.50 92928571
+ 0.07 0.00 0.50 100000000
+ 0.07 0.00 0.57 1000000
+ 0.07 0.00 0.57 8071429
+ 0.07 0.00 0.57 15142857
+ 0.07 0.00 0.57 22214286
+ 0.07 0.00 0.57 29285714
+ 0.07 0.00 0.57 36357143
+ 0.07 0.00 0.57 43428571
+ 0.07 0.00 0.57 50500000
+ 0.07 0.00 0.57 57571429
+ 0.07 0.00 0.57 64642857
+ 0.07 0.00 0.57 71714286
+ 0.07 0.00 0.57 78785714
+ 0.07 0.00 0.57 85857143
+ 0.07 0.00 0.57 92928571
+ 0.07 0.00 0.57 100000000
+ 0.07 0.00 0.64 1000000
+ 0.07 0.00 0.64 8071429
+ 0.07 0.00 0.64 15142857
+ 0.07 0.00 0.64 22214286
+ 0.07 0.00 0.64 29285714
+ 0.07 0.00 0.64 36357143
+ 0.07 0.00 0.64 43428571
+ 0.07 0.00 0.64 50500000
+ 0.07 0.00 0.64 57571429
+ 0.07 0.00 0.64 64642857
+ 0.07 0.00 0.64 71714286
+ 0.07 0.00 0.64 78785714
+ 0.07 0.00 0.64 85857143
+ 0.07 0.00 0.64 92928571
+ 0.07 0.00 0.64 100000000
+ 0.07 0.00 0.71 1000000
+ 0.07 0.00 0.71 8071429
+ 0.07 0.00 0.71 15142857
+ 0.07 0.00 0.71 22214286
+ 0.07 0.00 0.71 29285714
+ 0.07 0.00 0.71 36357143
+ 0.07 0.00 0.71 43428571
+ 0.07 0.00 0.71 50500000
+ 0.07 0.00 0.71 57571429
+ 0.07 0.00 0.71 64642857
+ 0.07 0.00 0.71 71714286
+ 0.07 0.00 0.71 78785714
+ 0.07 0.00 0.71 85857143
+ 0.07 0.00 0.71 92928571
+ 0.07 0.00 0.71 100000000
+ 0.07 0.00 0.79 1000000
+ 0.07 0.00 0.79 8071429
+ 0.07 0.00 0.79 15142857
+ 0.07 0.00 0.79 22214286
+ 0.07 0.00 0.79 29285714
+ 0.07 0.00 0.79 36357143
+ 0.07 0.00 0.79 43428571
+ 0.07 0.00 0.79 50500000
+ 0.07 0.00 0.79 57571429
+ 0.07 0.00 0.79 64642857
+ 0.07 0.00 0.79 71714286
+ 0.07 0.00 0.79 78785714
+ 0.07 0.00 0.79 85857143
+ 0.07 0.00 0.79 92928571
+ 0.07 0.00 0.79 100000000
+ 0.07 0.00 0.86 1000000
+ 0.07 0.00 0.86 8071429
+ 0.07 0.00 0.86 15142857
+ 0.07 0.00 0.86 22214286
+ 0.07 0.00 0.86 29285714
+ 0.07 0.00 0.86 36357143
+ 0.07 0.00 0.86 43428571
+ 0.07 0.00 0.86 50500000
+ 0.07 0.00 0.86 57571429
+ 0.07 0.00 0.86 64642857
+ 0.07 0.00 0.86 71714286
+ 0.07 0.00 0.86 78785714
+ 0.07 0.00 0.86 85857143
+ 0.07 0.00 0.86 92928571
+ 0.07 0.00 0.86 100000000
+ 0.07 0.00 0.93 1000000
+ 0.07 0.00 0.93 8071429
+ 0.07 0.00 0.93 15142857
+ 0.07 0.00 0.93 22214286
+ 0.07 0.00 0.93 29285714
+ 0.07 0.00 0.93 36357143
+ 0.07 0.00 0.93 43428571
+ 0.07 0.00 0.93 50500000
+ 0.07 0.00 0.93 57571429
+ 0.07 0.00 0.93 64642857
+ 0.07 0.00 0.93 71714286
+ 0.07 0.00 0.93 78785714
+ 0.07 0.00 0.93 85857143
+ 0.07 0.00 0.93 92928571
+ 0.07 0.00 0.93 100000000
+ 0.07 0.00 1.00 1000000
+ 0.07 0.00 1.00 8071429
+ 0.07 0.00 1.00 15142857
+ 0.07 0.00 1.00 22214286
+ 0.07 0.00 1.00 29285714
+ 0.07 0.00 1.00 36357143
+ 0.07 0.00 1.00 43428571
+ 0.07 0.00 1.00 50500000
+ 0.07 0.00 1.00 57571429
+ 0.07 0.00 1.00 64642857
+ 0.07 0.00 1.00 71714286
+ 0.07 0.00 1.00 78785714
+ 0.07 0.00 1.00 85857143
+ 0.07 0.00 1.00 92928571
+ 0.07 0.00 1.00 100000000
+ 0.07 0.07 0.00 1000000
+ 0.07 0.07 0.00 8071429
+ 0.07 0.07 0.00 15142857
+ 0.07 0.07 0.00 22214286
+ 0.07 0.07 0.00 29285714
+ 0.07 0.07 0.00 36357143
+ 0.07 0.07 0.00 43428571
+ 0.07 0.07 0.00 50500000
+ 0.07 0.07 0.00 57571429
+ 0.07 0.07 0.00 64642857
+ 0.07 0.07 0.00 71714286
+ 0.07 0.07 0.00 78785714
+ 0.07 0.07 0.00 85857143
+ 0.07 0.07 0.00 92928571
+ 0.07 0.07 0.00 100000000
+ 0.07 0.07 0.07 1000000
+ 0.07 0.07 0.07 8071429
+ 0.07 0.07 0.07 15142857
+ 0.07 0.07 0.07 22214286
+ 0.07 0.07 0.07 29285714
+ 0.07 0.07 0.07 36357143
+ 0.07 0.07 0.07 43428571
+ 0.07 0.07 0.07 50500000
+ 0.07 0.07 0.07 57571429
+ 0.07 0.07 0.07 64642857
+ 0.07 0.07 0.07 71714286
+ 0.07 0.07 0.07 78785714
+ 0.07 0.07 0.07 85857143
+ 0.07 0.07 0.07 92928571
+ 0.07 0.07 0.07 100000000
+ 0.07 0.07 0.14 1000000
+ 0.07 0.07 0.14 8071429
+ 0.07 0.07 0.14 15142857
+ 0.07 0.07 0.14 22214286
+ 0.07 0.07 0.14 29285714
+ 0.07 0.07 0.14 36357143
+ 0.07 0.07 0.14 43428571
+ 0.07 0.07 0.14 50500000
+ 0.07 0.07 0.14 57571429
+ 0.07 0.07 0.14 64642857
+ 0.07 0.07 0.14 71714286
+ 0.07 0.07 0.14 78785714
+ 0.07 0.07 0.14 85857143
+ 0.07 0.07 0.14 92928571
+ 0.07 0.07 0.14 100000000
+ 0.07 0.07 0.21 1000000
+ 0.07 0.07 0.21 8071429
+ 0.07 0.07 0.21 15142857
+ 0.07 0.07 0.21 22214286
+ 0.07 0.07 0.21 29285714
+ 0.07 0.07 0.21 36357143
+ 0.07 0.07 0.21 43428571
+ 0.07 0.07 0.21 50500000
+ 0.07 0.07 0.21 57571429
+ 0.07 0.07 0.21 64642857
+ 0.07 0.07 0.21 71714286
+ 0.07 0.07 0.21 78785714
+ 0.07 0.07 0.21 85857143
+ 0.07 0.07 0.21 92928571
+ 0.07 0.07 0.21 100000000
+ 0.07 0.07 0.29 1000000
+ 0.07 0.07 0.29 8071429
+ 0.07 0.07 0.29 15142857
+ 0.07 0.07 0.29 22214286
+ 0.07 0.07 0.29 29285714
+ 0.07 0.07 0.29 36357143
+ 0.07 0.07 0.29 43428571
+ 0.07 0.07 0.29 50500000
+ 0.07 0.07 0.29 57571429
+ 0.07 0.07 0.29 64642857
+ 0.07 0.07 0.29 71714286
+ 0.07 0.07 0.29 78785714
+ 0.07 0.07 0.29 85857143
+ 0.07 0.07 0.29 92928571
+ 0.07 0.07 0.29 100000000
+ 0.07 0.07 0.36 1000000
+ 0.07 0.07 0.36 8071429
+ 0.07 0.07 0.36 15142857
+ 0.07 0.07 0.36 22214286
+ 0.07 0.07 0.36 29285714
+ 0.07 0.07 0.36 36357143
+ 0.07 0.07 0.36 43428571
+ 0.07 0.07 0.36 50500000
+ 0.07 0.07 0.36 57571429
+ 0.07 0.07 0.36 64642857
+ 0.07 0.07 0.36 71714286
+ 0.07 0.07 0.36 78785714
+ 0.07 0.07 0.36 85857143
+ 0.07 0.07 0.36 92928571
+ 0.07 0.07 0.36 100000000
+ 0.07 0.07 0.43 1000000
+ 0.07 0.07 0.43 8071429
+ 0.07 0.07 0.43 15142857
+ 0.07 0.07 0.43 22214286
+ 0.07 0.07 0.43 29285714
+ 0.07 0.07 0.43 36357143
+ 0.07 0.07 0.43 43428571
+ 0.07 0.07 0.43 50500000
+ 0.07 0.07 0.43 57571429
+ 0.07 0.07 0.43 64642857
+ 0.07 0.07 0.43 71714286
+ 0.07 0.07 0.43 78785714
+ 0.07 0.07 0.43 85857143
+ 0.07 0.07 0.43 92928571
+ 0.07 0.07 0.43 100000000
+ 0.07 0.07 0.50 1000000
+ 0.07 0.07 0.50 8071429
+ 0.07 0.07 0.50 15142857
+ 0.07 0.07 0.50 22214286
+ 0.07 0.07 0.50 29285714
+ 0.07 0.07 0.50 36357143
+ 0.07 0.07 0.50 43428571
+ 0.07 0.07 0.50 50500000
+ 0.07 0.07 0.50 57571429
+ 0.07 0.07 0.50 64642857
+ 0.07 0.07 0.50 71714286
+ 0.07 0.07 0.50 78785714
+ 0.07 0.07 0.50 85857143
+ 0.07 0.07 0.50 92928571
+ 0.07 0.07 0.50 100000000
+ 0.07 0.07 0.57 1000000
+ 0.07 0.07 0.57 8071429
+ 0.07 0.07 0.57 15142857
+ 0.07 0.07 0.57 22214286
+ 0.07 0.07 0.57 29285714
+ 0.07 0.07 0.57 36357143
+ 0.07 0.07 0.57 43428571
+ 0.07 0.07 0.57 50500000
+ 0.07 0.07 0.57 57571429
+ 0.07 0.07 0.57 64642857
+ 0.07 0.07 0.57 71714286
+ 0.07 0.07 0.57 78785714
+ 0.07 0.07 0.57 85857143
+ 0.07 0.07 0.57 92928571
+ 0.07 0.07 0.57 100000000
+ 0.07 0.07 0.64 1000000
+ 0.07 0.07 0.64 8071429
+ 0.07 0.07 0.64 15142857
+ 0.07 0.07 0.64 22214286
+ 0.07 0.07 0.64 29285714
+ 0.07 0.07 0.64 36357143
+ 0.07 0.07 0.64 43428571
+ 0.07 0.07 0.64 50500000
+ 0.07 0.07 0.64 57571429
+ 0.07 0.07 0.64 64642857
+ 0.07 0.07 0.64 71714286
+ 0.07 0.07 0.64 78785714
+ 0.07 0.07 0.64 85857143
+ 0.07 0.07 0.64 92928571
+ 0.07 0.07 0.64 100000000
+ 0.07 0.07 0.71 1000000
+ 0.07 0.07 0.71 8071429
+ 0.07 0.07 0.71 15142857
+ 0.07 0.07 0.71 22214286
+ 0.07 0.07 0.71 29285714
+ 0.07 0.07 0.71 36357143
+ 0.07 0.07 0.71 43428571
+ 0.07 0.07 0.71 50500000
+ 0.07 0.07 0.71 57571429
+ 0.07 0.07 0.71 64642857
+ 0.07 0.07 0.71 71714286
+ 0.07 0.07 0.71 78785714
+ 0.07 0.07 0.71 85857143
+ 0.07 0.07 0.71 92928571
+ 0.07 0.07 0.71 100000000
+ 0.07 0.07 0.79 1000000
+ 0.07 0.07 0.79 8071429
+ 0.07 0.07 0.79 15142857
+ 0.07 0.07 0.79 22214286
+ 0.07 0.07 0.79 29285714
+ 0.07 0.07 0.79 36357143
+ 0.07 0.07 0.79 43428571
+ 0.07 0.07 0.79 50500000
+ 0.07 0.07 0.79 57571429
+ 0.07 0.07 0.79 64642857
+ 0.07 0.07 0.79 71714286
+ 0.07 0.07 0.79 78785714
+ 0.07 0.07 0.79 85857143
+ 0.07 0.07 0.79 92928571
+ 0.07 0.07 0.79 100000000
+ 0.07 0.07 0.86 1000000
+ 0.07 0.07 0.86 8071429
+ 0.07 0.07 0.86 15142857
+ 0.07 0.07 0.86 22214286
+ 0.07 0.07 0.86 29285714
+ 0.07 0.07 0.86 36357143
+ 0.07 0.07 0.86 43428571
+ 0.07 0.07 0.86 50500000
+ 0.07 0.07 0.86 57571429
+ 0.07 0.07 0.86 64642857
+ 0.07 0.07 0.86 71714286
+ 0.07 0.07 0.86 78785714
+ 0.07 0.07 0.86 85857143
+ 0.07 0.07 0.86 92928571
+ 0.07 0.07 0.86 100000000
+ 0.07 0.07 0.93 1000000
+ 0.07 0.07 0.93 8071429
+ 0.07 0.07 0.93 15142857
+ 0.07 0.07 0.93 22214286
+ 0.07 0.07 0.93 29285714
+ 0.07 0.07 0.93 36357143
+ 0.07 0.07 0.93 43428571
+ 0.07 0.07 0.93 50500000
+ 0.07 0.07 0.93 57571429
+ 0.07 0.07 0.93 64642857
+ 0.07 0.07 0.93 71714286
+ 0.07 0.07 0.93 78785714
+ 0.07 0.07 0.93 85857143
+ 0.07 0.07 0.93 92928571
+ 0.07 0.07 0.93 100000000
+ 0.07 0.07 1.00 1000000
+ 0.07 0.07 1.00 8071429
+ 0.07 0.07 1.00 15142857
+ 0.07 0.07 1.00 22214286
+ 0.07 0.07 1.00 29285714
+ 0.07 0.07 1.00 36357143
+ 0.07 0.07 1.00 43428571
+ 0.07 0.07 1.00 50500000
+ 0.07 0.07 1.00 57571429
+ 0.07 0.07 1.00 64642857
+ 0.07 0.07 1.00 71714286
+ 0.07 0.07 1.00 78785714
+ 0.07 0.07 1.00 85857143
+ 0.07 0.07 1.00 92928571
+ 0.07 0.07 1.00 100000000
+ 0.07 0.14 0.00 1000000
+ 0.07 0.14 0.00 8071429
+ 0.07 0.14 0.00 15142857
+ 0.07 0.14 0.00 22214286
+ 0.07 0.14 0.00 29285714
+ 0.07 0.14 0.00 36357143
+ 0.07 0.14 0.00 43428571
+ 0.07 0.14 0.00 50500000
+ 0.07 0.14 0.00 57571429
+ 0.07 0.14 0.00 64642857
+ 0.07 0.14 0.00 71714286
+ 0.07 0.14 0.00 78785714
+ 0.07 0.14 0.00 85857143
+ 0.07 0.14 0.00 92928571
+ 0.07 0.14 0.00 100000000
+ 0.07 0.14 0.07 1000000
+ 0.07 0.14 0.07 8071429
+ 0.07 0.14 0.07 15142857
+ 0.07 0.14 0.07 22214286
+ 0.07 0.14 0.07 29285714
+ 0.07 0.14 0.07 36357143
+ 0.07 0.14 0.07 43428571
+ 0.07 0.14 0.07 50500000
+ 0.07 0.14 0.07 57571429
+ 0.07 0.14 0.07 64642857
+ 0.07 0.14 0.07 71714286
+ 0.07 0.14 0.07 78785714
+ 0.07 0.14 0.07 85857143
+ 0.07 0.14 0.07 92928571
+ 0.07 0.14 0.07 100000000
+ 0.07 0.14 0.14 1000000
+ 0.07 0.14 0.14 8071429
+ 0.07 0.14 0.14 15142857
+ 0.07 0.14 0.14 22214286
+ 0.07 0.14 0.14 29285714
+ 0.07 0.14 0.14 36357143
+ 0.07 0.14 0.14 43428571
+ 0.07 0.14 0.14 50500000
+ 0.07 0.14 0.14 57571429
+ 0.07 0.14 0.14 64642857
+ 0.07 0.14 0.14 71714286
+ 0.07 0.14 0.14 78785714
+ 0.07 0.14 0.14 85857143
+ 0.07 0.14 0.14 92928571
+ 0.07 0.14 0.14 100000000
+ 0.07 0.14 0.21 1000000
+ 0.07 0.14 0.21 8071429
+ 0.07 0.14 0.21 15142857
+ 0.07 0.14 0.21 22214286
+ 0.07 0.14 0.21 29285714
+ 0.07 0.14 0.21 36357143
+ 0.07 0.14 0.21 43428571
+ 0.07 0.14 0.21 50500000
+ 0.07 0.14 0.21 57571429
+ 0.07 0.14 0.21 64642857
+ 0.07 0.14 0.21 71714286
+ 0.07 0.14 0.21 78785714
+ 0.07 0.14 0.21 85857143
+ 0.07 0.14 0.21 92928571
+ 0.07 0.14 0.21 100000000
+ 0.07 0.14 0.29 1000000
+ 0.07 0.14 0.29 8071429
+ 0.07 0.14 0.29 15142857
+ 0.07 0.14 0.29 22214286
+ 0.07 0.14 0.29 29285714
+ 0.07 0.14 0.29 36357143
+ 0.07 0.14 0.29 43428571
+ 0.07 0.14 0.29 50500000
+ 0.07 0.14 0.29 57571429
+ 0.07 0.14 0.29 64642857
+ 0.07 0.14 0.29 71714286
+ 0.07 0.14 0.29 78785714
+ 0.07 0.14 0.29 85857143
+ 0.07 0.14 0.29 92928571
+ 0.07 0.14 0.29 100000000
+ 0.07 0.14 0.36 1000000
+ 0.07 0.14 0.36 8071429
+ 0.07 0.14 0.36 15142857
+ 0.07 0.14 0.36 22214286
+ 0.07 0.14 0.36 29285714
+ 0.07 0.14 0.36 36357143
+ 0.07 0.14 0.36 43428571
+ 0.07 0.14 0.36 50500000
+ 0.07 0.14 0.36 57571429
+ 0.07 0.14 0.36 64642857
+ 0.07 0.14 0.36 71714286
+ 0.07 0.14 0.36 78785714
+ 0.07 0.14 0.36 85857143
+ 0.07 0.14 0.36 92928571
+ 0.07 0.14 0.36 100000000
+ 0.07 0.14 0.43 1000000
+ 0.07 0.14 0.43 8071429
+ 0.07 0.14 0.43 15142857
+ 0.07 0.14 0.43 22214286
+ 0.07 0.14 0.43 29285714
+ 0.07 0.14 0.43 36357143
+ 0.07 0.14 0.43 43428571
+ 0.07 0.14 0.43 50500000
+ 0.07 0.14 0.43 57571429
+ 0.07 0.14 0.43 64642857
+ 0.07 0.14 0.43 71714286
+ 0.07 0.14 0.43 78785714
+ 0.07 0.14 0.43 85857143
+ 0.07 0.14 0.43 92928571
+ 0.07 0.14 0.43 100000000
+ 0.07 0.14 0.50 1000000
+ 0.07 0.14 0.50 8071429
+ 0.07 0.14 0.50 15142857
+ 0.07 0.14 0.50 22214286
+ 0.07 0.14 0.50 29285714
+ 0.07 0.14 0.50 36357143
+ 0.07 0.14 0.50 43428571
+ 0.07 0.14 0.50 50500000
+ 0.07 0.14 0.50 57571429
+ 0.07 0.14 0.50 64642857
+ 0.07 0.14 0.50 71714286
+ 0.07 0.14 0.50 78785714
+ 0.07 0.14 0.50 85857143
+ 0.07 0.14 0.50 92928571
+ 0.07 0.14 0.50 100000000
+ 0.07 0.14 0.57 1000000
+ 0.07 0.14 0.57 8071429
+ 0.07 0.14 0.57 15142857
+ 0.07 0.14 0.57 22214286
+ 0.07 0.14 0.57 29285714
+ 0.07 0.14 0.57 36357143
+ 0.07 0.14 0.57 43428571
+ 0.07 0.14 0.57 50500000
+ 0.07 0.14 0.57 57571429
+ 0.07 0.14 0.57 64642857
+ 0.07 0.14 0.57 71714286
+ 0.07 0.14 0.57 78785714
+ 0.07 0.14 0.57 85857143
+ 0.07 0.14 0.57 92928571
+ 0.07 0.14 0.57 100000000
+ 0.07 0.14 0.64 1000000
+ 0.07 0.14 0.64 8071429
+ 0.07 0.14 0.64 15142857
+ 0.07 0.14 0.64 22214286
+ 0.07 0.14 0.64 29285714
+ 0.07 0.14 0.64 36357143
+ 0.07 0.14 0.64 43428571
+ 0.07 0.14 0.64 50500000
+ 0.07 0.14 0.64 57571429
+ 0.07 0.14 0.64 64642857
+ 0.07 0.14 0.64 71714286
+ 0.07 0.14 0.64 78785714
+ 0.07 0.14 0.64 85857143
+ 0.07 0.14 0.64 92928571
+ 0.07 0.14 0.64 100000000
+ 0.07 0.14 0.71 1000000
+ 0.07 0.14 0.71 8071429
+ 0.07 0.14 0.71 15142857
+ 0.07 0.14 0.71 22214286
+ 0.07 0.14 0.71 29285714
+ 0.07 0.14 0.71 36357143
+ 0.07 0.14 0.71 43428571
+ 0.07 0.14 0.71 50500000
+ 0.07 0.14 0.71 57571429
+ 0.07 0.14 0.71 64642857
+ 0.07 0.14 0.71 71714286
+ 0.07 0.14 0.71 78785714
+ 0.07 0.14 0.71 85857143
+ 0.07 0.14 0.71 92928571
+ 0.07 0.14 0.71 100000000
+ 0.07 0.14 0.79 1000000
+ 0.07 0.14 0.79 8071429
+ 0.07 0.14 0.79 15142857
+ 0.07 0.14 0.79 22214286
+ 0.07 0.14 0.79 29285714
+ 0.07 0.14 0.79 36357143
+ 0.07 0.14 0.79 43428571
+ 0.07 0.14 0.79 50500000
+ 0.07 0.14 0.79 57571429
+ 0.07 0.14 0.79 64642857
+ 0.07 0.14 0.79 71714286
+ 0.07 0.14 0.79 78785714
+ 0.07 0.14 0.79 85857143
+ 0.07 0.14 0.79 92928571
+ 0.07 0.14 0.79 100000000
+ 0.07 0.14 0.86 1000000
+ 0.07 0.14 0.86 8071429
+ 0.07 0.14 0.86 15142857
+ 0.07 0.14 0.86 22214286
+ 0.07 0.14 0.86 29285714
+ 0.07 0.14 0.86 36357143
+ 0.07 0.14 0.86 43428571
+ 0.07 0.14 0.86 50500000
+ 0.07 0.14 0.86 57571429
+ 0.07 0.14 0.86 64642857
+ 0.07 0.14 0.86 71714286
+ 0.07 0.14 0.86 78785714
+ 0.07 0.14 0.86 85857143
+ 0.07 0.14 0.86 92928571
+ 0.07 0.14 0.86 100000000
+ 0.07 0.14 0.93 1000000
+ 0.07 0.14 0.93 8071429
+ 0.07 0.14 0.93 15142857
+ 0.07 0.14 0.93 22214286
+ 0.07 0.14 0.93 29285714
+ 0.07 0.14 0.93 36357143
+ 0.07 0.14 0.93 43428571
+ 0.07 0.14 0.93 50500000
+ 0.07 0.14 0.93 57571429
+ 0.07 0.14 0.93 64642857
+ 0.07 0.14 0.93 71714286
+ 0.07 0.14 0.93 78785714
+ 0.07 0.14 0.93 85857143
+ 0.07 0.14 0.93 92928571
+ 0.07 0.14 0.93 100000000
+ 0.07 0.14 1.00 1000000
+ 0.07 0.14 1.00 8071429
+ 0.07 0.14 1.00 15142857
+ 0.07 0.14 1.00 22214286
+ 0.07 0.14 1.00 29285714
+ 0.07 0.14 1.00 36357143
+ 0.07 0.14 1.00 43428571
+ 0.07 0.14 1.00 50500000
+ 0.07 0.14 1.00 57571429
+ 0.07 0.14 1.00 64642857
+ 0.07 0.14 1.00 71714286
+ 0.07 0.14 1.00 78785714
+ 0.07 0.14 1.00 85857143
+ 0.07 0.14 1.00 92928571
+ 0.07 0.14 1.00 100000000
+ 0.07 0.21 0.00 1000000
+ 0.07 0.21 0.00 8071429
+ 0.07 0.21 0.00 15142857
+ 0.07 0.21 0.00 22214286
+ 0.07 0.21 0.00 29285714
+ 0.07 0.21 0.00 36357143
+ 0.07 0.21 0.00 43428571
+ 0.07 0.21 0.00 50500000
+ 0.07 0.21 0.00 57571429
+ 0.07 0.21 0.00 64642857
+ 0.07 0.21 0.00 71714286
+ 0.07 0.21 0.00 78785714
+ 0.07 0.21 0.00 85857143
+ 0.07 0.21 0.00 92928571
+ 0.07 0.21 0.00 100000000
+ 0.07 0.21 0.07 1000000
+ 0.07 0.21 0.07 8071429
+ 0.07 0.21 0.07 15142857
+ 0.07 0.21 0.07 22214286
+ 0.07 0.21 0.07 29285714
+ 0.07 0.21 0.07 36357143
+ 0.07 0.21 0.07 43428571
+ 0.07 0.21 0.07 50500000
+ 0.07 0.21 0.07 57571429
+ 0.07 0.21 0.07 64642857
+ 0.07 0.21 0.07 71714286
+ 0.07 0.21 0.07 78785714
+ 0.07 0.21 0.07 85857143
+ 0.07 0.21 0.07 92928571
+ 0.07 0.21 0.07 100000000
+ 0.07 0.21 0.14 1000000
+ 0.07 0.21 0.14 8071429
+ 0.07 0.21 0.14 15142857
+ 0.07 0.21 0.14 22214286
+ 0.07 0.21 0.14 29285714
+ 0.07 0.21 0.14 36357143
+ 0.07 0.21 0.14 43428571
+ 0.07 0.21 0.14 50500000
+ 0.07 0.21 0.14 57571429
+ 0.07 0.21 0.14 64642857
+ 0.07 0.21 0.14 71714286
+ 0.07 0.21 0.14 78785714
+ 0.07 0.21 0.14 85857143
+ 0.07 0.21 0.14 92928571
+ 0.07 0.21 0.14 100000000
+ 0.07 0.21 0.21 1000000
+ 0.07 0.21 0.21 8071429
+ 0.07 0.21 0.21 15142857
+ 0.07 0.21 0.21 22214286
+ 0.07 0.21 0.21 29285714
+ 0.07 0.21 0.21 36357143
+ 0.07 0.21 0.21 43428571
+ 0.07 0.21 0.21 50500000
+ 0.07 0.21 0.21 57571429
+ 0.07 0.21 0.21 64642857
+ 0.07 0.21 0.21 71714286
+ 0.07 0.21 0.21 78785714
+ 0.07 0.21 0.21 85857143
+ 0.07 0.21 0.21 92928571
+ 0.07 0.21 0.21 100000000
+ 0.07 0.21 0.29 1000000
+ 0.07 0.21 0.29 8071429
+ 0.07 0.21 0.29 15142857
+ 0.07 0.21 0.29 22214286
+ 0.07 0.21 0.29 29285714
+ 0.07 0.21 0.29 36357143
+ 0.07 0.21 0.29 43428571
+ 0.07 0.21 0.29 50500000
+ 0.07 0.21 0.29 57571429
+ 0.07 0.21 0.29 64642857
+ 0.07 0.21 0.29 71714286
+ 0.07 0.21 0.29 78785714
+ 0.07 0.21 0.29 85857143
+ 0.07 0.21 0.29 92928571
+ 0.07 0.21 0.29 100000000
+ 0.07 0.21 0.36 1000000
+ 0.07 0.21 0.36 8071429
+ 0.07 0.21 0.36 15142857
+ 0.07 0.21 0.36 22214286
+ 0.07 0.21 0.36 29285714
+ 0.07 0.21 0.36 36357143
+ 0.07 0.21 0.36 43428571
+ 0.07 0.21 0.36 50500000
+ 0.07 0.21 0.36 57571429
+ 0.07 0.21 0.36 64642857
+ 0.07 0.21 0.36 71714286
+ 0.07 0.21 0.36 78785714
+ 0.07 0.21 0.36 85857143
+ 0.07 0.21 0.36 92928571
+ 0.07 0.21 0.36 100000000
+ 0.07 0.21 0.43 1000000
+ 0.07 0.21 0.43 8071429
+ 0.07 0.21 0.43 15142857
+ 0.07 0.21 0.43 22214286
+ 0.07 0.21 0.43 29285714
+ 0.07 0.21 0.43 36357143
+ 0.07 0.21 0.43 43428571
+ 0.07 0.21 0.43 50500000
+ 0.07 0.21 0.43 57571429
+ 0.07 0.21 0.43 64642857
+ 0.07 0.21 0.43 71714286
+ 0.07 0.21 0.43 78785714
+ 0.07 0.21 0.43 85857143
+ 0.07 0.21 0.43 92928571
+ 0.07 0.21 0.43 100000000
+ 0.07 0.21 0.50 1000000
+ 0.07 0.21 0.50 8071429
+ 0.07 0.21 0.50 15142857
+ 0.07 0.21 0.50 22214286
+ 0.07 0.21 0.50 29285714
+ 0.07 0.21 0.50 36357143
+ 0.07 0.21 0.50 43428571
+ 0.07 0.21 0.50 50500000
+ 0.07 0.21 0.50 57571429
+ 0.07 0.21 0.50 64642857
+ 0.07 0.21 0.50 71714286
+ 0.07 0.21 0.50 78785714
+ 0.07 0.21 0.50 85857143
+ 0.07 0.21 0.50 92928571
+ 0.07 0.21 0.50 100000000
+ 0.07 0.21 0.57 1000000
+ 0.07 0.21 0.57 8071429
+ 0.07 0.21 0.57 15142857
+ 0.07 0.21 0.57 22214286
+ 0.07 0.21 0.57 29285714
+ 0.07 0.21 0.57 36357143
+ 0.07 0.21 0.57 43428571
+ 0.07 0.21 0.57 50500000
+ 0.07 0.21 0.57 57571429
+ 0.07 0.21 0.57 64642857
+ 0.07 0.21 0.57 71714286
+ 0.07 0.21 0.57 78785714
+ 0.07 0.21 0.57 85857143
+ 0.07 0.21 0.57 92928571
+ 0.07 0.21 0.57 100000000
+ 0.07 0.21 0.64 1000000
+ 0.07 0.21 0.64 8071429
+ 0.07 0.21 0.64 15142857
+ 0.07 0.21 0.64 22214286
+ 0.07 0.21 0.64 29285714
+ 0.07 0.21 0.64 36357143
+ 0.07 0.21 0.64 43428571
+ 0.07 0.21 0.64 50500000
+ 0.07 0.21 0.64 57571429
+ 0.07 0.21 0.64 64642857
+ 0.07 0.21 0.64 71714286
+ 0.07 0.21 0.64 78785714
+ 0.07 0.21 0.64 85857143
+ 0.07 0.21 0.64 92928571
+ 0.07 0.21 0.64 100000000
+ 0.07 0.21 0.71 1000000
+ 0.07 0.21 0.71 8071429
+ 0.07 0.21 0.71 15142857
+ 0.07 0.21 0.71 22214286
+ 0.07 0.21 0.71 29285714
+ 0.07 0.21 0.71 36357143
+ 0.07 0.21 0.71 43428571
+ 0.07 0.21 0.71 50500000
+ 0.07 0.21 0.71 57571429
+ 0.07 0.21 0.71 64642857
+ 0.07 0.21 0.71 71714286
+ 0.07 0.21 0.71 78785714
+ 0.07 0.21 0.71 85857143
+ 0.07 0.21 0.71 92928571
+ 0.07 0.21 0.71 100000000
+ 0.07 0.21 0.79 1000000
+ 0.07 0.21 0.79 8071429
+ 0.07 0.21 0.79 15142857
+ 0.07 0.21 0.79 22214286
+ 0.07 0.21 0.79 29285714
+ 0.07 0.21 0.79 36357143
+ 0.07 0.21 0.79 43428571
+ 0.07 0.21 0.79 50500000
+ 0.07 0.21 0.79 57571429
+ 0.07 0.21 0.79 64642857
+ 0.07 0.21 0.79 71714286
+ 0.07 0.21 0.79 78785714
+ 0.07 0.21 0.79 85857143
+ 0.07 0.21 0.79 92928571
+ 0.07 0.21 0.79 100000000
+ 0.07 0.21 0.86 1000000
+ 0.07 0.21 0.86 8071429
+ 0.07 0.21 0.86 15142857
+ 0.07 0.21 0.86 22214286
+ 0.07 0.21 0.86 29285714
+ 0.07 0.21 0.86 36357143
+ 0.07 0.21 0.86 43428571
+ 0.07 0.21 0.86 50500000
+ 0.07 0.21 0.86 57571429
+ 0.07 0.21 0.86 64642857
+ 0.07 0.21 0.86 71714286
+ 0.07 0.21 0.86 78785714
+ 0.07 0.21 0.86 85857143
+ 0.07 0.21 0.86 92928571
+ 0.07 0.21 0.86 100000000
+ 0.07 0.21 0.93 1000000
+ 0.07 0.21 0.93 8071429
+ 0.07 0.21 0.93 15142857
+ 0.07 0.21 0.93 22214286
+ 0.07 0.21 0.93 29285714
+ 0.07 0.21 0.93 36357143
+ 0.07 0.21 0.93 43428571
+ 0.07 0.21 0.93 50500000
+ 0.07 0.21 0.93 57571429
+ 0.07 0.21 0.93 64642857
+ 0.07 0.21 0.93 71714286
+ 0.07 0.21 0.93 78785714
+ 0.07 0.21 0.93 85857143
+ 0.07 0.21 0.93 92928571
+ 0.07 0.21 0.93 100000000
+ 0.07 0.21 1.00 1000000
+ 0.07 0.21 1.00 8071429
+ 0.07 0.21 1.00 15142857
+ 0.07 0.21 1.00 22214286
+ 0.07 0.21 1.00 29285714
+ 0.07 0.21 1.00 36357143
+ 0.07 0.21 1.00 43428571
+ 0.07 0.21 1.00 50500000
+ 0.07 0.21 1.00 57571429
+ 0.07 0.21 1.00 64642857
+ 0.07 0.21 1.00 71714286
+ 0.07 0.21 1.00 78785714
+ 0.07 0.21 1.00 85857143
+ 0.07 0.21 1.00 92928571
+ 0.07 0.21 1.00 100000000
+ 0.07 0.29 0.00 1000000
+ 0.07 0.29 0.00 8071429
+ 0.07 0.29 0.00 15142857
+ 0.07 0.29 0.00 22214286
+ 0.07 0.29 0.00 29285714
+ 0.07 0.29 0.00 36357143
+ 0.07 0.29 0.00 43428571
+ 0.07 0.29 0.00 50500000
+ 0.07 0.29 0.00 57571429
+ 0.07 0.29 0.00 64642857
+ 0.07 0.29 0.00 71714286
+ 0.07 0.29 0.00 78785714
+ 0.07 0.29 0.00 85857143
+ 0.07 0.29 0.00 92928571
+ 0.07 0.29 0.00 100000000
+ 0.07 0.29 0.07 1000000
+ 0.07 0.29 0.07 8071429
+ 0.07 0.29 0.07 15142857
+ 0.07 0.29 0.07 22214286
+ 0.07 0.29 0.07 29285714
+ 0.07 0.29 0.07 36357143
+ 0.07 0.29 0.07 43428571
+ 0.07 0.29 0.07 50500000
+ 0.07 0.29 0.07 57571429
+ 0.07 0.29 0.07 64642857
+ 0.07 0.29 0.07 71714286
+ 0.07 0.29 0.07 78785714
+ 0.07 0.29 0.07 85857143
+ 0.07 0.29 0.07 92928571
+ 0.07 0.29 0.07 100000000
+ 0.07 0.29 0.14 1000000
+ 0.07 0.29 0.14 8071429
+ 0.07 0.29 0.14 15142857
+ 0.07 0.29 0.14 22214286
+ 0.07 0.29 0.14 29285714
+ 0.07 0.29 0.14 36357143
+ 0.07 0.29 0.14 43428571
+ 0.07 0.29 0.14 50500000
+ 0.07 0.29 0.14 57571429
+ 0.07 0.29 0.14 64642857
+ 0.07 0.29 0.14 71714286
+ 0.07 0.29 0.14 78785714
+ 0.07 0.29 0.14 85857143
+ 0.07 0.29 0.14 92928571
+ 0.07 0.29 0.14 100000000
+ 0.07 0.29 0.21 1000000
+ 0.07 0.29 0.21 8071429
+ 0.07 0.29 0.21 15142857
+ 0.07 0.29 0.21 22214286
+ 0.07 0.29 0.21 29285714
+ 0.07 0.29 0.21 36357143
+ 0.07 0.29 0.21 43428571
+ 0.07 0.29 0.21 50500000
+ 0.07 0.29 0.21 57571429
+ 0.07 0.29 0.21 64642857
+ 0.07 0.29 0.21 71714286
+ 0.07 0.29 0.21 78785714
+ 0.07 0.29 0.21 85857143
+ 0.07 0.29 0.21 92928571
+ 0.07 0.29 0.21 100000000
+ 0.07 0.29 0.29 1000000
+ 0.07 0.29 0.29 8071429
+ 0.07 0.29 0.29 15142857
+ 0.07 0.29 0.29 22214286
+ 0.07 0.29 0.29 29285714
+ 0.07 0.29 0.29 36357143
+ 0.07 0.29 0.29 43428571
+ 0.07 0.29 0.29 50500000
+ 0.07 0.29 0.29 57571429
+ 0.07 0.29 0.29 64642857
+ 0.07 0.29 0.29 71714286
+ 0.07 0.29 0.29 78785714
+ 0.07 0.29 0.29 85857143
+ 0.07 0.29 0.29 92928571
+ 0.07 0.29 0.29 100000000
+ 0.07 0.29 0.36 1000000
+ 0.07 0.29 0.36 8071429
+ 0.07 0.29 0.36 15142857
+ 0.07 0.29 0.36 22214286
+ 0.07 0.29 0.36 29285714
+ 0.07 0.29 0.36 36357143
+ 0.07 0.29 0.36 43428571
+ 0.07 0.29 0.36 50500000
+ 0.07 0.29 0.36 57571429
+ 0.07 0.29 0.36 64642857
+ 0.07 0.29 0.36 71714286
+ 0.07 0.29 0.36 78785714
+ 0.07 0.29 0.36 85857143
+ 0.07 0.29 0.36 92928571
+ 0.07 0.29 0.36 100000000
+ 0.07 0.29 0.43 1000000
+ 0.07 0.29 0.43 8071429
+ 0.07 0.29 0.43 15142857
+ 0.07 0.29 0.43 22214286
+ 0.07 0.29 0.43 29285714
+ 0.07 0.29 0.43 36357143
+ 0.07 0.29 0.43 43428571
+ 0.07 0.29 0.43 50500000
+ 0.07 0.29 0.43 57571429
+ 0.07 0.29 0.43 64642857
+ 0.07 0.29 0.43 71714286
+ 0.07 0.29 0.43 78785714
+ 0.07 0.29 0.43 85857143
+ 0.07 0.29 0.43 92928571
+ 0.07 0.29 0.43 100000000
+ 0.07 0.29 0.50 1000000
+ 0.07 0.29 0.50 8071429
+ 0.07 0.29 0.50 15142857
+ 0.07 0.29 0.50 22214286
+ 0.07 0.29 0.50 29285714
+ 0.07 0.29 0.50 36357143
+ 0.07 0.29 0.50 43428571
+ 0.07 0.29 0.50 50500000
+ 0.07 0.29 0.50 57571429
+ 0.07 0.29 0.50 64642857
+ 0.07 0.29 0.50 71714286
+ 0.07 0.29 0.50 78785714
+ 0.07 0.29 0.50 85857143
+ 0.07 0.29 0.50 92928571
+ 0.07 0.29 0.50 100000000
+ 0.07 0.29 0.57 1000000
+ 0.07 0.29 0.57 8071429
+ 0.07 0.29 0.57 15142857
+ 0.07 0.29 0.57 22214286
+ 0.07 0.29 0.57 29285714
+ 0.07 0.29 0.57 36357143
+ 0.07 0.29 0.57 43428571
+ 0.07 0.29 0.57 50500000
+ 0.07 0.29 0.57 57571429
+ 0.07 0.29 0.57 64642857
+ 0.07 0.29 0.57 71714286
+ 0.07 0.29 0.57 78785714
+ 0.07 0.29 0.57 85857143
+ 0.07 0.29 0.57 92928571
+ 0.07 0.29 0.57 100000000
+ 0.07 0.29 0.64 1000000
+ 0.07 0.29 0.64 8071429
+ 0.07 0.29 0.64 15142857
+ 0.07 0.29 0.64 22214286
+ 0.07 0.29 0.64 29285714
+ 0.07 0.29 0.64 36357143
+ 0.07 0.29 0.64 43428571
+ 0.07 0.29 0.64 50500000
+ 0.07 0.29 0.64 57571429
+ 0.07 0.29 0.64 64642857
+ 0.07 0.29 0.64 71714286
+ 0.07 0.29 0.64 78785714
+ 0.07 0.29 0.64 85857143
+ 0.07 0.29 0.64 92928571
+ 0.07 0.29 0.64 100000000
+ 0.07 0.29 0.71 1000000
+ 0.07 0.29 0.71 8071429
+ 0.07 0.29 0.71 15142857
+ 0.07 0.29 0.71 22214286
+ 0.07 0.29 0.71 29285714
+ 0.07 0.29 0.71 36357143
+ 0.07 0.29 0.71 43428571
+ 0.07 0.29 0.71 50500000
+ 0.07 0.29 0.71 57571429
+ 0.07 0.29 0.71 64642857
+ 0.07 0.29 0.71 71714286
+ 0.07 0.29 0.71 78785714
+ 0.07 0.29 0.71 85857143
+ 0.07 0.29 0.71 92928571
+ 0.07 0.29 0.71 100000000
+ 0.07 0.29 0.79 1000000
+ 0.07 0.29 0.79 8071429
+ 0.07 0.29 0.79 15142857
+ 0.07 0.29 0.79 22214286
+ 0.07 0.29 0.79 29285714
+ 0.07 0.29 0.79 36357143
+ 0.07 0.29 0.79 43428571
+ 0.07 0.29 0.79 50500000
+ 0.07 0.29 0.79 57571429
+ 0.07 0.29 0.79 64642857
+ 0.07 0.29 0.79 71714286
+ 0.07 0.29 0.79 78785714
+ 0.07 0.29 0.79 85857143
+ 0.07 0.29 0.79 92928571
+ 0.07 0.29 0.79 100000000
+ 0.07 0.29 0.86 1000000
+ 0.07 0.29 0.86 8071429
+ 0.07 0.29 0.86 15142857
+ 0.07 0.29 0.86 22214286
+ 0.07 0.29 0.86 29285714
+ 0.07 0.29 0.86 36357143
+ 0.07 0.29 0.86 43428571
+ 0.07 0.29 0.86 50500000
+ 0.07 0.29 0.86 57571429
+ 0.07 0.29 0.86 64642857
+ 0.07 0.29 0.86 71714286
+ 0.07 0.29 0.86 78785714
+ 0.07 0.29 0.86 85857143
+ 0.07 0.29 0.86 92928571
+ 0.07 0.29 0.86 100000000
+ 0.07 0.29 0.93 1000000
+ 0.07 0.29 0.93 8071429
+ 0.07 0.29 0.93 15142857
+ 0.07 0.29 0.93 22214286
+ 0.07 0.29 0.93 29285714
+ 0.07 0.29 0.93 36357143
+ 0.07 0.29 0.93 43428571
+ 0.07 0.29 0.93 50500000
+ 0.07 0.29 0.93 57571429
+ 0.07 0.29 0.93 64642857
+ 0.07 0.29 0.93 71714286
+ 0.07 0.29 0.93 78785714
+ 0.07 0.29 0.93 85857143
+ 0.07 0.29 0.93 92928571
+ 0.07 0.29 0.93 100000000
+ 0.07 0.29 1.00 1000000
+ 0.07 0.29 1.00 8071429
+ 0.07 0.29 1.00 15142857
+ 0.07 0.29 1.00 22214286
+ 0.07 0.29 1.00 29285714
+ 0.07 0.29 1.00 36357143
+ 0.07 0.29 1.00 43428571
+ 0.07 0.29 1.00 50500000
+ 0.07 0.29 1.00 57571429
+ 0.07 0.29 1.00 64642857
+ 0.07 0.29 1.00 71714286
+ 0.07 0.29 1.00 78785714
+ 0.07 0.29 1.00 85857143
+ 0.07 0.29 1.00 92928571
+ 0.07 0.29 1.00 100000000
+ 0.07 0.36 0.00 1000000
+ 0.07 0.36 0.00 8071429
+ 0.07 0.36 0.00 15142857
+ 0.07 0.36 0.00 22214286
+ 0.07 0.36 0.00 29285714
+ 0.07 0.36 0.00 36357143
+ 0.07 0.36 0.00 43428571
+ 0.07 0.36 0.00 50500000
+ 0.07 0.36 0.00 57571429
+ 0.07 0.36 0.00 64642857
+ 0.07 0.36 0.00 71714286
+ 0.07 0.36 0.00 78785714
+ 0.07 0.36 0.00 85857143
+ 0.07 0.36 0.00 92928571
+ 0.07 0.36 0.00 100000000
+ 0.07 0.36 0.07 1000000
+ 0.07 0.36 0.07 8071429
+ 0.07 0.36 0.07 15142857
+ 0.07 0.36 0.07 22214286
+ 0.07 0.36 0.07 29285714
+ 0.07 0.36 0.07 36357143
+ 0.07 0.36 0.07 43428571
+ 0.07 0.36 0.07 50500000
+ 0.07 0.36 0.07 57571429
+ 0.07 0.36 0.07 64642857
+ 0.07 0.36 0.07 71714286
+ 0.07 0.36 0.07 78785714
+ 0.07 0.36 0.07 85857143
+ 0.07 0.36 0.07 92928571
+ 0.07 0.36 0.07 100000000
+ 0.07 0.36 0.14 1000000
+ 0.07 0.36 0.14 8071429
+ 0.07 0.36 0.14 15142857
+ 0.07 0.36 0.14 22214286
+ 0.07 0.36 0.14 29285714
+ 0.07 0.36 0.14 36357143
+ 0.07 0.36 0.14 43428571
+ 0.07 0.36 0.14 50500000
+ 0.07 0.36 0.14 57571429
+ 0.07 0.36 0.14 64642857
+ 0.07 0.36 0.14 71714286
+ 0.07 0.36 0.14 78785714
+ 0.07 0.36 0.14 85857143
+ 0.07 0.36 0.14 92928571
+ 0.07 0.36 0.14 100000000
+ 0.07 0.36 0.21 1000000
+ 0.07 0.36 0.21 8071429
+ 0.07 0.36 0.21 15142857
+ 0.07 0.36 0.21 22214286
+ 0.07 0.36 0.21 29285714
+ 0.07 0.36 0.21 36357143
+ 0.07 0.36 0.21 43428571
+ 0.07 0.36 0.21 50500000
+ 0.07 0.36 0.21 57571429
+ 0.07 0.36 0.21 64642857
+ 0.07 0.36 0.21 71714286
+ 0.07 0.36 0.21 78785714
+ 0.07 0.36 0.21 85857143
+ 0.07 0.36 0.21 92928571
+ 0.07 0.36 0.21 100000000
+ 0.07 0.36 0.29 1000000
+ 0.07 0.36 0.29 8071429
+ 0.07 0.36 0.29 15142857
+ 0.07 0.36 0.29 22214286
+ 0.07 0.36 0.29 29285714
+ 0.07 0.36 0.29 36357143
+ 0.07 0.36 0.29 43428571
+ 0.07 0.36 0.29 50500000
+ 0.07 0.36 0.29 57571429
+ 0.07 0.36 0.29 64642857
+ 0.07 0.36 0.29 71714286
+ 0.07 0.36 0.29 78785714
+ 0.07 0.36 0.29 85857143
+ 0.07 0.36 0.29 92928571
+ 0.07 0.36 0.29 100000000
+ 0.07 0.36 0.36 1000000
+ 0.07 0.36 0.36 8071429
+ 0.07 0.36 0.36 15142857
+ 0.07 0.36 0.36 22214286
+ 0.07 0.36 0.36 29285714
+ 0.07 0.36 0.36 36357143
+ 0.07 0.36 0.36 43428571
+ 0.07 0.36 0.36 50500000
+ 0.07 0.36 0.36 57571429
+ 0.07 0.36 0.36 64642857
+ 0.07 0.36 0.36 71714286
+ 0.07 0.36 0.36 78785714
+ 0.07 0.36 0.36 85857143
+ 0.07 0.36 0.36 92928571
+ 0.07 0.36 0.36 100000000
+ 0.07 0.36 0.43 1000000
+ 0.07 0.36 0.43 8071429
+ 0.07 0.36 0.43 15142857
+ 0.07 0.36 0.43 22214286
+ 0.07 0.36 0.43 29285714
+ 0.07 0.36 0.43 36357143
+ 0.07 0.36 0.43 43428571
+ 0.07 0.36 0.43 50500000
+ 0.07 0.36 0.43 57571429
+ 0.07 0.36 0.43 64642857
+ 0.07 0.36 0.43 71714286
+ 0.07 0.36 0.43 78785714
+ 0.07 0.36 0.43 85857143
+ 0.07 0.36 0.43 92928571
+ 0.07 0.36 0.43 100000000
+ 0.07 0.36 0.50 1000000
+ 0.07 0.36 0.50 8071429
+ 0.07 0.36 0.50 15142857
+ 0.07 0.36 0.50 22214286
+ 0.07 0.36 0.50 29285714
+ 0.07 0.36 0.50 36357143
+ 0.07 0.36 0.50 43428571
+ 0.07 0.36 0.50 50500000
+ 0.07 0.36 0.50 57571429
+ 0.07 0.36 0.50 64642857
+ 0.07 0.36 0.50 71714286
+ 0.07 0.36 0.50 78785714
+ 0.07 0.36 0.50 85857143
+ 0.07 0.36 0.50 92928571
+ 0.07 0.36 0.50 100000000
+ 0.07 0.36 0.57 1000000
+ 0.07 0.36 0.57 8071429
+ 0.07 0.36 0.57 15142857
+ 0.07 0.36 0.57 22214286
+ 0.07 0.36 0.57 29285714
+ 0.07 0.36 0.57 36357143
+ 0.07 0.36 0.57 43428571
+ 0.07 0.36 0.57 50500000
+ 0.07 0.36 0.57 57571429
+ 0.07 0.36 0.57 64642857
+ 0.07 0.36 0.57 71714286
+ 0.07 0.36 0.57 78785714
+ 0.07 0.36 0.57 85857143
+ 0.07 0.36 0.57 92928571
+ 0.07 0.36 0.57 100000000
+ 0.07 0.36 0.64 1000000
+ 0.07 0.36 0.64 8071429
+ 0.07 0.36 0.64 15142857
+ 0.07 0.36 0.64 22214286
+ 0.07 0.36 0.64 29285714
+ 0.07 0.36 0.64 36357143
+ 0.07 0.36 0.64 43428571
+ 0.07 0.36 0.64 50500000
+ 0.07 0.36 0.64 57571429
+ 0.07 0.36 0.64 64642857
+ 0.07 0.36 0.64 71714286
+ 0.07 0.36 0.64 78785714
+ 0.07 0.36 0.64 85857143
+ 0.07 0.36 0.64 92928571
+ 0.07 0.36 0.64 100000000
+ 0.07 0.36 0.71 1000000
+ 0.07 0.36 0.71 8071429
+ 0.07 0.36 0.71 15142857
+ 0.07 0.36 0.71 22214286
+ 0.07 0.36 0.71 29285714
+ 0.07 0.36 0.71 36357143
+ 0.07 0.36 0.71 43428571
+ 0.07 0.36 0.71 50500000
+ 0.07 0.36 0.71 57571429
+ 0.07 0.36 0.71 64642857
+ 0.07 0.36 0.71 71714286
+ 0.07 0.36 0.71 78785714
+ 0.07 0.36 0.71 85857143
+ 0.07 0.36 0.71 92928571
+ 0.07 0.36 0.71 100000000
+ 0.07 0.36 0.79 1000000
+ 0.07 0.36 0.79 8071429
+ 0.07 0.36 0.79 15142857
+ 0.07 0.36 0.79 22214286
+ 0.07 0.36 0.79 29285714
+ 0.07 0.36 0.79 36357143
+ 0.07 0.36 0.79 43428571
+ 0.07 0.36 0.79 50500000
+ 0.07 0.36 0.79 57571429
+ 0.07 0.36 0.79 64642857
+ 0.07 0.36 0.79 71714286
+ 0.07 0.36 0.79 78785714
+ 0.07 0.36 0.79 85857143
+ 0.07 0.36 0.79 92928571
+ 0.07 0.36 0.79 100000000
+ 0.07 0.36 0.86 1000000
+ 0.07 0.36 0.86 8071429
+ 0.07 0.36 0.86 15142857
+ 0.07 0.36 0.86 22214286
+ 0.07 0.36 0.86 29285714
+ 0.07 0.36 0.86 36357143
+ 0.07 0.36 0.86 43428571
+ 0.07 0.36 0.86 50500000
+ 0.07 0.36 0.86 57571429
+ 0.07 0.36 0.86 64642857
+ 0.07 0.36 0.86 71714286
+ 0.07 0.36 0.86 78785714
+ 0.07 0.36 0.86 85857143
+ 0.07 0.36 0.86 92928571
+ 0.07 0.36 0.86 100000000
+ 0.07 0.36 0.93 1000000
+ 0.07 0.36 0.93 8071429
+ 0.07 0.36 0.93 15142857
+ 0.07 0.36 0.93 22214286
+ 0.07 0.36 0.93 29285714
+ 0.07 0.36 0.93 36357143
+ 0.07 0.36 0.93 43428571
+ 0.07 0.36 0.93 50500000
+ 0.07 0.36 0.93 57571429
+ 0.07 0.36 0.93 64642857
+ 0.07 0.36 0.93 71714286
+ 0.07 0.36 0.93 78785714
+ 0.07 0.36 0.93 85857143
+ 0.07 0.36 0.93 92928571
+ 0.07 0.36 0.93 100000000
+ 0.07 0.36 1.00 1000000
+ 0.07 0.36 1.00 8071429
+ 0.07 0.36 1.00 15142857
+ 0.07 0.36 1.00 22214286
+ 0.07 0.36 1.00 29285714
+ 0.07 0.36 1.00 36357143
+ 0.07 0.36 1.00 43428571
+ 0.07 0.36 1.00 50500000
+ 0.07 0.36 1.00 57571429
+ 0.07 0.36 1.00 64642857
+ 0.07 0.36 1.00 71714286
+ 0.07 0.36 1.00 78785714
+ 0.07 0.36 1.00 85857143
+ 0.07 0.36 1.00 92928571
+ 0.07 0.36 1.00 100000000
+ 0.07 0.43 0.00 1000000
+ 0.07 0.43 0.00 8071429
+ 0.07 0.43 0.00 15142857
+ 0.07 0.43 0.00 22214286
+ 0.07 0.43 0.00 29285714
+ 0.07 0.43 0.00 36357143
+ 0.07 0.43 0.00 43428571
+ 0.07 0.43 0.00 50500000
+ 0.07 0.43 0.00 57571429
+ 0.07 0.43 0.00 64642857
+ 0.07 0.43 0.00 71714286
+ 0.07 0.43 0.00 78785714
+ 0.07 0.43 0.00 85857143
+ 0.07 0.43 0.00 92928571
+ 0.07 0.43 0.00 100000000
+ 0.07 0.43 0.07 1000000
+ 0.07 0.43 0.07 8071429
+ 0.07 0.43 0.07 15142857
+ 0.07 0.43 0.07 22214286
+ 0.07 0.43 0.07 29285714
+ 0.07 0.43 0.07 36357143
+ 0.07 0.43 0.07 43428571
+ 0.07 0.43 0.07 50500000
+ 0.07 0.43 0.07 57571429
+ 0.07 0.43 0.07 64642857
+ 0.07 0.43 0.07 71714286
+ 0.07 0.43 0.07 78785714
+ 0.07 0.43 0.07 85857143
+ 0.07 0.43 0.07 92928571
+ 0.07 0.43 0.07 100000000
+ 0.07 0.43 0.14 1000000
+ 0.07 0.43 0.14 8071429
+ 0.07 0.43 0.14 15142857
+ 0.07 0.43 0.14 22214286
+ 0.07 0.43 0.14 29285714
+ 0.07 0.43 0.14 36357143
+ 0.07 0.43 0.14 43428571
+ 0.07 0.43 0.14 50500000
+ 0.07 0.43 0.14 57571429
+ 0.07 0.43 0.14 64642857
+ 0.07 0.43 0.14 71714286
+ 0.07 0.43 0.14 78785714
+ 0.07 0.43 0.14 85857143
+ 0.07 0.43 0.14 92928571
+ 0.07 0.43 0.14 100000000
+ 0.07 0.43 0.21 1000000
+ 0.07 0.43 0.21 8071429
+ 0.07 0.43 0.21 15142857
+ 0.07 0.43 0.21 22214286
+ 0.07 0.43 0.21 29285714
+ 0.07 0.43 0.21 36357143
+ 0.07 0.43 0.21 43428571
+ 0.07 0.43 0.21 50500000
+ 0.07 0.43 0.21 57571429
+ 0.07 0.43 0.21 64642857
+ 0.07 0.43 0.21 71714286
+ 0.07 0.43 0.21 78785714
+ 0.07 0.43 0.21 85857143
+ 0.07 0.43 0.21 92928571
+ 0.07 0.43 0.21 100000000
+ 0.07 0.43 0.29 1000000
+ 0.07 0.43 0.29 8071429
+ 0.07 0.43 0.29 15142857
+ 0.07 0.43 0.29 22214286
+ 0.07 0.43 0.29 29285714
+ 0.07 0.43 0.29 36357143
+ 0.07 0.43 0.29 43428571
+ 0.07 0.43 0.29 50500000
+ 0.07 0.43 0.29 57571429
+ 0.07 0.43 0.29 64642857
+ 0.07 0.43 0.29 71714286
+ 0.07 0.43 0.29 78785714
+ 0.07 0.43 0.29 85857143
+ 0.07 0.43 0.29 92928571
+ 0.07 0.43 0.29 100000000
+ 0.07 0.43 0.36 1000000
+ 0.07 0.43 0.36 8071429
+ 0.07 0.43 0.36 15142857
+ 0.07 0.43 0.36 22214286
+ 0.07 0.43 0.36 29285714
+ 0.07 0.43 0.36 36357143
+ 0.07 0.43 0.36 43428571
+ 0.07 0.43 0.36 50500000
+ 0.07 0.43 0.36 57571429
+ 0.07 0.43 0.36 64642857
+ 0.07 0.43 0.36 71714286
+ 0.07 0.43 0.36 78785714
+ 0.07 0.43 0.36 85857143
+ 0.07 0.43 0.36 92928571
+ 0.07 0.43 0.36 100000000
+ 0.07 0.43 0.43 1000000
+ 0.07 0.43 0.43 8071429
+ 0.07 0.43 0.43 15142857
+ 0.07 0.43 0.43 22214286
+ 0.07 0.43 0.43 29285714
+ 0.07 0.43 0.43 36357143
+ 0.07 0.43 0.43 43428571
+ 0.07 0.43 0.43 50500000
+ 0.07 0.43 0.43 57571429
+ 0.07 0.43 0.43 64642857
+ 0.07 0.43 0.43 71714286
+ 0.07 0.43 0.43 78785714
+ 0.07 0.43 0.43 85857143
+ 0.07 0.43 0.43 92928571
+ 0.07 0.43 0.43 100000000
+ 0.07 0.43 0.50 1000000
+ 0.07 0.43 0.50 8071429
+ 0.07 0.43 0.50 15142857
+ 0.07 0.43 0.50 22214286
+ 0.07 0.43 0.50 29285714
+ 0.07 0.43 0.50 36357143
+ 0.07 0.43 0.50 43428571
+ 0.07 0.43 0.50 50500000
+ 0.07 0.43 0.50 57571429
+ 0.07 0.43 0.50 64642857
+ 0.07 0.43 0.50 71714286
+ 0.07 0.43 0.50 78785714
+ 0.07 0.43 0.50 85857143
+ 0.07 0.43 0.50 92928571
+ 0.07 0.43 0.50 100000000
+ 0.07 0.43 0.57 1000000
+ 0.07 0.43 0.57 8071429
+ 0.07 0.43 0.57 15142857
+ 0.07 0.43 0.57 22214286
+ 0.07 0.43 0.57 29285714
+ 0.07 0.43 0.57 36357143
+ 0.07 0.43 0.57 43428571
+ 0.07 0.43 0.57 50500000
+ 0.07 0.43 0.57 57571429
+ 0.07 0.43 0.57 64642857
+ 0.07 0.43 0.57 71714286
+ 0.07 0.43 0.57 78785714
+ 0.07 0.43 0.57 85857143
+ 0.07 0.43 0.57 92928571
+ 0.07 0.43 0.57 100000000
+ 0.07 0.43 0.64 1000000
+ 0.07 0.43 0.64 8071429
+ 0.07 0.43 0.64 15142857
+ 0.07 0.43 0.64 22214286
+ 0.07 0.43 0.64 29285714
+ 0.07 0.43 0.64 36357143
+ 0.07 0.43 0.64 43428571
+ 0.07 0.43 0.64 50500000
+ 0.07 0.43 0.64 57571429
+ 0.07 0.43 0.64 64642857
+ 0.07 0.43 0.64 71714286
+ 0.07 0.43 0.64 78785714
+ 0.07 0.43 0.64 85857143
+ 0.07 0.43 0.64 92928571
+ 0.07 0.43 0.64 100000000
+ 0.07 0.43 0.71 1000000
+ 0.07 0.43 0.71 8071429
+ 0.07 0.43 0.71 15142857
+ 0.07 0.43 0.71 22214286
+ 0.07 0.43 0.71 29285714
+ 0.07 0.43 0.71 36357143
+ 0.07 0.43 0.71 43428571
+ 0.07 0.43 0.71 50500000
+ 0.07 0.43 0.71 57571429
+ 0.07 0.43 0.71 64642857
+ 0.07 0.43 0.71 71714286
+ 0.07 0.43 0.71 78785714
+ 0.07 0.43 0.71 85857143
+ 0.07 0.43 0.71 92928571
+ 0.07 0.43 0.71 100000000
+ 0.07 0.43 0.79 1000000
+ 0.07 0.43 0.79 8071429
+ 0.07 0.43 0.79 15142857
+ 0.07 0.43 0.79 22214286
+ 0.07 0.43 0.79 29285714
+ 0.07 0.43 0.79 36357143
+ 0.07 0.43 0.79 43428571
+ 0.07 0.43 0.79 50500000
+ 0.07 0.43 0.79 57571429
+ 0.07 0.43 0.79 64642857
+ 0.07 0.43 0.79 71714286
+ 0.07 0.43 0.79 78785714
+ 0.07 0.43 0.79 85857143
+ 0.07 0.43 0.79 92928571
+ 0.07 0.43 0.79 100000000
+ 0.07 0.43 0.86 1000000
+ 0.07 0.43 0.86 8071429
+ 0.07 0.43 0.86 15142857
+ 0.07 0.43 0.86 22214286
+ 0.07 0.43 0.86 29285714
+ 0.07 0.43 0.86 36357143
+ 0.07 0.43 0.86 43428571
+ 0.07 0.43 0.86 50500000
+ 0.07 0.43 0.86 57571429
+ 0.07 0.43 0.86 64642857
+ 0.07 0.43 0.86 71714286
+ 0.07 0.43 0.86 78785714
+ 0.07 0.43 0.86 85857143
+ 0.07 0.43 0.86 92928571
+ 0.07 0.43 0.86 100000000
+ 0.07 0.43 0.93 1000000
+ 0.07 0.43 0.93 8071429
+ 0.07 0.43 0.93 15142857
+ 0.07 0.43 0.93 22214286
+ 0.07 0.43 0.93 29285714
+ 0.07 0.43 0.93 36357143
+ 0.07 0.43 0.93 43428571
+ 0.07 0.43 0.93 50500000
+ 0.07 0.43 0.93 57571429
+ 0.07 0.43 0.93 64642857
+ 0.07 0.43 0.93 71714286
+ 0.07 0.43 0.93 78785714
+ 0.07 0.43 0.93 85857143
+ 0.07 0.43 0.93 92928571
+ 0.07 0.43 0.93 100000000
+ 0.07 0.43 1.00 1000000
+ 0.07 0.43 1.00 8071429
+ 0.07 0.43 1.00 15142857
+ 0.07 0.43 1.00 22214286
+ 0.07 0.43 1.00 29285714
+ 0.07 0.43 1.00 36357143
+ 0.07 0.43 1.00 43428571
+ 0.07 0.43 1.00 50500000
+ 0.07 0.43 1.00 57571429
+ 0.07 0.43 1.00 64642857
+ 0.07 0.43 1.00 71714286
+ 0.07 0.43 1.00 78785714
+ 0.07 0.43 1.00 85857143
+ 0.07 0.43 1.00 92928571
+ 0.07 0.43 1.00 100000000
+ 0.07 0.50 0.00 1000000
+ 0.07 0.50 0.00 8071429
+ 0.07 0.50 0.00 15142857
+ 0.07 0.50 0.00 22214286
+ 0.07 0.50 0.00 29285714
+ 0.07 0.50 0.00 36357143
+ 0.07 0.50 0.00 43428571
+ 0.07 0.50 0.00 50500000
+ 0.07 0.50 0.00 57571429
+ 0.07 0.50 0.00 64642857
+ 0.07 0.50 0.00 71714286
+ 0.07 0.50 0.00 78785714
+ 0.07 0.50 0.00 85857143
+ 0.07 0.50 0.00 92928571
+ 0.07 0.50 0.00 100000000
+ 0.07 0.50 0.07 1000000
+ 0.07 0.50 0.07 8071429
+ 0.07 0.50 0.07 15142857
+ 0.07 0.50 0.07 22214286
+ 0.07 0.50 0.07 29285714
+ 0.07 0.50 0.07 36357143
+ 0.07 0.50 0.07 43428571
+ 0.07 0.50 0.07 50500000
+ 0.07 0.50 0.07 57571429
+ 0.07 0.50 0.07 64642857
+ 0.07 0.50 0.07 71714286
+ 0.07 0.50 0.07 78785714
+ 0.07 0.50 0.07 85857143
+ 0.07 0.50 0.07 92928571
+ 0.07 0.50 0.07 100000000
+ 0.07 0.50 0.14 1000000
+ 0.07 0.50 0.14 8071429
+ 0.07 0.50 0.14 15142857
+ 0.07 0.50 0.14 22214286
+ 0.07 0.50 0.14 29285714
+ 0.07 0.50 0.14 36357143
+ 0.07 0.50 0.14 43428571
+ 0.07 0.50 0.14 50500000
+ 0.07 0.50 0.14 57571429
+ 0.07 0.50 0.14 64642857
+ 0.07 0.50 0.14 71714286
+ 0.07 0.50 0.14 78785714
+ 0.07 0.50 0.14 85857143
+ 0.07 0.50 0.14 92928571
+ 0.07 0.50 0.14 100000000
+ 0.07 0.50 0.21 1000000
+ 0.07 0.50 0.21 8071429
+ 0.07 0.50 0.21 15142857
+ 0.07 0.50 0.21 22214286
+ 0.07 0.50 0.21 29285714
+ 0.07 0.50 0.21 36357143
+ 0.07 0.50 0.21 43428571
+ 0.07 0.50 0.21 50500000
+ 0.07 0.50 0.21 57571429
+ 0.07 0.50 0.21 64642857
+ 0.07 0.50 0.21 71714286
+ 0.07 0.50 0.21 78785714
+ 0.07 0.50 0.21 85857143
+ 0.07 0.50 0.21 92928571
+ 0.07 0.50 0.21 100000000
+ 0.07 0.50 0.29 1000000
+ 0.07 0.50 0.29 8071429
+ 0.07 0.50 0.29 15142857
+ 0.07 0.50 0.29 22214286
+ 0.07 0.50 0.29 29285714
+ 0.07 0.50 0.29 36357143
+ 0.07 0.50 0.29 43428571
+ 0.07 0.50 0.29 50500000
+ 0.07 0.50 0.29 57571429
+ 0.07 0.50 0.29 64642857
+ 0.07 0.50 0.29 71714286
+ 0.07 0.50 0.29 78785714
+ 0.07 0.50 0.29 85857143
+ 0.07 0.50 0.29 92928571
+ 0.07 0.50 0.29 100000000
+ 0.07 0.50 0.36 1000000
+ 0.07 0.50 0.36 8071429
+ 0.07 0.50 0.36 15142857
+ 0.07 0.50 0.36 22214286
+ 0.07 0.50 0.36 29285714
+ 0.07 0.50 0.36 36357143
+ 0.07 0.50 0.36 43428571
+ 0.07 0.50 0.36 50500000
+ 0.07 0.50 0.36 57571429
+ 0.07 0.50 0.36 64642857
+ 0.07 0.50 0.36 71714286
+ 0.07 0.50 0.36 78785714
+ 0.07 0.50 0.36 85857143
+ 0.07 0.50 0.36 92928571
+ 0.07 0.50 0.36 100000000
+ 0.07 0.50 0.43 1000000
+ 0.07 0.50 0.43 8071429
+ 0.07 0.50 0.43 15142857
+ 0.07 0.50 0.43 22214286
+ 0.07 0.50 0.43 29285714
+ 0.07 0.50 0.43 36357143
+ 0.07 0.50 0.43 43428571
+ 0.07 0.50 0.43 50500000
+ 0.07 0.50 0.43 57571429
+ 0.07 0.50 0.43 64642857
+ 0.07 0.50 0.43 71714286
+ 0.07 0.50 0.43 78785714
+ 0.07 0.50 0.43 85857143
+ 0.07 0.50 0.43 92928571
+ 0.07 0.50 0.43 100000000
+ 0.07 0.50 0.50 1000000
+ 0.07 0.50 0.50 8071429
+ 0.07 0.50 0.50 15142857
+ 0.07 0.50 0.50 22214286
+ 0.07 0.50 0.50 29285714
+ 0.07 0.50 0.50 36357143
+ 0.07 0.50 0.50 43428571
+ 0.07 0.50 0.50 50500000
+ 0.07 0.50 0.50 57571429
+ 0.07 0.50 0.50 64642857
+ 0.07 0.50 0.50 71714286
+ 0.07 0.50 0.50 78785714
+ 0.07 0.50 0.50 85857143
+ 0.07 0.50 0.50 92928571
+ 0.07 0.50 0.50 100000000
+ 0.07 0.50 0.57 1000000
+ 0.07 0.50 0.57 8071429
+ 0.07 0.50 0.57 15142857
+ 0.07 0.50 0.57 22214286
+ 0.07 0.50 0.57 29285714
+ 0.07 0.50 0.57 36357143
+ 0.07 0.50 0.57 43428571
+ 0.07 0.50 0.57 50500000
+ 0.07 0.50 0.57 57571429
+ 0.07 0.50 0.57 64642857
+ 0.07 0.50 0.57 71714286
+ 0.07 0.50 0.57 78785714
+ 0.07 0.50 0.57 85857143
+ 0.07 0.50 0.57 92928571
+ 0.07 0.50 0.57 100000000
+ 0.07 0.50 0.64 1000000
+ 0.07 0.50 0.64 8071429
+ 0.07 0.50 0.64 15142857
+ 0.07 0.50 0.64 22214286
+ 0.07 0.50 0.64 29285714
+ 0.07 0.50 0.64 36357143
+ 0.07 0.50 0.64 43428571
+ 0.07 0.50 0.64 50500000
+ 0.07 0.50 0.64 57571429
+ 0.07 0.50 0.64 64642857
+ 0.07 0.50 0.64 71714286
+ 0.07 0.50 0.64 78785714
+ 0.07 0.50 0.64 85857143
+ 0.07 0.50 0.64 92928571
+ 0.07 0.50 0.64 100000000
+ 0.07 0.50 0.71 1000000
+ 0.07 0.50 0.71 8071429
+ 0.07 0.50 0.71 15142857
+ 0.07 0.50 0.71 22214286
+ 0.07 0.50 0.71 29285714
+ 0.07 0.50 0.71 36357143
+ 0.07 0.50 0.71 43428571
+ 0.07 0.50 0.71 50500000
+ 0.07 0.50 0.71 57571429
+ 0.07 0.50 0.71 64642857
+ 0.07 0.50 0.71 71714286
+ 0.07 0.50 0.71 78785714
+ 0.07 0.50 0.71 85857143
+ 0.07 0.50 0.71 92928571
+ 0.07 0.50 0.71 100000000
+ 0.07 0.50 0.79 1000000
+ 0.07 0.50 0.79 8071429
+ 0.07 0.50 0.79 15142857
+ 0.07 0.50 0.79 22214286
+ 0.07 0.50 0.79 29285714
+ 0.07 0.50 0.79 36357143
+ 0.07 0.50 0.79 43428571
+ 0.07 0.50 0.79 50500000
+ 0.07 0.50 0.79 57571429
+ 0.07 0.50 0.79 64642857
+ 0.07 0.50 0.79 71714286
+ 0.07 0.50 0.79 78785714
+ 0.07 0.50 0.79 85857143
+ 0.07 0.50 0.79 92928571
+ 0.07 0.50 0.79 100000000
+ 0.07 0.50 0.86 1000000
+ 0.07 0.50 0.86 8071429
+ 0.07 0.50 0.86 15142857
+ 0.07 0.50 0.86 22214286
+ 0.07 0.50 0.86 29285714
+ 0.07 0.50 0.86 36357143
+ 0.07 0.50 0.86 43428571
+ 0.07 0.50 0.86 50500000
+ 0.07 0.50 0.86 57571429
+ 0.07 0.50 0.86 64642857
+ 0.07 0.50 0.86 71714286
+ 0.07 0.50 0.86 78785714
+ 0.07 0.50 0.86 85857143
+ 0.07 0.50 0.86 92928571
+ 0.07 0.50 0.86 100000000
+ 0.07 0.50 0.93 1000000
+ 0.07 0.50 0.93 8071429
+ 0.07 0.50 0.93 15142857
+ 0.07 0.50 0.93 22214286
+ 0.07 0.50 0.93 29285714
+ 0.07 0.50 0.93 36357143
+ 0.07 0.50 0.93 43428571
+ 0.07 0.50 0.93 50500000
+ 0.07 0.50 0.93 57571429
+ 0.07 0.50 0.93 64642857
+ 0.07 0.50 0.93 71714286
+ 0.07 0.50 0.93 78785714
+ 0.07 0.50 0.93 85857143
+ 0.07 0.50 0.93 92928571
+ 0.07 0.50 0.93 100000000
+ 0.07 0.50 1.00 1000000
+ 0.07 0.50 1.00 8071429
+ 0.07 0.50 1.00 15142857
+ 0.07 0.50 1.00 22214286
+ 0.07 0.50 1.00 29285714
+ 0.07 0.50 1.00 36357143
+ 0.07 0.50 1.00 43428571
+ 0.07 0.50 1.00 50500000
+ 0.07 0.50 1.00 57571429
+ 0.07 0.50 1.00 64642857
+ 0.07 0.50 1.00 71714286
+ 0.07 0.50 1.00 78785714
+ 0.07 0.50 1.00 85857143
+ 0.07 0.50 1.00 92928571
+ 0.07 0.50 1.00 100000000
+ 0.07 0.57 0.00 1000000
+ 0.07 0.57 0.00 8071429
+ 0.07 0.57 0.00 15142857
+ 0.07 0.57 0.00 22214286
+ 0.07 0.57 0.00 29285714
+ 0.07 0.57 0.00 36357143
+ 0.07 0.57 0.00 43428571
+ 0.07 0.57 0.00 50500000
+ 0.07 0.57 0.00 57571429
+ 0.07 0.57 0.00 64642857
+ 0.07 0.57 0.00 71714286
+ 0.07 0.57 0.00 78785714
+ 0.07 0.57 0.00 85857143
+ 0.07 0.57 0.00 92928571
+ 0.07 0.57 0.00 100000000
+ 0.07 0.57 0.07 1000000
+ 0.07 0.57 0.07 8071429
+ 0.07 0.57 0.07 15142857
+ 0.07 0.57 0.07 22214286
+ 0.07 0.57 0.07 29285714
+ 0.07 0.57 0.07 36357143
+ 0.07 0.57 0.07 43428571
+ 0.07 0.57 0.07 50500000
+ 0.07 0.57 0.07 57571429
+ 0.07 0.57 0.07 64642857
+ 0.07 0.57 0.07 71714286
+ 0.07 0.57 0.07 78785714
+ 0.07 0.57 0.07 85857143
+ 0.07 0.57 0.07 92928571
+ 0.07 0.57 0.07 100000000
+ 0.07 0.57 0.14 1000000
+ 0.07 0.57 0.14 8071429
+ 0.07 0.57 0.14 15142857
+ 0.07 0.57 0.14 22214286
+ 0.07 0.57 0.14 29285714
+ 0.07 0.57 0.14 36357143
+ 0.07 0.57 0.14 43428571
+ 0.07 0.57 0.14 50500000
+ 0.07 0.57 0.14 57571429
+ 0.07 0.57 0.14 64642857
+ 0.07 0.57 0.14 71714286
+ 0.07 0.57 0.14 78785714
+ 0.07 0.57 0.14 85857143
+ 0.07 0.57 0.14 92928571
+ 0.07 0.57 0.14 100000000
+ 0.07 0.57 0.21 1000000
+ 0.07 0.57 0.21 8071429
+ 0.07 0.57 0.21 15142857
+ 0.07 0.57 0.21 22214286
+ 0.07 0.57 0.21 29285714
+ 0.07 0.57 0.21 36357143
+ 0.07 0.57 0.21 43428571
+ 0.07 0.57 0.21 50500000
+ 0.07 0.57 0.21 57571429
+ 0.07 0.57 0.21 64642857
+ 0.07 0.57 0.21 71714286
+ 0.07 0.57 0.21 78785714
+ 0.07 0.57 0.21 85857143
+ 0.07 0.57 0.21 92928571
+ 0.07 0.57 0.21 100000000
+ 0.07 0.57 0.29 1000000
+ 0.07 0.57 0.29 8071429
+ 0.07 0.57 0.29 15142857
+ 0.07 0.57 0.29 22214286
+ 0.07 0.57 0.29 29285714
+ 0.07 0.57 0.29 36357143
+ 0.07 0.57 0.29 43428571
+ 0.07 0.57 0.29 50500000
+ 0.07 0.57 0.29 57571429
+ 0.07 0.57 0.29 64642857
+ 0.07 0.57 0.29 71714286
+ 0.07 0.57 0.29 78785714
+ 0.07 0.57 0.29 85857143
+ 0.07 0.57 0.29 92928571
+ 0.07 0.57 0.29 100000000
+ 0.07 0.57 0.36 1000000
+ 0.07 0.57 0.36 8071429
+ 0.07 0.57 0.36 15142857
+ 0.07 0.57 0.36 22214286
+ 0.07 0.57 0.36 29285714
+ 0.07 0.57 0.36 36357143
+ 0.07 0.57 0.36 43428571
+ 0.07 0.57 0.36 50500000
+ 0.07 0.57 0.36 57571429
+ 0.07 0.57 0.36 64642857
+ 0.07 0.57 0.36 71714286
+ 0.07 0.57 0.36 78785714
+ 0.07 0.57 0.36 85857143
+ 0.07 0.57 0.36 92928571
+ 0.07 0.57 0.36 100000000
+ 0.07 0.57 0.43 1000000
+ 0.07 0.57 0.43 8071429
+ 0.07 0.57 0.43 15142857
+ 0.07 0.57 0.43 22214286
+ 0.07 0.57 0.43 29285714
+ 0.07 0.57 0.43 36357143
+ 0.07 0.57 0.43 43428571
+ 0.07 0.57 0.43 50500000
+ 0.07 0.57 0.43 57571429
+ 0.07 0.57 0.43 64642857
+ 0.07 0.57 0.43 71714286
+ 0.07 0.57 0.43 78785714
+ 0.07 0.57 0.43 85857143
+ 0.07 0.57 0.43 92928571
+ 0.07 0.57 0.43 100000000
+ 0.07 0.57 0.50 1000000
+ 0.07 0.57 0.50 8071429
+ 0.07 0.57 0.50 15142857
+ 0.07 0.57 0.50 22214286
+ 0.07 0.57 0.50 29285714
+ 0.07 0.57 0.50 36357143
+ 0.07 0.57 0.50 43428571
+ 0.07 0.57 0.50 50500000
+ 0.07 0.57 0.50 57571429
+ 0.07 0.57 0.50 64642857
+ 0.07 0.57 0.50 71714286
+ 0.07 0.57 0.50 78785714
+ 0.07 0.57 0.50 85857143
+ 0.07 0.57 0.50 92928571
+ 0.07 0.57 0.50 100000000
+ 0.07 0.57 0.57 1000000
+ 0.07 0.57 0.57 8071429
+ 0.07 0.57 0.57 15142857
+ 0.07 0.57 0.57 22214286
+ 0.07 0.57 0.57 29285714
+ 0.07 0.57 0.57 36357143
+ 0.07 0.57 0.57 43428571
+ 0.07 0.57 0.57 50500000
+ 0.07 0.57 0.57 57571429
+ 0.07 0.57 0.57 64642857
+ 0.07 0.57 0.57 71714286
+ 0.07 0.57 0.57 78785714
+ 0.07 0.57 0.57 85857143
+ 0.07 0.57 0.57 92928571
+ 0.07 0.57 0.57 100000000
+ 0.07 0.57 0.64 1000000
+ 0.07 0.57 0.64 8071429
+ 0.07 0.57 0.64 15142857
+ 0.07 0.57 0.64 22214286
+ 0.07 0.57 0.64 29285714
+ 0.07 0.57 0.64 36357143
+ 0.07 0.57 0.64 43428571
+ 0.07 0.57 0.64 50500000
+ 0.07 0.57 0.64 57571429
+ 0.07 0.57 0.64 64642857
+ 0.07 0.57 0.64 71714286
+ 0.07 0.57 0.64 78785714
+ 0.07 0.57 0.64 85857143
+ 0.07 0.57 0.64 92928571
+ 0.07 0.57 0.64 100000000
+ 0.07 0.57 0.71 1000000
+ 0.07 0.57 0.71 8071429
+ 0.07 0.57 0.71 15142857
+ 0.07 0.57 0.71 22214286
+ 0.07 0.57 0.71 29285714
+ 0.07 0.57 0.71 36357143
+ 0.07 0.57 0.71 43428571
+ 0.07 0.57 0.71 50500000
+ 0.07 0.57 0.71 57571429
+ 0.07 0.57 0.71 64642857
+ 0.07 0.57 0.71 71714286
+ 0.07 0.57 0.71 78785714
+ 0.07 0.57 0.71 85857143
+ 0.07 0.57 0.71 92928571
+ 0.07 0.57 0.71 100000000
+ 0.07 0.57 0.79 1000000
+ 0.07 0.57 0.79 8071429
+ 0.07 0.57 0.79 15142857
+ 0.07 0.57 0.79 22214286
+ 0.07 0.57 0.79 29285714
+ 0.07 0.57 0.79 36357143
+ 0.07 0.57 0.79 43428571
+ 0.07 0.57 0.79 50500000
+ 0.07 0.57 0.79 57571429
+ 0.07 0.57 0.79 64642857
+ 0.07 0.57 0.79 71714286
+ 0.07 0.57 0.79 78785714
+ 0.07 0.57 0.79 85857143
+ 0.07 0.57 0.79 92928571
+ 0.07 0.57 0.79 100000000
+ 0.07 0.57 0.86 1000000
+ 0.07 0.57 0.86 8071429
+ 0.07 0.57 0.86 15142857
+ 0.07 0.57 0.86 22214286
+ 0.07 0.57 0.86 29285714
+ 0.07 0.57 0.86 36357143
+ 0.07 0.57 0.86 43428571
+ 0.07 0.57 0.86 50500000
+ 0.07 0.57 0.86 57571429
+ 0.07 0.57 0.86 64642857
+ 0.07 0.57 0.86 71714286
+ 0.07 0.57 0.86 78785714
+ 0.07 0.57 0.86 85857143
+ 0.07 0.57 0.86 92928571
+ 0.07 0.57 0.86 100000000
+ 0.07 0.57 0.93 1000000
+ 0.07 0.57 0.93 8071429
+ 0.07 0.57 0.93 15142857
+ 0.07 0.57 0.93 22214286
+ 0.07 0.57 0.93 29285714
+ 0.07 0.57 0.93 36357143
+ 0.07 0.57 0.93 43428571
+ 0.07 0.57 0.93 50500000
+ 0.07 0.57 0.93 57571429
+ 0.07 0.57 0.93 64642857
+ 0.07 0.57 0.93 71714286
+ 0.07 0.57 0.93 78785714
+ 0.07 0.57 0.93 85857143
+ 0.07 0.57 0.93 92928571
+ 0.07 0.57 0.93 100000000
+ 0.07 0.57 1.00 1000000
+ 0.07 0.57 1.00 8071429
+ 0.07 0.57 1.00 15142857
+ 0.07 0.57 1.00 22214286
+ 0.07 0.57 1.00 29285714
+ 0.07 0.57 1.00 36357143
+ 0.07 0.57 1.00 43428571
+ 0.07 0.57 1.00 50500000
+ 0.07 0.57 1.00 57571429
+ 0.07 0.57 1.00 64642857
+ 0.07 0.57 1.00 71714286
+ 0.07 0.57 1.00 78785714
+ 0.07 0.57 1.00 85857143
+ 0.07 0.57 1.00 92928571
+ 0.07 0.57 1.00 100000000
+ 0.07 0.64 0.00 1000000
+ 0.07 0.64 0.00 8071429
+ 0.07 0.64 0.00 15142857
+ 0.07 0.64 0.00 22214286
+ 0.07 0.64 0.00 29285714
+ 0.07 0.64 0.00 36357143
+ 0.07 0.64 0.00 43428571
+ 0.07 0.64 0.00 50500000
+ 0.07 0.64 0.00 57571429
+ 0.07 0.64 0.00 64642857
+ 0.07 0.64 0.00 71714286
+ 0.07 0.64 0.00 78785714
+ 0.07 0.64 0.00 85857143
+ 0.07 0.64 0.00 92928571
+ 0.07 0.64 0.00 100000000
+ 0.07 0.64 0.07 1000000
+ 0.07 0.64 0.07 8071429
+ 0.07 0.64 0.07 15142857
+ 0.07 0.64 0.07 22214286
+ 0.07 0.64 0.07 29285714
+ 0.07 0.64 0.07 36357143
+ 0.07 0.64 0.07 43428571
+ 0.07 0.64 0.07 50500000
+ 0.07 0.64 0.07 57571429
+ 0.07 0.64 0.07 64642857
+ 0.07 0.64 0.07 71714286
+ 0.07 0.64 0.07 78785714
+ 0.07 0.64 0.07 85857143
+ 0.07 0.64 0.07 92928571
+ 0.07 0.64 0.07 100000000
+ 0.07 0.64 0.14 1000000
+ 0.07 0.64 0.14 8071429
+ 0.07 0.64 0.14 15142857
+ 0.07 0.64 0.14 22214286
+ 0.07 0.64 0.14 29285714
+ 0.07 0.64 0.14 36357143
+ 0.07 0.64 0.14 43428571
+ 0.07 0.64 0.14 50500000
+ 0.07 0.64 0.14 57571429
+ 0.07 0.64 0.14 64642857
+ 0.07 0.64 0.14 71714286
+ 0.07 0.64 0.14 78785714
+ 0.07 0.64 0.14 85857143
+ 0.07 0.64 0.14 92928571
+ 0.07 0.64 0.14 100000000
+ 0.07 0.64 0.21 1000000
+ 0.07 0.64 0.21 8071429
+ 0.07 0.64 0.21 15142857
+ 0.07 0.64 0.21 22214286
+ 0.07 0.64 0.21 29285714
+ 0.07 0.64 0.21 36357143
+ 0.07 0.64 0.21 43428571
+ 0.07 0.64 0.21 50500000
+ 0.07 0.64 0.21 57571429
+ 0.07 0.64 0.21 64642857
+ 0.07 0.64 0.21 71714286
+ 0.07 0.64 0.21 78785714
+ 0.07 0.64 0.21 85857143
+ 0.07 0.64 0.21 92928571
+ 0.07 0.64 0.21 100000000
+ 0.07 0.64 0.29 1000000
+ 0.07 0.64 0.29 8071429
+ 0.07 0.64 0.29 15142857
+ 0.07 0.64 0.29 22214286
+ 0.07 0.64 0.29 29285714
+ 0.07 0.64 0.29 36357143
+ 0.07 0.64 0.29 43428571
+ 0.07 0.64 0.29 50500000
+ 0.07 0.64 0.29 57571429
+ 0.07 0.64 0.29 64642857
+ 0.07 0.64 0.29 71714286
+ 0.07 0.64 0.29 78785714
+ 0.07 0.64 0.29 85857143
+ 0.07 0.64 0.29 92928571
+ 0.07 0.64 0.29 100000000
+ 0.07 0.64 0.36 1000000
+ 0.07 0.64 0.36 8071429
+ 0.07 0.64 0.36 15142857
+ 0.07 0.64 0.36 22214286
+ 0.07 0.64 0.36 29285714
+ 0.07 0.64 0.36 36357143
+ 0.07 0.64 0.36 43428571
+ 0.07 0.64 0.36 50500000
+ 0.07 0.64 0.36 57571429
+ 0.07 0.64 0.36 64642857
+ 0.07 0.64 0.36 71714286
+ 0.07 0.64 0.36 78785714
+ 0.07 0.64 0.36 85857143
+ 0.07 0.64 0.36 92928571
+ 0.07 0.64 0.36 100000000
+ 0.07 0.64 0.43 1000000
+ 0.07 0.64 0.43 8071429
+ 0.07 0.64 0.43 15142857
+ 0.07 0.64 0.43 22214286
+ 0.07 0.64 0.43 29285714
+ 0.07 0.64 0.43 36357143
+ 0.07 0.64 0.43 43428571
+ 0.07 0.64 0.43 50500000
+ 0.07 0.64 0.43 57571429
+ 0.07 0.64 0.43 64642857
+ 0.07 0.64 0.43 71714286
+ 0.07 0.64 0.43 78785714
+ 0.07 0.64 0.43 85857143
+ 0.07 0.64 0.43 92928571
+ 0.07 0.64 0.43 100000000
+ 0.07 0.64 0.50 1000000
+ 0.07 0.64 0.50 8071429
+ 0.07 0.64 0.50 15142857
+ 0.07 0.64 0.50 22214286
+ 0.07 0.64 0.50 29285714
+ 0.07 0.64 0.50 36357143
+ 0.07 0.64 0.50 43428571
+ 0.07 0.64 0.50 50500000
+ 0.07 0.64 0.50 57571429
+ 0.07 0.64 0.50 64642857
+ 0.07 0.64 0.50 71714286
+ 0.07 0.64 0.50 78785714
+ 0.07 0.64 0.50 85857143
+ 0.07 0.64 0.50 92928571
+ 0.07 0.64 0.50 100000000
+ 0.07 0.64 0.57 1000000
+ 0.07 0.64 0.57 8071429
+ 0.07 0.64 0.57 15142857
+ 0.07 0.64 0.57 22214286
+ 0.07 0.64 0.57 29285714
+ 0.07 0.64 0.57 36357143
+ 0.07 0.64 0.57 43428571
+ 0.07 0.64 0.57 50500000
+ 0.07 0.64 0.57 57571429
+ 0.07 0.64 0.57 64642857
+ 0.07 0.64 0.57 71714286
+ 0.07 0.64 0.57 78785714
+ 0.07 0.64 0.57 85857143
+ 0.07 0.64 0.57 92928571
+ 0.07 0.64 0.57 100000000
+ 0.07 0.64 0.64 1000000
+ 0.07 0.64 0.64 8071429
+ 0.07 0.64 0.64 15142857
+ 0.07 0.64 0.64 22214286
+ 0.07 0.64 0.64 29285714
+ 0.07 0.64 0.64 36357143
+ 0.07 0.64 0.64 43428571
+ 0.07 0.64 0.64 50500000
+ 0.07 0.64 0.64 57571429
+ 0.07 0.64 0.64 64642857
+ 0.07 0.64 0.64 71714286
+ 0.07 0.64 0.64 78785714
+ 0.07 0.64 0.64 85857143
+ 0.07 0.64 0.64 92928571
+ 0.07 0.64 0.64 100000000
+ 0.07 0.64 0.71 1000000
+ 0.07 0.64 0.71 8071429
+ 0.07 0.64 0.71 15142857
+ 0.07 0.64 0.71 22214286
+ 0.07 0.64 0.71 29285714
+ 0.07 0.64 0.71 36357143
+ 0.07 0.64 0.71 43428571
+ 0.07 0.64 0.71 50500000
+ 0.07 0.64 0.71 57571429
+ 0.07 0.64 0.71 64642857
+ 0.07 0.64 0.71 71714286
+ 0.07 0.64 0.71 78785714
+ 0.07 0.64 0.71 85857143
+ 0.07 0.64 0.71 92928571
+ 0.07 0.64 0.71 100000000
+ 0.07 0.64 0.79 1000000
+ 0.07 0.64 0.79 8071429
+ 0.07 0.64 0.79 15142857
+ 0.07 0.64 0.79 22214286
+ 0.07 0.64 0.79 29285714
+ 0.07 0.64 0.79 36357143
+ 0.07 0.64 0.79 43428571
+ 0.07 0.64 0.79 50500000
+ 0.07 0.64 0.79 57571429
+ 0.07 0.64 0.79 64642857
+ 0.07 0.64 0.79 71714286
+ 0.07 0.64 0.79 78785714
+ 0.07 0.64 0.79 85857143
+ 0.07 0.64 0.79 92928571
+ 0.07 0.64 0.79 100000000
+ 0.07 0.64 0.86 1000000
+ 0.07 0.64 0.86 8071429
+ 0.07 0.64 0.86 15142857
+ 0.07 0.64 0.86 22214286
+ 0.07 0.64 0.86 29285714
+ 0.07 0.64 0.86 36357143
+ 0.07 0.64 0.86 43428571
+ 0.07 0.64 0.86 50500000
+ 0.07 0.64 0.86 57571429
+ 0.07 0.64 0.86 64642857
+ 0.07 0.64 0.86 71714286
+ 0.07 0.64 0.86 78785714
+ 0.07 0.64 0.86 85857143
+ 0.07 0.64 0.86 92928571
+ 0.07 0.64 0.86 100000000
+ 0.07 0.64 0.93 1000000
+ 0.07 0.64 0.93 8071429
+ 0.07 0.64 0.93 15142857
+ 0.07 0.64 0.93 22214286
+ 0.07 0.64 0.93 29285714
+ 0.07 0.64 0.93 36357143
+ 0.07 0.64 0.93 43428571
+ 0.07 0.64 0.93 50500000
+ 0.07 0.64 0.93 57571429
+ 0.07 0.64 0.93 64642857
+ 0.07 0.64 0.93 71714286
+ 0.07 0.64 0.93 78785714
+ 0.07 0.64 0.93 85857143
+ 0.07 0.64 0.93 92928571
+ 0.07 0.64 0.93 100000000
+ 0.07 0.64 1.00 1000000
+ 0.07 0.64 1.00 8071429
+ 0.07 0.64 1.00 15142857
+ 0.07 0.64 1.00 22214286
+ 0.07 0.64 1.00 29285714
+ 0.07 0.64 1.00 36357143
+ 0.07 0.64 1.00 43428571
+ 0.07 0.64 1.00 50500000
+ 0.07 0.64 1.00 57571429
+ 0.07 0.64 1.00 64642857
+ 0.07 0.64 1.00 71714286
+ 0.07 0.64 1.00 78785714
+ 0.07 0.64 1.00 85857143
+ 0.07 0.64 1.00 92928571
+ 0.07 0.64 1.00 100000000
+ 0.07 0.71 0.00 1000000
+ 0.07 0.71 0.00 8071429
+ 0.07 0.71 0.00 15142857
+ 0.07 0.71 0.00 22214286
+ 0.07 0.71 0.00 29285714
+ 0.07 0.71 0.00 36357143
+ 0.07 0.71 0.00 43428571
+ 0.07 0.71 0.00 50500000
+ 0.07 0.71 0.00 57571429
+ 0.07 0.71 0.00 64642857
+ 0.07 0.71 0.00 71714286
+ 0.07 0.71 0.00 78785714
+ 0.07 0.71 0.00 85857143
+ 0.07 0.71 0.00 92928571
+ 0.07 0.71 0.00 100000000
+ 0.07 0.71 0.07 1000000
+ 0.07 0.71 0.07 8071429
+ 0.07 0.71 0.07 15142857
+ 0.07 0.71 0.07 22214286
+ 0.07 0.71 0.07 29285714
+ 0.07 0.71 0.07 36357143
+ 0.07 0.71 0.07 43428571
+ 0.07 0.71 0.07 50500000
+ 0.07 0.71 0.07 57571429
+ 0.07 0.71 0.07 64642857
+ 0.07 0.71 0.07 71714286
+ 0.07 0.71 0.07 78785714
+ 0.07 0.71 0.07 85857143
+ 0.07 0.71 0.07 92928571
+ 0.07 0.71 0.07 100000000
+ 0.07 0.71 0.14 1000000
+ 0.07 0.71 0.14 8071429
+ 0.07 0.71 0.14 15142857
+ 0.07 0.71 0.14 22214286
+ 0.07 0.71 0.14 29285714
+ 0.07 0.71 0.14 36357143
+ 0.07 0.71 0.14 43428571
+ 0.07 0.71 0.14 50500000
+ 0.07 0.71 0.14 57571429
+ 0.07 0.71 0.14 64642857
+ 0.07 0.71 0.14 71714286
+ 0.07 0.71 0.14 78785714
+ 0.07 0.71 0.14 85857143
+ 0.07 0.71 0.14 92928571
+ 0.07 0.71 0.14 100000000
+ 0.07 0.71 0.21 1000000
+ 0.07 0.71 0.21 8071429
+ 0.07 0.71 0.21 15142857
+ 0.07 0.71 0.21 22214286
+ 0.07 0.71 0.21 29285714
+ 0.07 0.71 0.21 36357143
+ 0.07 0.71 0.21 43428571
+ 0.07 0.71 0.21 50500000
+ 0.07 0.71 0.21 57571429
+ 0.07 0.71 0.21 64642857
+ 0.07 0.71 0.21 71714286
+ 0.07 0.71 0.21 78785714
+ 0.07 0.71 0.21 85857143
+ 0.07 0.71 0.21 92928571
+ 0.07 0.71 0.21 100000000
+ 0.07 0.71 0.29 1000000
+ 0.07 0.71 0.29 8071429
+ 0.07 0.71 0.29 15142857
+ 0.07 0.71 0.29 22214286
+ 0.07 0.71 0.29 29285714
+ 0.07 0.71 0.29 36357143
+ 0.07 0.71 0.29 43428571
+ 0.07 0.71 0.29 50500000
+ 0.07 0.71 0.29 57571429
+ 0.07 0.71 0.29 64642857
+ 0.07 0.71 0.29 71714286
+ 0.07 0.71 0.29 78785714
+ 0.07 0.71 0.29 85857143
+ 0.07 0.71 0.29 92928571
+ 0.07 0.71 0.29 100000000
+ 0.07 0.71 0.36 1000000
+ 0.07 0.71 0.36 8071429
+ 0.07 0.71 0.36 15142857
+ 0.07 0.71 0.36 22214286
+ 0.07 0.71 0.36 29285714
+ 0.07 0.71 0.36 36357143
+ 0.07 0.71 0.36 43428571
+ 0.07 0.71 0.36 50500000
+ 0.07 0.71 0.36 57571429
+ 0.07 0.71 0.36 64642857
+ 0.07 0.71 0.36 71714286
+ 0.07 0.71 0.36 78785714
+ 0.07 0.71 0.36 85857143
+ 0.07 0.71 0.36 92928571
+ 0.07 0.71 0.36 100000000
+ 0.07 0.71 0.43 1000000
+ 0.07 0.71 0.43 8071429
+ 0.07 0.71 0.43 15142857
+ 0.07 0.71 0.43 22214286
+ 0.07 0.71 0.43 29285714
+ 0.07 0.71 0.43 36357143
+ 0.07 0.71 0.43 43428571
+ 0.07 0.71 0.43 50500000
+ 0.07 0.71 0.43 57571429
+ 0.07 0.71 0.43 64642857
+ 0.07 0.71 0.43 71714286
+ 0.07 0.71 0.43 78785714
+ 0.07 0.71 0.43 85857143
+ 0.07 0.71 0.43 92928571
+ 0.07 0.71 0.43 100000000
+ 0.07 0.71 0.50 1000000
+ 0.07 0.71 0.50 8071429
+ 0.07 0.71 0.50 15142857
+ 0.07 0.71 0.50 22214286
+ 0.07 0.71 0.50 29285714
+ 0.07 0.71 0.50 36357143
+ 0.07 0.71 0.50 43428571
+ 0.07 0.71 0.50 50500000
+ 0.07 0.71 0.50 57571429
+ 0.07 0.71 0.50 64642857
+ 0.07 0.71 0.50 71714286
+ 0.07 0.71 0.50 78785714
+ 0.07 0.71 0.50 85857143
+ 0.07 0.71 0.50 92928571
+ 0.07 0.71 0.50 100000000
+ 0.07 0.71 0.57 1000000
+ 0.07 0.71 0.57 8071429
+ 0.07 0.71 0.57 15142857
+ 0.07 0.71 0.57 22214286
+ 0.07 0.71 0.57 29285714
+ 0.07 0.71 0.57 36357143
+ 0.07 0.71 0.57 43428571
+ 0.07 0.71 0.57 50500000
+ 0.07 0.71 0.57 57571429
+ 0.07 0.71 0.57 64642857
+ 0.07 0.71 0.57 71714286
+ 0.07 0.71 0.57 78785714
+ 0.07 0.71 0.57 85857143
+ 0.07 0.71 0.57 92928571
+ 0.07 0.71 0.57 100000000
+ 0.07 0.71 0.64 1000000
+ 0.07 0.71 0.64 8071429
+ 0.07 0.71 0.64 15142857
+ 0.07 0.71 0.64 22214286
+ 0.07 0.71 0.64 29285714
+ 0.07 0.71 0.64 36357143
+ 0.07 0.71 0.64 43428571
+ 0.07 0.71 0.64 50500000
+ 0.07 0.71 0.64 57571429
+ 0.07 0.71 0.64 64642857
+ 0.07 0.71 0.64 71714286
+ 0.07 0.71 0.64 78785714
+ 0.07 0.71 0.64 85857143
+ 0.07 0.71 0.64 92928571
+ 0.07 0.71 0.64 100000000
+ 0.07 0.71 0.71 1000000
+ 0.07 0.71 0.71 8071429
+ 0.07 0.71 0.71 15142857
+ 0.07 0.71 0.71 22214286
+ 0.07 0.71 0.71 29285714
+ 0.07 0.71 0.71 36357143
+ 0.07 0.71 0.71 43428571
+ 0.07 0.71 0.71 50500000
+ 0.07 0.71 0.71 57571429
+ 0.07 0.71 0.71 64642857
+ 0.07 0.71 0.71 71714286
+ 0.07 0.71 0.71 78785714
+ 0.07 0.71 0.71 85857143
+ 0.07 0.71 0.71 92928571
+ 0.07 0.71 0.71 100000000
+ 0.07 0.71 0.79 1000000
+ 0.07 0.71 0.79 8071429
+ 0.07 0.71 0.79 15142857
+ 0.07 0.71 0.79 22214286
+ 0.07 0.71 0.79 29285714
+ 0.07 0.71 0.79 36357143
+ 0.07 0.71 0.79 43428571
+ 0.07 0.71 0.79 50500000
+ 0.07 0.71 0.79 57571429
+ 0.07 0.71 0.79 64642857
+ 0.07 0.71 0.79 71714286
+ 0.07 0.71 0.79 78785714
+ 0.07 0.71 0.79 85857143
+ 0.07 0.71 0.79 92928571
+ 0.07 0.71 0.79 100000000
+ 0.07 0.71 0.86 1000000
+ 0.07 0.71 0.86 8071429
+ 0.07 0.71 0.86 15142857
+ 0.07 0.71 0.86 22214286
+ 0.07 0.71 0.86 29285714
+ 0.07 0.71 0.86 36357143
+ 0.07 0.71 0.86 43428571
+ 0.07 0.71 0.86 50500000
+ 0.07 0.71 0.86 57571429
+ 0.07 0.71 0.86 64642857
+ 0.07 0.71 0.86 71714286
+ 0.07 0.71 0.86 78785714
+ 0.07 0.71 0.86 85857143
+ 0.07 0.71 0.86 92928571
+ 0.07 0.71 0.86 100000000
+ 0.07 0.71 0.93 1000000
+ 0.07 0.71 0.93 8071429
+ 0.07 0.71 0.93 15142857
+ 0.07 0.71 0.93 22214286
+ 0.07 0.71 0.93 29285714
+ 0.07 0.71 0.93 36357143
+ 0.07 0.71 0.93 43428571
+ 0.07 0.71 0.93 50500000
+ 0.07 0.71 0.93 57571429
+ 0.07 0.71 0.93 64642857
+ 0.07 0.71 0.93 71714286
+ 0.07 0.71 0.93 78785714
+ 0.07 0.71 0.93 85857143
+ 0.07 0.71 0.93 92928571
+ 0.07 0.71 0.93 100000000
+ 0.07 0.71 1.00 1000000
+ 0.07 0.71 1.00 8071429
+ 0.07 0.71 1.00 15142857
+ 0.07 0.71 1.00 22214286
+ 0.07 0.71 1.00 29285714
+ 0.07 0.71 1.00 36357143
+ 0.07 0.71 1.00 43428571
+ 0.07 0.71 1.00 50500000
+ 0.07 0.71 1.00 57571429
+ 0.07 0.71 1.00 64642857
+ 0.07 0.71 1.00 71714286
+ 0.07 0.71 1.00 78785714
+ 0.07 0.71 1.00 85857143
+ 0.07 0.71 1.00 92928571
+ 0.07 0.71 1.00 100000000
+ 0.07 0.79 0.00 1000000
+ 0.07 0.79 0.00 8071429
+ 0.07 0.79 0.00 15142857
+ 0.07 0.79 0.00 22214286
+ 0.07 0.79 0.00 29285714
+ 0.07 0.79 0.00 36357143
+ 0.07 0.79 0.00 43428571
+ 0.07 0.79 0.00 50500000
+ 0.07 0.79 0.00 57571429
+ 0.07 0.79 0.00 64642857
+ 0.07 0.79 0.00 71714286
+ 0.07 0.79 0.00 78785714
+ 0.07 0.79 0.00 85857143
+ 0.07 0.79 0.00 92928571
+ 0.07 0.79 0.00 100000000
+ 0.07 0.79 0.07 1000000
+ 0.07 0.79 0.07 8071429
+ 0.07 0.79 0.07 15142857
+ 0.07 0.79 0.07 22214286
+ 0.07 0.79 0.07 29285714
+ 0.07 0.79 0.07 36357143
+ 0.07 0.79 0.07 43428571
+ 0.07 0.79 0.07 50500000
+ 0.07 0.79 0.07 57571429
+ 0.07 0.79 0.07 64642857
+ 0.07 0.79 0.07 71714286
+ 0.07 0.79 0.07 78785714
+ 0.07 0.79 0.07 85857143
+ 0.07 0.79 0.07 92928571
+ 0.07 0.79 0.07 100000000
+ 0.07 0.79 0.14 1000000
+ 0.07 0.79 0.14 8071429
+ 0.07 0.79 0.14 15142857
+ 0.07 0.79 0.14 22214286
+ 0.07 0.79 0.14 29285714
+ 0.07 0.79 0.14 36357143
+ 0.07 0.79 0.14 43428571
+ 0.07 0.79 0.14 50500000
+ 0.07 0.79 0.14 57571429
+ 0.07 0.79 0.14 64642857
+ 0.07 0.79 0.14 71714286
+ 0.07 0.79 0.14 78785714
+ 0.07 0.79 0.14 85857143
+ 0.07 0.79 0.14 92928571
+ 0.07 0.79 0.14 100000000
+ 0.07 0.79 0.21 1000000
+ 0.07 0.79 0.21 8071429
+ 0.07 0.79 0.21 15142857
+ 0.07 0.79 0.21 22214286
+ 0.07 0.79 0.21 29285714
+ 0.07 0.79 0.21 36357143
+ 0.07 0.79 0.21 43428571
+ 0.07 0.79 0.21 50500000
+ 0.07 0.79 0.21 57571429
+ 0.07 0.79 0.21 64642857
+ 0.07 0.79 0.21 71714286
+ 0.07 0.79 0.21 78785714
+ 0.07 0.79 0.21 85857143
+ 0.07 0.79 0.21 92928571
+ 0.07 0.79 0.21 100000000
+ 0.07 0.79 0.29 1000000
+ 0.07 0.79 0.29 8071429
+ 0.07 0.79 0.29 15142857
+ 0.07 0.79 0.29 22214286
+ 0.07 0.79 0.29 29285714
+ 0.07 0.79 0.29 36357143
+ 0.07 0.79 0.29 43428571
+ 0.07 0.79 0.29 50500000
+ 0.07 0.79 0.29 57571429
+ 0.07 0.79 0.29 64642857
+ 0.07 0.79 0.29 71714286
+ 0.07 0.79 0.29 78785714
+ 0.07 0.79 0.29 85857143
+ 0.07 0.79 0.29 92928571
+ 0.07 0.79 0.29 100000000
+ 0.07 0.79 0.36 1000000
+ 0.07 0.79 0.36 8071429
+ 0.07 0.79 0.36 15142857
+ 0.07 0.79 0.36 22214286
+ 0.07 0.79 0.36 29285714
+ 0.07 0.79 0.36 36357143
+ 0.07 0.79 0.36 43428571
+ 0.07 0.79 0.36 50500000
+ 0.07 0.79 0.36 57571429
+ 0.07 0.79 0.36 64642857
+ 0.07 0.79 0.36 71714286
+ 0.07 0.79 0.36 78785714
+ 0.07 0.79 0.36 85857143
+ 0.07 0.79 0.36 92928571
+ 0.07 0.79 0.36 100000000
+ 0.07 0.79 0.43 1000000
+ 0.07 0.79 0.43 8071429
+ 0.07 0.79 0.43 15142857
+ 0.07 0.79 0.43 22214286
+ 0.07 0.79 0.43 29285714
+ 0.07 0.79 0.43 36357143
+ 0.07 0.79 0.43 43428571
+ 0.07 0.79 0.43 50500000
+ 0.07 0.79 0.43 57571429
+ 0.07 0.79 0.43 64642857
+ 0.07 0.79 0.43 71714286
+ 0.07 0.79 0.43 78785714
+ 0.07 0.79 0.43 85857143
+ 0.07 0.79 0.43 92928571
+ 0.07 0.79 0.43 100000000
+ 0.07 0.79 0.50 1000000
+ 0.07 0.79 0.50 8071429
+ 0.07 0.79 0.50 15142857
+ 0.07 0.79 0.50 22214286
+ 0.07 0.79 0.50 29285714
+ 0.07 0.79 0.50 36357143
+ 0.07 0.79 0.50 43428571
+ 0.07 0.79 0.50 50500000
+ 0.07 0.79 0.50 57571429
+ 0.07 0.79 0.50 64642857
+ 0.07 0.79 0.50 71714286
+ 0.07 0.79 0.50 78785714
+ 0.07 0.79 0.50 85857143
+ 0.07 0.79 0.50 92928571
+ 0.07 0.79 0.50 100000000
+ 0.07 0.79 0.57 1000000
+ 0.07 0.79 0.57 8071429
+ 0.07 0.79 0.57 15142857
+ 0.07 0.79 0.57 22214286
+ 0.07 0.79 0.57 29285714
+ 0.07 0.79 0.57 36357143
+ 0.07 0.79 0.57 43428571
+ 0.07 0.79 0.57 50500000
+ 0.07 0.79 0.57 57571429
+ 0.07 0.79 0.57 64642857
+ 0.07 0.79 0.57 71714286
+ 0.07 0.79 0.57 78785714
+ 0.07 0.79 0.57 85857143
+ 0.07 0.79 0.57 92928571
+ 0.07 0.79 0.57 100000000
+ 0.07 0.79 0.64 1000000
+ 0.07 0.79 0.64 8071429
+ 0.07 0.79 0.64 15142857
+ 0.07 0.79 0.64 22214286
+ 0.07 0.79 0.64 29285714
+ 0.07 0.79 0.64 36357143
+ 0.07 0.79 0.64 43428571
+ 0.07 0.79 0.64 50500000
+ 0.07 0.79 0.64 57571429
+ 0.07 0.79 0.64 64642857
+ 0.07 0.79 0.64 71714286
+ 0.07 0.79 0.64 78785714
+ 0.07 0.79 0.64 85857143
+ 0.07 0.79 0.64 92928571
+ 0.07 0.79 0.64 100000000
+ 0.07 0.79 0.71 1000000
+ 0.07 0.79 0.71 8071429
+ 0.07 0.79 0.71 15142857
+ 0.07 0.79 0.71 22214286
+ 0.07 0.79 0.71 29285714
+ 0.07 0.79 0.71 36357143
+ 0.07 0.79 0.71 43428571
+ 0.07 0.79 0.71 50500000
+ 0.07 0.79 0.71 57571429
+ 0.07 0.79 0.71 64642857
+ 0.07 0.79 0.71 71714286
+ 0.07 0.79 0.71 78785714
+ 0.07 0.79 0.71 85857143
+ 0.07 0.79 0.71 92928571
+ 0.07 0.79 0.71 100000000
+ 0.07 0.79 0.79 1000000
+ 0.07 0.79 0.79 8071429
+ 0.07 0.79 0.79 15142857
+ 0.07 0.79 0.79 22214286
+ 0.07 0.79 0.79 29285714
+ 0.07 0.79 0.79 36357143
+ 0.07 0.79 0.79 43428571
+ 0.07 0.79 0.79 50500000
+ 0.07 0.79 0.79 57571429
+ 0.07 0.79 0.79 64642857
+ 0.07 0.79 0.79 71714286
+ 0.07 0.79 0.79 78785714
+ 0.07 0.79 0.79 85857143
+ 0.07 0.79 0.79 92928571
+ 0.07 0.79 0.79 100000000
+ 0.07 0.79 0.86 1000000
+ 0.07 0.79 0.86 8071429
+ 0.07 0.79 0.86 15142857
+ 0.07 0.79 0.86 22214286
+ 0.07 0.79 0.86 29285714
+ 0.07 0.79 0.86 36357143
+ 0.07 0.79 0.86 43428571
+ 0.07 0.79 0.86 50500000
+ 0.07 0.79 0.86 57571429
+ 0.07 0.79 0.86 64642857
+ 0.07 0.79 0.86 71714286
+ 0.07 0.79 0.86 78785714
+ 0.07 0.79 0.86 85857143
+ 0.07 0.79 0.86 92928571
+ 0.07 0.79 0.86 100000000
+ 0.07 0.79 0.93 1000000
+ 0.07 0.79 0.93 8071429
+ 0.07 0.79 0.93 15142857
+ 0.07 0.79 0.93 22214286
+ 0.07 0.79 0.93 29285714
+ 0.07 0.79 0.93 36357143
+ 0.07 0.79 0.93 43428571
+ 0.07 0.79 0.93 50500000
+ 0.07 0.79 0.93 57571429
+ 0.07 0.79 0.93 64642857
+ 0.07 0.79 0.93 71714286
+ 0.07 0.79 0.93 78785714
+ 0.07 0.79 0.93 85857143
+ 0.07 0.79 0.93 92928571
+ 0.07 0.79 0.93 100000000
+ 0.07 0.79 1.00 1000000
+ 0.07 0.79 1.00 8071429
+ 0.07 0.79 1.00 15142857
+ 0.07 0.79 1.00 22214286
+ 0.07 0.79 1.00 29285714
+ 0.07 0.79 1.00 36357143
+ 0.07 0.79 1.00 43428571
+ 0.07 0.79 1.00 50500000
+ 0.07 0.79 1.00 57571429
+ 0.07 0.79 1.00 64642857
+ 0.07 0.79 1.00 71714286
+ 0.07 0.79 1.00 78785714
+ 0.07 0.79 1.00 85857143
+ 0.07 0.79 1.00 92928571
+ 0.07 0.79 1.00 100000000
+ 0.07 0.86 0.00 1000000
+ 0.07 0.86 0.00 8071429
+ 0.07 0.86 0.00 15142857
+ 0.07 0.86 0.00 22214286
+ 0.07 0.86 0.00 29285714
+ 0.07 0.86 0.00 36357143
+ 0.07 0.86 0.00 43428571
+ 0.07 0.86 0.00 50500000
+ 0.07 0.86 0.00 57571429
+ 0.07 0.86 0.00 64642857
+ 0.07 0.86 0.00 71714286
+ 0.07 0.86 0.00 78785714
+ 0.07 0.86 0.00 85857143
+ 0.07 0.86 0.00 92928571
+ 0.07 0.86 0.00 100000000
+ 0.07 0.86 0.07 1000000
+ 0.07 0.86 0.07 8071429
+ 0.07 0.86 0.07 15142857
+ 0.07 0.86 0.07 22214286
+ 0.07 0.86 0.07 29285714
+ 0.07 0.86 0.07 36357143
+ 0.07 0.86 0.07 43428571
+ 0.07 0.86 0.07 50500000
+ 0.07 0.86 0.07 57571429
+ 0.07 0.86 0.07 64642857
+ 0.07 0.86 0.07 71714286
+ 0.07 0.86 0.07 78785714
+ 0.07 0.86 0.07 85857143
+ 0.07 0.86 0.07 92928571
+ 0.07 0.86 0.07 100000000
+ 0.07 0.86 0.14 1000000
+ 0.07 0.86 0.14 8071429
+ 0.07 0.86 0.14 15142857
+ 0.07 0.86 0.14 22214286
+ 0.07 0.86 0.14 29285714
+ 0.07 0.86 0.14 36357143
+ 0.07 0.86 0.14 43428571
+ 0.07 0.86 0.14 50500000
+ 0.07 0.86 0.14 57571429
+ 0.07 0.86 0.14 64642857
+ 0.07 0.86 0.14 71714286
+ 0.07 0.86 0.14 78785714
+ 0.07 0.86 0.14 85857143
+ 0.07 0.86 0.14 92928571
+ 0.07 0.86 0.14 100000000
+ 0.07 0.86 0.21 1000000
+ 0.07 0.86 0.21 8071429
+ 0.07 0.86 0.21 15142857
+ 0.07 0.86 0.21 22214286
+ 0.07 0.86 0.21 29285714
+ 0.07 0.86 0.21 36357143
+ 0.07 0.86 0.21 43428571
+ 0.07 0.86 0.21 50500000
+ 0.07 0.86 0.21 57571429
+ 0.07 0.86 0.21 64642857
+ 0.07 0.86 0.21 71714286
+ 0.07 0.86 0.21 78785714
+ 0.07 0.86 0.21 85857143
+ 0.07 0.86 0.21 92928571
+ 0.07 0.86 0.21 100000000
+ 0.07 0.86 0.29 1000000
+ 0.07 0.86 0.29 8071429
+ 0.07 0.86 0.29 15142857
+ 0.07 0.86 0.29 22214286
+ 0.07 0.86 0.29 29285714
+ 0.07 0.86 0.29 36357143
+ 0.07 0.86 0.29 43428571
+ 0.07 0.86 0.29 50500000
+ 0.07 0.86 0.29 57571429
+ 0.07 0.86 0.29 64642857
+ 0.07 0.86 0.29 71714286
+ 0.07 0.86 0.29 78785714
+ 0.07 0.86 0.29 85857143
+ 0.07 0.86 0.29 92928571
+ 0.07 0.86 0.29 100000000
+ 0.07 0.86 0.36 1000000
+ 0.07 0.86 0.36 8071429
+ 0.07 0.86 0.36 15142857
+ 0.07 0.86 0.36 22214286
+ 0.07 0.86 0.36 29285714
+ 0.07 0.86 0.36 36357143
+ 0.07 0.86 0.36 43428571
+ 0.07 0.86 0.36 50500000
+ 0.07 0.86 0.36 57571429
+ 0.07 0.86 0.36 64642857
+ 0.07 0.86 0.36 71714286
+ 0.07 0.86 0.36 78785714
+ 0.07 0.86 0.36 85857143
+ 0.07 0.86 0.36 92928571
+ 0.07 0.86 0.36 100000000
+ 0.07 0.86 0.43 1000000
+ 0.07 0.86 0.43 8071429
+ 0.07 0.86 0.43 15142857
+ 0.07 0.86 0.43 22214286
+ 0.07 0.86 0.43 29285714
+ 0.07 0.86 0.43 36357143
+ 0.07 0.86 0.43 43428571
+ 0.07 0.86 0.43 50500000
+ 0.07 0.86 0.43 57571429
+ 0.07 0.86 0.43 64642857
+ 0.07 0.86 0.43 71714286
+ 0.07 0.86 0.43 78785714
+ 0.07 0.86 0.43 85857143
+ 0.07 0.86 0.43 92928571
+ 0.07 0.86 0.43 100000000
+ 0.07 0.86 0.50 1000000
+ 0.07 0.86 0.50 8071429
+ 0.07 0.86 0.50 15142857
+ 0.07 0.86 0.50 22214286
+ 0.07 0.86 0.50 29285714
+ 0.07 0.86 0.50 36357143
+ 0.07 0.86 0.50 43428571
+ 0.07 0.86 0.50 50500000
+ 0.07 0.86 0.50 57571429
+ 0.07 0.86 0.50 64642857
+ 0.07 0.86 0.50 71714286
+ 0.07 0.86 0.50 78785714
+ 0.07 0.86 0.50 85857143
+ 0.07 0.86 0.50 92928571
+ 0.07 0.86 0.50 100000000
+ 0.07 0.86 0.57 1000000
+ 0.07 0.86 0.57 8071429
+ 0.07 0.86 0.57 15142857
+ 0.07 0.86 0.57 22214286
+ 0.07 0.86 0.57 29285714
+ 0.07 0.86 0.57 36357143
+ 0.07 0.86 0.57 43428571
+ 0.07 0.86 0.57 50500000
+ 0.07 0.86 0.57 57571429
+ 0.07 0.86 0.57 64642857
+ 0.07 0.86 0.57 71714286
+ 0.07 0.86 0.57 78785714
+ 0.07 0.86 0.57 85857143
+ 0.07 0.86 0.57 92928571
+ 0.07 0.86 0.57 100000000
+ 0.07 0.86 0.64 1000000
+ 0.07 0.86 0.64 8071429
+ 0.07 0.86 0.64 15142857
+ 0.07 0.86 0.64 22214286
+ 0.07 0.86 0.64 29285714
+ 0.07 0.86 0.64 36357143
+ 0.07 0.86 0.64 43428571
+ 0.07 0.86 0.64 50500000
+ 0.07 0.86 0.64 57571429
+ 0.07 0.86 0.64 64642857
+ 0.07 0.86 0.64 71714286
+ 0.07 0.86 0.64 78785714
+ 0.07 0.86 0.64 85857143
+ 0.07 0.86 0.64 92928571
+ 0.07 0.86 0.64 100000000
+ 0.07 0.86 0.71 1000000
+ 0.07 0.86 0.71 8071429
+ 0.07 0.86 0.71 15142857
+ 0.07 0.86 0.71 22214286
+ 0.07 0.86 0.71 29285714
+ 0.07 0.86 0.71 36357143
+ 0.07 0.86 0.71 43428571
+ 0.07 0.86 0.71 50500000
+ 0.07 0.86 0.71 57571429
+ 0.07 0.86 0.71 64642857
+ 0.07 0.86 0.71 71714286
+ 0.07 0.86 0.71 78785714
+ 0.07 0.86 0.71 85857143
+ 0.07 0.86 0.71 92928571
+ 0.07 0.86 0.71 100000000
+ 0.07 0.86 0.79 1000000
+ 0.07 0.86 0.79 8071429
+ 0.07 0.86 0.79 15142857
+ 0.07 0.86 0.79 22214286
+ 0.07 0.86 0.79 29285714
+ 0.07 0.86 0.79 36357143
+ 0.07 0.86 0.79 43428571
+ 0.07 0.86 0.79 50500000
+ 0.07 0.86 0.79 57571429
+ 0.07 0.86 0.79 64642857
+ 0.07 0.86 0.79 71714286
+ 0.07 0.86 0.79 78785714
+ 0.07 0.86 0.79 85857143
+ 0.07 0.86 0.79 92928571
+ 0.07 0.86 0.79 100000000
+ 0.07 0.86 0.86 1000000
+ 0.07 0.86 0.86 8071429
+ 0.07 0.86 0.86 15142857
+ 0.07 0.86 0.86 22214286
+ 0.07 0.86 0.86 29285714
+ 0.07 0.86 0.86 36357143
+ 0.07 0.86 0.86 43428571
+ 0.07 0.86 0.86 50500000
+ 0.07 0.86 0.86 57571429
+ 0.07 0.86 0.86 64642857
+ 0.07 0.86 0.86 71714286
+ 0.07 0.86 0.86 78785714
+ 0.07 0.86 0.86 85857143
+ 0.07 0.86 0.86 92928571
+ 0.07 0.86 0.86 100000000
+ 0.07 0.86 0.93 1000000
+ 0.07 0.86 0.93 8071429
+ 0.07 0.86 0.93 15142857
+ 0.07 0.86 0.93 22214286
+ 0.07 0.86 0.93 29285714
+ 0.07 0.86 0.93 36357143
+ 0.07 0.86 0.93 43428571
+ 0.07 0.86 0.93 50500000
+ 0.07 0.86 0.93 57571429
+ 0.07 0.86 0.93 64642857
+ 0.07 0.86 0.93 71714286
+ 0.07 0.86 0.93 78785714
+ 0.07 0.86 0.93 85857143
+ 0.07 0.86 0.93 92928571
+ 0.07 0.86 0.93 100000000
+ 0.07 0.86 1.00 1000000
+ 0.07 0.86 1.00 8071429
+ 0.07 0.86 1.00 15142857
+ 0.07 0.86 1.00 22214286
+ 0.07 0.86 1.00 29285714
+ 0.07 0.86 1.00 36357143
+ 0.07 0.86 1.00 43428571
+ 0.07 0.86 1.00 50500000
+ 0.07 0.86 1.00 57571429
+ 0.07 0.86 1.00 64642857
+ 0.07 0.86 1.00 71714286
+ 0.07 0.86 1.00 78785714
+ 0.07 0.86 1.00 85857143
+ 0.07 0.86 1.00 92928571
+ 0.07 0.86 1.00 100000000
+ 0.07 0.93 0.00 1000000
+ 0.07 0.93 0.00 8071429
+ 0.07 0.93 0.00 15142857
+ 0.07 0.93 0.00 22214286
+ 0.07 0.93 0.00 29285714
+ 0.07 0.93 0.00 36357143
+ 0.07 0.93 0.00 43428571
+ 0.07 0.93 0.00 50500000
+ 0.07 0.93 0.00 57571429
+ 0.07 0.93 0.00 64642857
+ 0.07 0.93 0.00 71714286
+ 0.07 0.93 0.00 78785714
+ 0.07 0.93 0.00 85857143
+ 0.07 0.93 0.00 92928571
+ 0.07 0.93 0.00 100000000
+ 0.07 0.93 0.07 1000000
+ 0.07 0.93 0.07 8071429
+ 0.07 0.93 0.07 15142857
+ 0.07 0.93 0.07 22214286
+ 0.07 0.93 0.07 29285714
+ 0.07 0.93 0.07 36357143
+ 0.07 0.93 0.07 43428571
+ 0.07 0.93 0.07 50500000
+ 0.07 0.93 0.07 57571429
+ 0.07 0.93 0.07 64642857
+ 0.07 0.93 0.07 71714286
+ 0.07 0.93 0.07 78785714
+ 0.07 0.93 0.07 85857143
+ 0.07 0.93 0.07 92928571
+ 0.07 0.93 0.07 100000000
+ 0.07 0.93 0.14 1000000
+ 0.07 0.93 0.14 8071429
+ 0.07 0.93 0.14 15142857
+ 0.07 0.93 0.14 22214286
+ 0.07 0.93 0.14 29285714
+ 0.07 0.93 0.14 36357143
+ 0.07 0.93 0.14 43428571
+ 0.07 0.93 0.14 50500000
+ 0.07 0.93 0.14 57571429
+ 0.07 0.93 0.14 64642857
+ 0.07 0.93 0.14 71714286
+ 0.07 0.93 0.14 78785714
+ 0.07 0.93 0.14 85857143
+ 0.07 0.93 0.14 92928571
+ 0.07 0.93 0.14 100000000
+ 0.07 0.93 0.21 1000000
+ 0.07 0.93 0.21 8071429
+ 0.07 0.93 0.21 15142857
+ 0.07 0.93 0.21 22214286
+ 0.07 0.93 0.21 29285714
+ 0.07 0.93 0.21 36357143
+ 0.07 0.93 0.21 43428571
+ 0.07 0.93 0.21 50500000
+ 0.07 0.93 0.21 57571429
+ 0.07 0.93 0.21 64642857
+ 0.07 0.93 0.21 71714286
+ 0.07 0.93 0.21 78785714
+ 0.07 0.93 0.21 85857143
+ 0.07 0.93 0.21 92928571
+ 0.07 0.93 0.21 100000000
+ 0.07 0.93 0.29 1000000
+ 0.07 0.93 0.29 8071429
+ 0.07 0.93 0.29 15142857
+ 0.07 0.93 0.29 22214286
+ 0.07 0.93 0.29 29285714
+ 0.07 0.93 0.29 36357143
+ 0.07 0.93 0.29 43428571
+ 0.07 0.93 0.29 50500000
+ 0.07 0.93 0.29 57571429
+ 0.07 0.93 0.29 64642857
+ 0.07 0.93 0.29 71714286
+ 0.07 0.93 0.29 78785714
+ 0.07 0.93 0.29 85857143
+ 0.07 0.93 0.29 92928571
+ 0.07 0.93 0.29 100000000
+ 0.07 0.93 0.36 1000000
+ 0.07 0.93 0.36 8071429
+ 0.07 0.93 0.36 15142857
+ 0.07 0.93 0.36 22214286
+ 0.07 0.93 0.36 29285714
+ 0.07 0.93 0.36 36357143
+ 0.07 0.93 0.36 43428571
+ 0.07 0.93 0.36 50500000
+ 0.07 0.93 0.36 57571429
+ 0.07 0.93 0.36 64642857
+ 0.07 0.93 0.36 71714286
+ 0.07 0.93 0.36 78785714
+ 0.07 0.93 0.36 85857143
+ 0.07 0.93 0.36 92928571
+ 0.07 0.93 0.36 100000000
+ 0.07 0.93 0.43 1000000
+ 0.07 0.93 0.43 8071429
+ 0.07 0.93 0.43 15142857
+ 0.07 0.93 0.43 22214286
+ 0.07 0.93 0.43 29285714
+ 0.07 0.93 0.43 36357143
+ 0.07 0.93 0.43 43428571
+ 0.07 0.93 0.43 50500000
+ 0.07 0.93 0.43 57571429
+ 0.07 0.93 0.43 64642857
+ 0.07 0.93 0.43 71714286
+ 0.07 0.93 0.43 78785714
+ 0.07 0.93 0.43 85857143
+ 0.07 0.93 0.43 92928571
+ 0.07 0.93 0.43 100000000
+ 0.07 0.93 0.50 1000000
+ 0.07 0.93 0.50 8071429
+ 0.07 0.93 0.50 15142857
+ 0.07 0.93 0.50 22214286
+ 0.07 0.93 0.50 29285714
+ 0.07 0.93 0.50 36357143
+ 0.07 0.93 0.50 43428571
+ 0.07 0.93 0.50 50500000
+ 0.07 0.93 0.50 57571429
+ 0.07 0.93 0.50 64642857
+ 0.07 0.93 0.50 71714286
+ 0.07 0.93 0.50 78785714
+ 0.07 0.93 0.50 85857143
+ 0.07 0.93 0.50 92928571
+ 0.07 0.93 0.50 100000000
+ 0.07 0.93 0.57 1000000
+ 0.07 0.93 0.57 8071429
+ 0.07 0.93 0.57 15142857
+ 0.07 0.93 0.57 22214286
+ 0.07 0.93 0.57 29285714
+ 0.07 0.93 0.57 36357143
+ 0.07 0.93 0.57 43428571
+ 0.07 0.93 0.57 50500000
+ 0.07 0.93 0.57 57571429
+ 0.07 0.93 0.57 64642857
+ 0.07 0.93 0.57 71714286
+ 0.07 0.93 0.57 78785714
+ 0.07 0.93 0.57 85857143
+ 0.07 0.93 0.57 92928571
+ 0.07 0.93 0.57 100000000
+ 0.07 0.93 0.64 1000000
+ 0.07 0.93 0.64 8071429
+ 0.07 0.93 0.64 15142857
+ 0.07 0.93 0.64 22214286
+ 0.07 0.93 0.64 29285714
+ 0.07 0.93 0.64 36357143
+ 0.07 0.93 0.64 43428571
+ 0.07 0.93 0.64 50500000
+ 0.07 0.93 0.64 57571429
+ 0.07 0.93 0.64 64642857
+ 0.07 0.93 0.64 71714286
+ 0.07 0.93 0.64 78785714
+ 0.07 0.93 0.64 85857143
+ 0.07 0.93 0.64 92928571
+ 0.07 0.93 0.64 100000000
+ 0.07 0.93 0.71 1000000
+ 0.07 0.93 0.71 8071429
+ 0.07 0.93 0.71 15142857
+ 0.07 0.93 0.71 22214286
+ 0.07 0.93 0.71 29285714
+ 0.07 0.93 0.71 36357143
+ 0.07 0.93 0.71 43428571
+ 0.07 0.93 0.71 50500000
+ 0.07 0.93 0.71 57571429
+ 0.07 0.93 0.71 64642857
+ 0.07 0.93 0.71 71714286
+ 0.07 0.93 0.71 78785714
+ 0.07 0.93 0.71 85857143
+ 0.07 0.93 0.71 92928571
+ 0.07 0.93 0.71 100000000
+ 0.07 0.93 0.79 1000000
+ 0.07 0.93 0.79 8071429
+ 0.07 0.93 0.79 15142857
+ 0.07 0.93 0.79 22214286
+ 0.07 0.93 0.79 29285714
+ 0.07 0.93 0.79 36357143
+ 0.07 0.93 0.79 43428571
+ 0.07 0.93 0.79 50500000
+ 0.07 0.93 0.79 57571429
+ 0.07 0.93 0.79 64642857
+ 0.07 0.93 0.79 71714286
+ 0.07 0.93 0.79 78785714
+ 0.07 0.93 0.79 85857143
+ 0.07 0.93 0.79 92928571
+ 0.07 0.93 0.79 100000000
+ 0.07 0.93 0.86 1000000
+ 0.07 0.93 0.86 8071429
+ 0.07 0.93 0.86 15142857
+ 0.07 0.93 0.86 22214286
+ 0.07 0.93 0.86 29285714
+ 0.07 0.93 0.86 36357143
+ 0.07 0.93 0.86 43428571
+ 0.07 0.93 0.86 50500000
+ 0.07 0.93 0.86 57571429
+ 0.07 0.93 0.86 64642857
+ 0.07 0.93 0.86 71714286
+ 0.07 0.93 0.86 78785714
+ 0.07 0.93 0.86 85857143
+ 0.07 0.93 0.86 92928571
+ 0.07 0.93 0.86 100000000
+ 0.07 0.93 0.93 1000000
+ 0.07 0.93 0.93 8071429
+ 0.07 0.93 0.93 15142857
+ 0.07 0.93 0.93 22214286
+ 0.07 0.93 0.93 29285714
+ 0.07 0.93 0.93 36357143
+ 0.07 0.93 0.93 43428571
+ 0.07 0.93 0.93 50500000
+ 0.07 0.93 0.93 57571429
+ 0.07 0.93 0.93 64642857
+ 0.07 0.93 0.93 71714286
+ 0.07 0.93 0.93 78785714
+ 0.07 0.93 0.93 85857143
+ 0.07 0.93 0.93 92928571
+ 0.07 0.93 0.93 100000000
+ 0.07 0.93 1.00 1000000
+ 0.07 0.93 1.00 8071429
+ 0.07 0.93 1.00 15142857
+ 0.07 0.93 1.00 22214286
+ 0.07 0.93 1.00 29285714
+ 0.07 0.93 1.00 36357143
+ 0.07 0.93 1.00 43428571
+ 0.07 0.93 1.00 50500000
+ 0.07 0.93 1.00 57571429
+ 0.07 0.93 1.00 64642857
+ 0.07 0.93 1.00 71714286
+ 0.07 0.93 1.00 78785714
+ 0.07 0.93 1.00 85857143
+ 0.07 0.93 1.00 92928571
+ 0.07 0.93 1.00 100000000
+ 0.07 1.00 0.00 1000000
+ 0.07 1.00 0.00 8071429
+ 0.07 1.00 0.00 15142857
+ 0.07 1.00 0.00 22214286
+ 0.07 1.00 0.00 29285714
+ 0.07 1.00 0.00 36357143
+ 0.07 1.00 0.00 43428571
+ 0.07 1.00 0.00 50500000
+ 0.07 1.00 0.00 57571429
+ 0.07 1.00 0.00 64642857
+ 0.07 1.00 0.00 71714286
+ 0.07 1.00 0.00 78785714
+ 0.07 1.00 0.00 85857143
+ 0.07 1.00 0.00 92928571
+ 0.07 1.00 0.00 100000000
+ 0.07 1.00 0.07 1000000
+ 0.07 1.00 0.07 8071429
+ 0.07 1.00 0.07 15142857
+ 0.07 1.00 0.07 22214286
+ 0.07 1.00 0.07 29285714
+ 0.07 1.00 0.07 36357143
+ 0.07 1.00 0.07 43428571
+ 0.07 1.00 0.07 50500000
+ 0.07 1.00 0.07 57571429
+ 0.07 1.00 0.07 64642857
+ 0.07 1.00 0.07 71714286
+ 0.07 1.00 0.07 78785714
+ 0.07 1.00 0.07 85857143
+ 0.07 1.00 0.07 92928571
+ 0.07 1.00 0.07 100000000
+ 0.07 1.00 0.14 1000000
+ 0.07 1.00 0.14 8071429
+ 0.07 1.00 0.14 15142857
+ 0.07 1.00 0.14 22214286
+ 0.07 1.00 0.14 29285714
+ 0.07 1.00 0.14 36357143
+ 0.07 1.00 0.14 43428571
+ 0.07 1.00 0.14 50500000
+ 0.07 1.00 0.14 57571429
+ 0.07 1.00 0.14 64642857
+ 0.07 1.00 0.14 71714286
+ 0.07 1.00 0.14 78785714
+ 0.07 1.00 0.14 85857143
+ 0.07 1.00 0.14 92928571
+ 0.07 1.00 0.14 100000000
+ 0.07 1.00 0.21 1000000
+ 0.07 1.00 0.21 8071429
+ 0.07 1.00 0.21 15142857
+ 0.07 1.00 0.21 22214286
+ 0.07 1.00 0.21 29285714
+ 0.07 1.00 0.21 36357143
+ 0.07 1.00 0.21 43428571
+ 0.07 1.00 0.21 50500000
+ 0.07 1.00 0.21 57571429
+ 0.07 1.00 0.21 64642857
+ 0.07 1.00 0.21 71714286
+ 0.07 1.00 0.21 78785714
+ 0.07 1.00 0.21 85857143
+ 0.07 1.00 0.21 92928571
+ 0.07 1.00 0.21 100000000
+ 0.07 1.00 0.29 1000000
+ 0.07 1.00 0.29 8071429
+ 0.07 1.00 0.29 15142857
+ 0.07 1.00 0.29 22214286
+ 0.07 1.00 0.29 29285714
+ 0.07 1.00 0.29 36357143
+ 0.07 1.00 0.29 43428571
+ 0.07 1.00 0.29 50500000
+ 0.07 1.00 0.29 57571429
+ 0.07 1.00 0.29 64642857
+ 0.07 1.00 0.29 71714286
+ 0.07 1.00 0.29 78785714
+ 0.07 1.00 0.29 85857143
+ 0.07 1.00 0.29 92928571
+ 0.07 1.00 0.29 100000000
+ 0.07 1.00 0.36 1000000
+ 0.07 1.00 0.36 8071429
+ 0.07 1.00 0.36 15142857
+ 0.07 1.00 0.36 22214286
+ 0.07 1.00 0.36 29285714
+ 0.07 1.00 0.36 36357143
+ 0.07 1.00 0.36 43428571
+ 0.07 1.00 0.36 50500000
+ 0.07 1.00 0.36 57571429
+ 0.07 1.00 0.36 64642857
+ 0.07 1.00 0.36 71714286
+ 0.07 1.00 0.36 78785714
+ 0.07 1.00 0.36 85857143
+ 0.07 1.00 0.36 92928571
+ 0.07 1.00 0.36 100000000
+ 0.07 1.00 0.43 1000000
+ 0.07 1.00 0.43 8071429
+ 0.07 1.00 0.43 15142857
+ 0.07 1.00 0.43 22214286
+ 0.07 1.00 0.43 29285714
+ 0.07 1.00 0.43 36357143
+ 0.07 1.00 0.43 43428571
+ 0.07 1.00 0.43 50500000
+ 0.07 1.00 0.43 57571429
+ 0.07 1.00 0.43 64642857
+ 0.07 1.00 0.43 71714286
+ 0.07 1.00 0.43 78785714
+ 0.07 1.00 0.43 85857143
+ 0.07 1.00 0.43 92928571
+ 0.07 1.00 0.43 100000000
+ 0.07 1.00 0.50 1000000
+ 0.07 1.00 0.50 8071429
+ 0.07 1.00 0.50 15142857
+ 0.07 1.00 0.50 22214286
+ 0.07 1.00 0.50 29285714
+ 0.07 1.00 0.50 36357143
+ 0.07 1.00 0.50 43428571
+ 0.07 1.00 0.50 50500000
+ 0.07 1.00 0.50 57571429
+ 0.07 1.00 0.50 64642857
+ 0.07 1.00 0.50 71714286
+ 0.07 1.00 0.50 78785714
+ 0.07 1.00 0.50 85857143
+ 0.07 1.00 0.50 92928571
+ 0.07 1.00 0.50 100000000
+ 0.07 1.00 0.57 1000000
+ 0.07 1.00 0.57 8071429
+ 0.07 1.00 0.57 15142857
+ 0.07 1.00 0.57 22214286
+ 0.07 1.00 0.57 29285714
+ 0.07 1.00 0.57 36357143
+ 0.07 1.00 0.57 43428571
+ 0.07 1.00 0.57 50500000
+ 0.07 1.00 0.57 57571429
+ 0.07 1.00 0.57 64642857
+ 0.07 1.00 0.57 71714286
+ 0.07 1.00 0.57 78785714
+ 0.07 1.00 0.57 85857143
+ 0.07 1.00 0.57 92928571
+ 0.07 1.00 0.57 100000000
+ 0.07 1.00 0.64 1000000
+ 0.07 1.00 0.64 8071429
+ 0.07 1.00 0.64 15142857
+ 0.07 1.00 0.64 22214286
+ 0.07 1.00 0.64 29285714
+ 0.07 1.00 0.64 36357143
+ 0.07 1.00 0.64 43428571
+ 0.07 1.00 0.64 50500000
+ 0.07 1.00 0.64 57571429
+ 0.07 1.00 0.64 64642857
+ 0.07 1.00 0.64 71714286
+ 0.07 1.00 0.64 78785714
+ 0.07 1.00 0.64 85857143
+ 0.07 1.00 0.64 92928571
+ 0.07 1.00 0.64 100000000
+ 0.07 1.00 0.71 1000000
+ 0.07 1.00 0.71 8071429
+ 0.07 1.00 0.71 15142857
+ 0.07 1.00 0.71 22214286
+ 0.07 1.00 0.71 29285714
+ 0.07 1.00 0.71 36357143
+ 0.07 1.00 0.71 43428571
+ 0.07 1.00 0.71 50500000
+ 0.07 1.00 0.71 57571429
+ 0.07 1.00 0.71 64642857
+ 0.07 1.00 0.71 71714286
+ 0.07 1.00 0.71 78785714
+ 0.07 1.00 0.71 85857143
+ 0.07 1.00 0.71 92928571
+ 0.07 1.00 0.71 100000000
+ 0.07 1.00 0.79 1000000
+ 0.07 1.00 0.79 8071429
+ 0.07 1.00 0.79 15142857
+ 0.07 1.00 0.79 22214286
+ 0.07 1.00 0.79 29285714
+ 0.07 1.00 0.79 36357143
+ 0.07 1.00 0.79 43428571
+ 0.07 1.00 0.79 50500000
+ 0.07 1.00 0.79 57571429
+ 0.07 1.00 0.79 64642857
+ 0.07 1.00 0.79 71714286
+ 0.07 1.00 0.79 78785714
+ 0.07 1.00 0.79 85857143
+ 0.07 1.00 0.79 92928571
+ 0.07 1.00 0.79 100000000
+ 0.07 1.00 0.86 1000000
+ 0.07 1.00 0.86 8071429
+ 0.07 1.00 0.86 15142857
+ 0.07 1.00 0.86 22214286
+ 0.07 1.00 0.86 29285714
+ 0.07 1.00 0.86 36357143
+ 0.07 1.00 0.86 43428571
+ 0.07 1.00 0.86 50500000
+ 0.07 1.00 0.86 57571429
+ 0.07 1.00 0.86 64642857
+ 0.07 1.00 0.86 71714286
+ 0.07 1.00 0.86 78785714
+ 0.07 1.00 0.86 85857143
+ 0.07 1.00 0.86 92928571
+ 0.07 1.00 0.86 100000000
+ 0.07 1.00 0.93 1000000
+ 0.07 1.00 0.93 8071429
+ 0.07 1.00 0.93 15142857
+ 0.07 1.00 0.93 22214286
+ 0.07 1.00 0.93 29285714
+ 0.07 1.00 0.93 36357143
+ 0.07 1.00 0.93 43428571
+ 0.07 1.00 0.93 50500000
+ 0.07 1.00 0.93 57571429
+ 0.07 1.00 0.93 64642857
+ 0.07 1.00 0.93 71714286
+ 0.07 1.00 0.93 78785714
+ 0.07 1.00 0.93 85857143
+ 0.07 1.00 0.93 92928571
+ 0.07 1.00 0.93 100000000
+ 0.07 1.00 1.00 1000000
+ 0.07 1.00 1.00 8071429
+ 0.07 1.00 1.00 15142857
+ 0.07 1.00 1.00 22214286
+ 0.07 1.00 1.00 29285714
+ 0.07 1.00 1.00 36357143
+ 0.07 1.00 1.00 43428571
+ 0.07 1.00 1.00 50500000
+ 0.07 1.00 1.00 57571429
+ 0.07 1.00 1.00 64642857
+ 0.07 1.00 1.00 71714286
+ 0.07 1.00 1.00 78785714
+ 0.07 1.00 1.00 85857143
+ 0.07 1.00 1.00 92928571
+ 0.07 1.00 1.00 100000000
+ 0.14 0.00 0.00 1000000
+ 0.14 0.00 0.00 8071429
+ 0.14 0.00 0.00 15142857
+ 0.14 0.00 0.00 22214286
+ 0.14 0.00 0.00 29285714
+ 0.14 0.00 0.00 36357143
+ 0.14 0.00 0.00 43428571
+ 0.14 0.00 0.00 50500000
+ 0.14 0.00 0.00 57571429
+ 0.14 0.00 0.00 64642857
+ 0.14 0.00 0.00 71714286
+ 0.14 0.00 0.00 78785714
+ 0.14 0.00 0.00 85857143
+ 0.14 0.00 0.00 92928571
+ 0.14 0.00 0.00 100000000
+ 0.14 0.00 0.07 1000000
+ 0.14 0.00 0.07 8071429
+ 0.14 0.00 0.07 15142857
+ 0.14 0.00 0.07 22214286
+ 0.14 0.00 0.07 29285714
+ 0.14 0.00 0.07 36357143
+ 0.14 0.00 0.07 43428571
+ 0.14 0.00 0.07 50500000
+ 0.14 0.00 0.07 57571429
+ 0.14 0.00 0.07 64642857
+ 0.14 0.00 0.07 71714286
+ 0.14 0.00 0.07 78785714
+ 0.14 0.00 0.07 85857143
+ 0.14 0.00 0.07 92928571
+ 0.14 0.00 0.07 100000000
+ 0.14 0.00 0.14 1000000
+ 0.14 0.00 0.14 8071429
+ 0.14 0.00 0.14 15142857
+ 0.14 0.00 0.14 22214286
+ 0.14 0.00 0.14 29285714
+ 0.14 0.00 0.14 36357143
+ 0.14 0.00 0.14 43428571
+ 0.14 0.00 0.14 50500000
+ 0.14 0.00 0.14 57571429
+ 0.14 0.00 0.14 64642857
+ 0.14 0.00 0.14 71714286
+ 0.14 0.00 0.14 78785714
+ 0.14 0.00 0.14 85857143
+ 0.14 0.00 0.14 92928571
+ 0.14 0.00 0.14 100000000
+ 0.14 0.00 0.21 1000000
+ 0.14 0.00 0.21 8071429
+ 0.14 0.00 0.21 15142857
+ 0.14 0.00 0.21 22214286
+ 0.14 0.00 0.21 29285714
+ 0.14 0.00 0.21 36357143
+ 0.14 0.00 0.21 43428571
+ 0.14 0.00 0.21 50500000
+ 0.14 0.00 0.21 57571429
+ 0.14 0.00 0.21 64642857
+ 0.14 0.00 0.21 71714286
+ 0.14 0.00 0.21 78785714
+ 0.14 0.00 0.21 85857143
+ 0.14 0.00 0.21 92928571
+ 0.14 0.00 0.21 100000000
+ 0.14 0.00 0.29 1000000
+ 0.14 0.00 0.29 8071429
+ 0.14 0.00 0.29 15142857
+ 0.14 0.00 0.29 22214286
+ 0.14 0.00 0.29 29285714
+ 0.14 0.00 0.29 36357143
+ 0.14 0.00 0.29 43428571
+ 0.14 0.00 0.29 50500000
+ 0.14 0.00 0.29 57571429
+ 0.14 0.00 0.29 64642857
+ 0.14 0.00 0.29 71714286
+ 0.14 0.00 0.29 78785714
+ 0.14 0.00 0.29 85857143
+ 0.14 0.00 0.29 92928571
+ 0.14 0.00 0.29 100000000
+ 0.14 0.00 0.36 1000000
+ 0.14 0.00 0.36 8071429
+ 0.14 0.00 0.36 15142857
+ 0.14 0.00 0.36 22214286
+ 0.14 0.00 0.36 29285714
+ 0.14 0.00 0.36 36357143
+ 0.14 0.00 0.36 43428571
+ 0.14 0.00 0.36 50500000
+ 0.14 0.00 0.36 57571429
+ 0.14 0.00 0.36 64642857
+ 0.14 0.00 0.36 71714286
+ 0.14 0.00 0.36 78785714
+ 0.14 0.00 0.36 85857143
+ 0.14 0.00 0.36 92928571
+ 0.14 0.00 0.36 100000000
+ 0.14 0.00 0.43 1000000
+ 0.14 0.00 0.43 8071429
+ 0.14 0.00 0.43 15142857
+ 0.14 0.00 0.43 22214286
+ 0.14 0.00 0.43 29285714
+ 0.14 0.00 0.43 36357143
+ 0.14 0.00 0.43 43428571
+ 0.14 0.00 0.43 50500000
+ 0.14 0.00 0.43 57571429
+ 0.14 0.00 0.43 64642857
+ 0.14 0.00 0.43 71714286
+ 0.14 0.00 0.43 78785714
+ 0.14 0.00 0.43 85857143
+ 0.14 0.00 0.43 92928571
+ 0.14 0.00 0.43 100000000
+ 0.14 0.00 0.50 1000000
+ 0.14 0.00 0.50 8071429
+ 0.14 0.00 0.50 15142857
+ 0.14 0.00 0.50 22214286
+ 0.14 0.00 0.50 29285714
+ 0.14 0.00 0.50 36357143
+ 0.14 0.00 0.50 43428571
+ 0.14 0.00 0.50 50500000
+ 0.14 0.00 0.50 57571429
+ 0.14 0.00 0.50 64642857
+ 0.14 0.00 0.50 71714286
+ 0.14 0.00 0.50 78785714
+ 0.14 0.00 0.50 85857143
+ 0.14 0.00 0.50 92928571
+ 0.14 0.00 0.50 100000000
+ 0.14 0.00 0.57 1000000
+ 0.14 0.00 0.57 8071429
+ 0.14 0.00 0.57 15142857
+ 0.14 0.00 0.57 22214286
+ 0.14 0.00 0.57 29285714
+ 0.14 0.00 0.57 36357143
+ 0.14 0.00 0.57 43428571
+ 0.14 0.00 0.57 50500000
+ 0.14 0.00 0.57 57571429
+ 0.14 0.00 0.57 64642857
+ 0.14 0.00 0.57 71714286
+ 0.14 0.00 0.57 78785714
+ 0.14 0.00 0.57 85857143
+ 0.14 0.00 0.57 92928571
+ 0.14 0.00 0.57 100000000
+ 0.14 0.00 0.64 1000000
+ 0.14 0.00 0.64 8071429
+ 0.14 0.00 0.64 15142857
+ 0.14 0.00 0.64 22214286
+ 0.14 0.00 0.64 29285714
+ 0.14 0.00 0.64 36357143
+ 0.14 0.00 0.64 43428571
+ 0.14 0.00 0.64 50500000
+ 0.14 0.00 0.64 57571429
+ 0.14 0.00 0.64 64642857
+ 0.14 0.00 0.64 71714286
+ 0.14 0.00 0.64 78785714
+ 0.14 0.00 0.64 85857143
+ 0.14 0.00 0.64 92928571
+ 0.14 0.00 0.64 100000000
+ 0.14 0.00 0.71 1000000
+ 0.14 0.00 0.71 8071429
+ 0.14 0.00 0.71 15142857
+ 0.14 0.00 0.71 22214286
+ 0.14 0.00 0.71 29285714
+ 0.14 0.00 0.71 36357143
+ 0.14 0.00 0.71 43428571
+ 0.14 0.00 0.71 50500000
+ 0.14 0.00 0.71 57571429
+ 0.14 0.00 0.71 64642857
+ 0.14 0.00 0.71 71714286
+ 0.14 0.00 0.71 78785714
+ 0.14 0.00 0.71 85857143
+ 0.14 0.00 0.71 92928571
+ 0.14 0.00 0.71 100000000
+ 0.14 0.00 0.79 1000000
+ 0.14 0.00 0.79 8071429
+ 0.14 0.00 0.79 15142857
+ 0.14 0.00 0.79 22214286
+ 0.14 0.00 0.79 29285714
+ 0.14 0.00 0.79 36357143
+ 0.14 0.00 0.79 43428571
+ 0.14 0.00 0.79 50500000
+ 0.14 0.00 0.79 57571429
+ 0.14 0.00 0.79 64642857
+ 0.14 0.00 0.79 71714286
+ 0.14 0.00 0.79 78785714
+ 0.14 0.00 0.79 85857143
+ 0.14 0.00 0.79 92928571
+ 0.14 0.00 0.79 100000000
+ 0.14 0.00 0.86 1000000
+ 0.14 0.00 0.86 8071429
+ 0.14 0.00 0.86 15142857
+ 0.14 0.00 0.86 22214286
+ 0.14 0.00 0.86 29285714
+ 0.14 0.00 0.86 36357143
+ 0.14 0.00 0.86 43428571
+ 0.14 0.00 0.86 50500000
+ 0.14 0.00 0.86 57571429
+ 0.14 0.00 0.86 64642857
+ 0.14 0.00 0.86 71714286
+ 0.14 0.00 0.86 78785714
+ 0.14 0.00 0.86 85857143
+ 0.14 0.00 0.86 92928571
+ 0.14 0.00 0.86 100000000
+ 0.14 0.00 0.93 1000000
+ 0.14 0.00 0.93 8071429
+ 0.14 0.00 0.93 15142857
+ 0.14 0.00 0.93 22214286
+ 0.14 0.00 0.93 29285714
+ 0.14 0.00 0.93 36357143
+ 0.14 0.00 0.93 43428571
+ 0.14 0.00 0.93 50500000
+ 0.14 0.00 0.93 57571429
+ 0.14 0.00 0.93 64642857
+ 0.14 0.00 0.93 71714286
+ 0.14 0.00 0.93 78785714
+ 0.14 0.00 0.93 85857143
+ 0.14 0.00 0.93 92928571
+ 0.14 0.00 0.93 100000000
+ 0.14 0.00 1.00 1000000
+ 0.14 0.00 1.00 8071429
+ 0.14 0.00 1.00 15142857
+ 0.14 0.00 1.00 22214286
+ 0.14 0.00 1.00 29285714
+ 0.14 0.00 1.00 36357143
+ 0.14 0.00 1.00 43428571
+ 0.14 0.00 1.00 50500000
+ 0.14 0.00 1.00 57571429
+ 0.14 0.00 1.00 64642857
+ 0.14 0.00 1.00 71714286
+ 0.14 0.00 1.00 78785714
+ 0.14 0.00 1.00 85857143
+ 0.14 0.00 1.00 92928571
+ 0.14 0.00 1.00 100000000
+ 0.14 0.07 0.00 1000000
+ 0.14 0.07 0.00 8071429
+ 0.14 0.07 0.00 15142857
+ 0.14 0.07 0.00 22214286
+ 0.14 0.07 0.00 29285714
+ 0.14 0.07 0.00 36357143
+ 0.14 0.07 0.00 43428571
+ 0.14 0.07 0.00 50500000
+ 0.14 0.07 0.00 57571429
+ 0.14 0.07 0.00 64642857
+ 0.14 0.07 0.00 71714286
+ 0.14 0.07 0.00 78785714
+ 0.14 0.07 0.00 85857143
+ 0.14 0.07 0.00 92928571
+ 0.14 0.07 0.00 100000000
+ 0.14 0.07 0.07 1000000
+ 0.14 0.07 0.07 8071429
+ 0.14 0.07 0.07 15142857
+ 0.14 0.07 0.07 22214286
+ 0.14 0.07 0.07 29285714
+ 0.14 0.07 0.07 36357143
+ 0.14 0.07 0.07 43428571
+ 0.14 0.07 0.07 50500000
+ 0.14 0.07 0.07 57571429
+ 0.14 0.07 0.07 64642857
+ 0.14 0.07 0.07 71714286
+ 0.14 0.07 0.07 78785714
+ 0.14 0.07 0.07 85857143
+ 0.14 0.07 0.07 92928571
+ 0.14 0.07 0.07 100000000
+ 0.14 0.07 0.14 1000000
+ 0.14 0.07 0.14 8071429
+ 0.14 0.07 0.14 15142857
+ 0.14 0.07 0.14 22214286
+ 0.14 0.07 0.14 29285714
+ 0.14 0.07 0.14 36357143
+ 0.14 0.07 0.14 43428571
+ 0.14 0.07 0.14 50500000
+ 0.14 0.07 0.14 57571429
+ 0.14 0.07 0.14 64642857
+ 0.14 0.07 0.14 71714286
+ 0.14 0.07 0.14 78785714
+ 0.14 0.07 0.14 85857143
+ 0.14 0.07 0.14 92928571
+ 0.14 0.07 0.14 100000000
+ 0.14 0.07 0.21 1000000
+ 0.14 0.07 0.21 8071429
+ 0.14 0.07 0.21 15142857
+ 0.14 0.07 0.21 22214286
+ 0.14 0.07 0.21 29285714
+ 0.14 0.07 0.21 36357143
+ 0.14 0.07 0.21 43428571
+ 0.14 0.07 0.21 50500000
+ 0.14 0.07 0.21 57571429
+ 0.14 0.07 0.21 64642857
+ 0.14 0.07 0.21 71714286
+ 0.14 0.07 0.21 78785714
+ 0.14 0.07 0.21 85857143
+ 0.14 0.07 0.21 92928571
+ 0.14 0.07 0.21 100000000
+ 0.14 0.07 0.29 1000000
+ 0.14 0.07 0.29 8071429
+ 0.14 0.07 0.29 15142857
+ 0.14 0.07 0.29 22214286
+ 0.14 0.07 0.29 29285714
+ 0.14 0.07 0.29 36357143
+ 0.14 0.07 0.29 43428571
+ 0.14 0.07 0.29 50500000
+ 0.14 0.07 0.29 57571429
+ 0.14 0.07 0.29 64642857
+ 0.14 0.07 0.29 71714286
+ 0.14 0.07 0.29 78785714
+ 0.14 0.07 0.29 85857143
+ 0.14 0.07 0.29 92928571
+ 0.14 0.07 0.29 100000000
+ 0.14 0.07 0.36 1000000
+ 0.14 0.07 0.36 8071429
+ 0.14 0.07 0.36 15142857
+ 0.14 0.07 0.36 22214286
+ 0.14 0.07 0.36 29285714
+ 0.14 0.07 0.36 36357143
+ 0.14 0.07 0.36 43428571
+ 0.14 0.07 0.36 50500000
+ 0.14 0.07 0.36 57571429
+ 0.14 0.07 0.36 64642857
+ 0.14 0.07 0.36 71714286
+ 0.14 0.07 0.36 78785714
+ 0.14 0.07 0.36 85857143
+ 0.14 0.07 0.36 92928571
+ 0.14 0.07 0.36 100000000
+ 0.14 0.07 0.43 1000000
+ 0.14 0.07 0.43 8071429
+ 0.14 0.07 0.43 15142857
+ 0.14 0.07 0.43 22214286
+ 0.14 0.07 0.43 29285714
+ 0.14 0.07 0.43 36357143
+ 0.14 0.07 0.43 43428571
+ 0.14 0.07 0.43 50500000
+ 0.14 0.07 0.43 57571429
+ 0.14 0.07 0.43 64642857
+ 0.14 0.07 0.43 71714286
+ 0.14 0.07 0.43 78785714
+ 0.14 0.07 0.43 85857143
+ 0.14 0.07 0.43 92928571
+ 0.14 0.07 0.43 100000000
+ 0.14 0.07 0.50 1000000
+ 0.14 0.07 0.50 8071429
+ 0.14 0.07 0.50 15142857
+ 0.14 0.07 0.50 22214286
+ 0.14 0.07 0.50 29285714
+ 0.14 0.07 0.50 36357143
+ 0.14 0.07 0.50 43428571
+ 0.14 0.07 0.50 50500000
+ 0.14 0.07 0.50 57571429
+ 0.14 0.07 0.50 64642857
+ 0.14 0.07 0.50 71714286
+ 0.14 0.07 0.50 78785714
+ 0.14 0.07 0.50 85857143
+ 0.14 0.07 0.50 92928571
+ 0.14 0.07 0.50 100000000
+ 0.14 0.07 0.57 1000000
+ 0.14 0.07 0.57 8071429
+ 0.14 0.07 0.57 15142857
+ 0.14 0.07 0.57 22214286
+ 0.14 0.07 0.57 29285714
+ 0.14 0.07 0.57 36357143
+ 0.14 0.07 0.57 43428571
+ 0.14 0.07 0.57 50500000
+ 0.14 0.07 0.57 57571429
+ 0.14 0.07 0.57 64642857
+ 0.14 0.07 0.57 71714286
+ 0.14 0.07 0.57 78785714
+ 0.14 0.07 0.57 85857143
+ 0.14 0.07 0.57 92928571
+ 0.14 0.07 0.57 100000000
+ 0.14 0.07 0.64 1000000
+ 0.14 0.07 0.64 8071429
+ 0.14 0.07 0.64 15142857
+ 0.14 0.07 0.64 22214286
+ 0.14 0.07 0.64 29285714
+ 0.14 0.07 0.64 36357143
+ 0.14 0.07 0.64 43428571
+ 0.14 0.07 0.64 50500000
+ 0.14 0.07 0.64 57571429
+ 0.14 0.07 0.64 64642857
+ 0.14 0.07 0.64 71714286
+ 0.14 0.07 0.64 78785714
+ 0.14 0.07 0.64 85857143
+ 0.14 0.07 0.64 92928571
+ 0.14 0.07 0.64 100000000
+ 0.14 0.07 0.71 1000000
+ 0.14 0.07 0.71 8071429
+ 0.14 0.07 0.71 15142857
+ 0.14 0.07 0.71 22214286
+ 0.14 0.07 0.71 29285714
+ 0.14 0.07 0.71 36357143
+ 0.14 0.07 0.71 43428571
+ 0.14 0.07 0.71 50500000
+ 0.14 0.07 0.71 57571429
+ 0.14 0.07 0.71 64642857
+ 0.14 0.07 0.71 71714286
+ 0.14 0.07 0.71 78785714
+ 0.14 0.07 0.71 85857143
+ 0.14 0.07 0.71 92928571
+ 0.14 0.07 0.71 100000000
+ 0.14 0.07 0.79 1000000
+ 0.14 0.07 0.79 8071429
+ 0.14 0.07 0.79 15142857
+ 0.14 0.07 0.79 22214286
+ 0.14 0.07 0.79 29285714
+ 0.14 0.07 0.79 36357143
+ 0.14 0.07 0.79 43428571
+ 0.14 0.07 0.79 50500000
+ 0.14 0.07 0.79 57571429
+ 0.14 0.07 0.79 64642857
+ 0.14 0.07 0.79 71714286
+ 0.14 0.07 0.79 78785714
+ 0.14 0.07 0.79 85857143
+ 0.14 0.07 0.79 92928571
+ 0.14 0.07 0.79 100000000
+ 0.14 0.07 0.86 1000000
+ 0.14 0.07 0.86 8071429
+ 0.14 0.07 0.86 15142857
+ 0.14 0.07 0.86 22214286
+ 0.14 0.07 0.86 29285714
+ 0.14 0.07 0.86 36357143
+ 0.14 0.07 0.86 43428571
+ 0.14 0.07 0.86 50500000
+ 0.14 0.07 0.86 57571429
+ 0.14 0.07 0.86 64642857
+ 0.14 0.07 0.86 71714286
+ 0.14 0.07 0.86 78785714
+ 0.14 0.07 0.86 85857143
+ 0.14 0.07 0.86 92928571
+ 0.14 0.07 0.86 100000000
+ 0.14 0.07 0.93 1000000
+ 0.14 0.07 0.93 8071429
+ 0.14 0.07 0.93 15142857
+ 0.14 0.07 0.93 22214286
+ 0.14 0.07 0.93 29285714
+ 0.14 0.07 0.93 36357143
+ 0.14 0.07 0.93 43428571
+ 0.14 0.07 0.93 50500000
+ 0.14 0.07 0.93 57571429
+ 0.14 0.07 0.93 64642857
+ 0.14 0.07 0.93 71714286
+ 0.14 0.07 0.93 78785714
+ 0.14 0.07 0.93 85857143
+ 0.14 0.07 0.93 92928571
+ 0.14 0.07 0.93 100000000
+ 0.14 0.07 1.00 1000000
+ 0.14 0.07 1.00 8071429
+ 0.14 0.07 1.00 15142857
+ 0.14 0.07 1.00 22214286
+ 0.14 0.07 1.00 29285714
+ 0.14 0.07 1.00 36357143
+ 0.14 0.07 1.00 43428571
+ 0.14 0.07 1.00 50500000
+ 0.14 0.07 1.00 57571429
+ 0.14 0.07 1.00 64642857
+ 0.14 0.07 1.00 71714286
+ 0.14 0.07 1.00 78785714
+ 0.14 0.07 1.00 85857143
+ 0.14 0.07 1.00 92928571
+ 0.14 0.07 1.00 100000000
+ 0.14 0.14 0.00 1000000
+ 0.14 0.14 0.00 8071429
+ 0.14 0.14 0.00 15142857
+ 0.14 0.14 0.00 22214286
+ 0.14 0.14 0.00 29285714
+ 0.14 0.14 0.00 36357143
+ 0.14 0.14 0.00 43428571
+ 0.14 0.14 0.00 50500000
+ 0.14 0.14 0.00 57571429
+ 0.14 0.14 0.00 64642857
+ 0.14 0.14 0.00 71714286
+ 0.14 0.14 0.00 78785714
+ 0.14 0.14 0.00 85857143
+ 0.14 0.14 0.00 92928571
+ 0.14 0.14 0.00 100000000
+ 0.14 0.14 0.07 1000000
+ 0.14 0.14 0.07 8071429
+ 0.14 0.14 0.07 15142857
+ 0.14 0.14 0.07 22214286
+ 0.14 0.14 0.07 29285714
+ 0.14 0.14 0.07 36357143
+ 0.14 0.14 0.07 43428571
+ 0.14 0.14 0.07 50500000
+ 0.14 0.14 0.07 57571429
+ 0.14 0.14 0.07 64642857
+ 0.14 0.14 0.07 71714286
+ 0.14 0.14 0.07 78785714
+ 0.14 0.14 0.07 85857143
+ 0.14 0.14 0.07 92928571
+ 0.14 0.14 0.07 100000000
+ 0.14 0.14 0.14 1000000
+ 0.14 0.14 0.14 8071429
+ 0.14 0.14 0.14 15142857
+ 0.14 0.14 0.14 22214286
+ 0.14 0.14 0.14 29285714
+ 0.14 0.14 0.14 36357143
+ 0.14 0.14 0.14 43428571
+ 0.14 0.14 0.14 50500000
+ 0.14 0.14 0.14 57571429
+ 0.14 0.14 0.14 64642857
+ 0.14 0.14 0.14 71714286
+ 0.14 0.14 0.14 78785714
+ 0.14 0.14 0.14 85857143
+ 0.14 0.14 0.14 92928571
+ 0.14 0.14 0.14 100000000
+ 0.14 0.14 0.21 1000000
+ 0.14 0.14 0.21 8071429
+ 0.14 0.14 0.21 15142857
+ 0.14 0.14 0.21 22214286
+ 0.14 0.14 0.21 29285714
+ 0.14 0.14 0.21 36357143
+ 0.14 0.14 0.21 43428571
+ 0.14 0.14 0.21 50500000
+ 0.14 0.14 0.21 57571429
+ 0.14 0.14 0.21 64642857
+ 0.14 0.14 0.21 71714286
+ 0.14 0.14 0.21 78785714
+ 0.14 0.14 0.21 85857143
+ 0.14 0.14 0.21 92928571
+ 0.14 0.14 0.21 100000000
+ 0.14 0.14 0.29 1000000
+ 0.14 0.14 0.29 8071429
+ 0.14 0.14 0.29 15142857
+ 0.14 0.14 0.29 22214286
+ 0.14 0.14 0.29 29285714
+ 0.14 0.14 0.29 36357143
+ 0.14 0.14 0.29 43428571
+ 0.14 0.14 0.29 50500000
+ 0.14 0.14 0.29 57571429
+ 0.14 0.14 0.29 64642857
+ 0.14 0.14 0.29 71714286
+ 0.14 0.14 0.29 78785714
+ 0.14 0.14 0.29 85857143
+ 0.14 0.14 0.29 92928571
+ 0.14 0.14 0.29 100000000
+ 0.14 0.14 0.36 1000000
+ 0.14 0.14 0.36 8071429
+ 0.14 0.14 0.36 15142857
+ 0.14 0.14 0.36 22214286
+ 0.14 0.14 0.36 29285714
+ 0.14 0.14 0.36 36357143
+ 0.14 0.14 0.36 43428571
+ 0.14 0.14 0.36 50500000
+ 0.14 0.14 0.36 57571429
+ 0.14 0.14 0.36 64642857
+ 0.14 0.14 0.36 71714286
+ 0.14 0.14 0.36 78785714
+ 0.14 0.14 0.36 85857143
+ 0.14 0.14 0.36 92928571
+ 0.14 0.14 0.36 100000000
+ 0.14 0.14 0.43 1000000
+ 0.14 0.14 0.43 8071429
+ 0.14 0.14 0.43 15142857
+ 0.14 0.14 0.43 22214286
+ 0.14 0.14 0.43 29285714
+ 0.14 0.14 0.43 36357143
+ 0.14 0.14 0.43 43428571
+ 0.14 0.14 0.43 50500000
+ 0.14 0.14 0.43 57571429
+ 0.14 0.14 0.43 64642857
+ 0.14 0.14 0.43 71714286
+ 0.14 0.14 0.43 78785714
+ 0.14 0.14 0.43 85857143
+ 0.14 0.14 0.43 92928571
+ 0.14 0.14 0.43 100000000
+ 0.14 0.14 0.50 1000000
+ 0.14 0.14 0.50 8071429
+ 0.14 0.14 0.50 15142857
+ 0.14 0.14 0.50 22214286
+ 0.14 0.14 0.50 29285714
+ 0.14 0.14 0.50 36357143
+ 0.14 0.14 0.50 43428571
+ 0.14 0.14 0.50 50500000
+ 0.14 0.14 0.50 57571429
+ 0.14 0.14 0.50 64642857
+ 0.14 0.14 0.50 71714286
+ 0.14 0.14 0.50 78785714
+ 0.14 0.14 0.50 85857143
+ 0.14 0.14 0.50 92928571
+ 0.14 0.14 0.50 100000000
+ 0.14 0.14 0.57 1000000
+ 0.14 0.14 0.57 8071429
+ 0.14 0.14 0.57 15142857
+ 0.14 0.14 0.57 22214286
+ 0.14 0.14 0.57 29285714
+ 0.14 0.14 0.57 36357143
+ 0.14 0.14 0.57 43428571
+ 0.14 0.14 0.57 50500000
+ 0.14 0.14 0.57 57571429
+ 0.14 0.14 0.57 64642857
+ 0.14 0.14 0.57 71714286
+ 0.14 0.14 0.57 78785714
+ 0.14 0.14 0.57 85857143
+ 0.14 0.14 0.57 92928571
+ 0.14 0.14 0.57 100000000
+ 0.14 0.14 0.64 1000000
+ 0.14 0.14 0.64 8071429
+ 0.14 0.14 0.64 15142857
+ 0.14 0.14 0.64 22214286
+ 0.14 0.14 0.64 29285714
+ 0.14 0.14 0.64 36357143
+ 0.14 0.14 0.64 43428571
+ 0.14 0.14 0.64 50500000
+ 0.14 0.14 0.64 57571429
+ 0.14 0.14 0.64 64642857
+ 0.14 0.14 0.64 71714286
+ 0.14 0.14 0.64 78785714
+ 0.14 0.14 0.64 85857143
+ 0.14 0.14 0.64 92928571
+ 0.14 0.14 0.64 100000000
+ 0.14 0.14 0.71 1000000
+ 0.14 0.14 0.71 8071429
+ 0.14 0.14 0.71 15142857
+ 0.14 0.14 0.71 22214286
+ 0.14 0.14 0.71 29285714
+ 0.14 0.14 0.71 36357143
+ 0.14 0.14 0.71 43428571
+ 0.14 0.14 0.71 50500000
+ 0.14 0.14 0.71 57571429
+ 0.14 0.14 0.71 64642857
+ 0.14 0.14 0.71 71714286
+ 0.14 0.14 0.71 78785714
+ 0.14 0.14 0.71 85857143
+ 0.14 0.14 0.71 92928571
+ 0.14 0.14 0.71 100000000
+ 0.14 0.14 0.79 1000000
+ 0.14 0.14 0.79 8071429
+ 0.14 0.14 0.79 15142857
+ 0.14 0.14 0.79 22214286
+ 0.14 0.14 0.79 29285714
+ 0.14 0.14 0.79 36357143
+ 0.14 0.14 0.79 43428571
+ 0.14 0.14 0.79 50500000
+ 0.14 0.14 0.79 57571429
+ 0.14 0.14 0.79 64642857
+ 0.14 0.14 0.79 71714286
+ 0.14 0.14 0.79 78785714
+ 0.14 0.14 0.79 85857143
+ 0.14 0.14 0.79 92928571
+ 0.14 0.14 0.79 100000000
+ 0.14 0.14 0.86 1000000
+ 0.14 0.14 0.86 8071429
+ 0.14 0.14 0.86 15142857
+ 0.14 0.14 0.86 22214286
+ 0.14 0.14 0.86 29285714
+ 0.14 0.14 0.86 36357143
+ 0.14 0.14 0.86 43428571
+ 0.14 0.14 0.86 50500000
+ 0.14 0.14 0.86 57571429
+ 0.14 0.14 0.86 64642857
+ 0.14 0.14 0.86 71714286
+ 0.14 0.14 0.86 78785714
+ 0.14 0.14 0.86 85857143
+ 0.14 0.14 0.86 92928571
+ 0.14 0.14 0.86 100000000
+ 0.14 0.14 0.93 1000000
+ 0.14 0.14 0.93 8071429
+ 0.14 0.14 0.93 15142857
+ 0.14 0.14 0.93 22214286
+ 0.14 0.14 0.93 29285714
+ 0.14 0.14 0.93 36357143
+ 0.14 0.14 0.93 43428571
+ 0.14 0.14 0.93 50500000
+ 0.14 0.14 0.93 57571429
+ 0.14 0.14 0.93 64642857
+ 0.14 0.14 0.93 71714286
+ 0.14 0.14 0.93 78785714
+ 0.14 0.14 0.93 85857143
+ 0.14 0.14 0.93 92928571
+ 0.14 0.14 0.93 100000000
+ 0.14 0.14 1.00 1000000
+ 0.14 0.14 1.00 8071429
+ 0.14 0.14 1.00 15142857
+ 0.14 0.14 1.00 22214286
+ 0.14 0.14 1.00 29285714
+ 0.14 0.14 1.00 36357143
+ 0.14 0.14 1.00 43428571
+ 0.14 0.14 1.00 50500000
+ 0.14 0.14 1.00 57571429
+ 0.14 0.14 1.00 64642857
+ 0.14 0.14 1.00 71714286
+ 0.14 0.14 1.00 78785714
+ 0.14 0.14 1.00 85857143
+ 0.14 0.14 1.00 92928571
+ 0.14 0.14 1.00 100000000
+ 0.14 0.21 0.00 1000000
+ 0.14 0.21 0.00 8071429
+ 0.14 0.21 0.00 15142857
+ 0.14 0.21 0.00 22214286
+ 0.14 0.21 0.00 29285714
+ 0.14 0.21 0.00 36357143
+ 0.14 0.21 0.00 43428571
+ 0.14 0.21 0.00 50500000
+ 0.14 0.21 0.00 57571429
+ 0.14 0.21 0.00 64642857
+ 0.14 0.21 0.00 71714286
+ 0.14 0.21 0.00 78785714
+ 0.14 0.21 0.00 85857143
+ 0.14 0.21 0.00 92928571
+ 0.14 0.21 0.00 100000000
+ 0.14 0.21 0.07 1000000
+ 0.14 0.21 0.07 8071429
+ 0.14 0.21 0.07 15142857
+ 0.14 0.21 0.07 22214286
+ 0.14 0.21 0.07 29285714
+ 0.14 0.21 0.07 36357143
+ 0.14 0.21 0.07 43428571
+ 0.14 0.21 0.07 50500000
+ 0.14 0.21 0.07 57571429
+ 0.14 0.21 0.07 64642857
+ 0.14 0.21 0.07 71714286
+ 0.14 0.21 0.07 78785714
+ 0.14 0.21 0.07 85857143
+ 0.14 0.21 0.07 92928571
+ 0.14 0.21 0.07 100000000
+ 0.14 0.21 0.14 1000000
+ 0.14 0.21 0.14 8071429
+ 0.14 0.21 0.14 15142857
+ 0.14 0.21 0.14 22214286
+ 0.14 0.21 0.14 29285714
+ 0.14 0.21 0.14 36357143
+ 0.14 0.21 0.14 43428571
+ 0.14 0.21 0.14 50500000
+ 0.14 0.21 0.14 57571429
+ 0.14 0.21 0.14 64642857
+ 0.14 0.21 0.14 71714286
+ 0.14 0.21 0.14 78785714
+ 0.14 0.21 0.14 85857143
+ 0.14 0.21 0.14 92928571
+ 0.14 0.21 0.14 100000000
+ 0.14 0.21 0.21 1000000
+ 0.14 0.21 0.21 8071429
+ 0.14 0.21 0.21 15142857
+ 0.14 0.21 0.21 22214286
+ 0.14 0.21 0.21 29285714
+ 0.14 0.21 0.21 36357143
+ 0.14 0.21 0.21 43428571
+ 0.14 0.21 0.21 50500000
+ 0.14 0.21 0.21 57571429
+ 0.14 0.21 0.21 64642857
+ 0.14 0.21 0.21 71714286
+ 0.14 0.21 0.21 78785714
+ 0.14 0.21 0.21 85857143
+ 0.14 0.21 0.21 92928571
+ 0.14 0.21 0.21 100000000
+ 0.14 0.21 0.29 1000000
+ 0.14 0.21 0.29 8071429
+ 0.14 0.21 0.29 15142857
+ 0.14 0.21 0.29 22214286
+ 0.14 0.21 0.29 29285714
+ 0.14 0.21 0.29 36357143
+ 0.14 0.21 0.29 43428571
+ 0.14 0.21 0.29 50500000
+ 0.14 0.21 0.29 57571429
+ 0.14 0.21 0.29 64642857
+ 0.14 0.21 0.29 71714286
+ 0.14 0.21 0.29 78785714
+ 0.14 0.21 0.29 85857143
+ 0.14 0.21 0.29 92928571
+ 0.14 0.21 0.29 100000000
+ 0.14 0.21 0.36 1000000
+ 0.14 0.21 0.36 8071429
+ 0.14 0.21 0.36 15142857
+ 0.14 0.21 0.36 22214286
+ 0.14 0.21 0.36 29285714
+ 0.14 0.21 0.36 36357143
+ 0.14 0.21 0.36 43428571
+ 0.14 0.21 0.36 50500000
+ 0.14 0.21 0.36 57571429
+ 0.14 0.21 0.36 64642857
+ 0.14 0.21 0.36 71714286
+ 0.14 0.21 0.36 78785714
+ 0.14 0.21 0.36 85857143
+ 0.14 0.21 0.36 92928571
+ 0.14 0.21 0.36 100000000
+ 0.14 0.21 0.43 1000000
+ 0.14 0.21 0.43 8071429
+ 0.14 0.21 0.43 15142857
+ 0.14 0.21 0.43 22214286
+ 0.14 0.21 0.43 29285714
+ 0.14 0.21 0.43 36357143
+ 0.14 0.21 0.43 43428571
+ 0.14 0.21 0.43 50500000
+ 0.14 0.21 0.43 57571429
+ 0.14 0.21 0.43 64642857
+ 0.14 0.21 0.43 71714286
+ 0.14 0.21 0.43 78785714
+ 0.14 0.21 0.43 85857143
+ 0.14 0.21 0.43 92928571
+ 0.14 0.21 0.43 100000000
+ 0.14 0.21 0.50 1000000
+ 0.14 0.21 0.50 8071429
+ 0.14 0.21 0.50 15142857
+ 0.14 0.21 0.50 22214286
+ 0.14 0.21 0.50 29285714
+ 0.14 0.21 0.50 36357143
+ 0.14 0.21 0.50 43428571
+ 0.14 0.21 0.50 50500000
+ 0.14 0.21 0.50 57571429
+ 0.14 0.21 0.50 64642857
+ 0.14 0.21 0.50 71714286
+ 0.14 0.21 0.50 78785714
+ 0.14 0.21 0.50 85857143
+ 0.14 0.21 0.50 92928571
+ 0.14 0.21 0.50 100000000
+ 0.14 0.21 0.57 1000000
+ 0.14 0.21 0.57 8071429
+ 0.14 0.21 0.57 15142857
+ 0.14 0.21 0.57 22214286
+ 0.14 0.21 0.57 29285714
+ 0.14 0.21 0.57 36357143
+ 0.14 0.21 0.57 43428571
+ 0.14 0.21 0.57 50500000
+ 0.14 0.21 0.57 57571429
+ 0.14 0.21 0.57 64642857
+ 0.14 0.21 0.57 71714286
+ 0.14 0.21 0.57 78785714
+ 0.14 0.21 0.57 85857143
+ 0.14 0.21 0.57 92928571
+ 0.14 0.21 0.57 100000000
+ 0.14 0.21 0.64 1000000
+ 0.14 0.21 0.64 8071429
+ 0.14 0.21 0.64 15142857
+ 0.14 0.21 0.64 22214286
+ 0.14 0.21 0.64 29285714
+ 0.14 0.21 0.64 36357143
+ 0.14 0.21 0.64 43428571
+ 0.14 0.21 0.64 50500000
+ 0.14 0.21 0.64 57571429
+ 0.14 0.21 0.64 64642857
+ 0.14 0.21 0.64 71714286
+ 0.14 0.21 0.64 78785714
+ 0.14 0.21 0.64 85857143
+ 0.14 0.21 0.64 92928571
+ 0.14 0.21 0.64 100000000
+ 0.14 0.21 0.71 1000000
+ 0.14 0.21 0.71 8071429
+ 0.14 0.21 0.71 15142857
+ 0.14 0.21 0.71 22214286
+ 0.14 0.21 0.71 29285714
+ 0.14 0.21 0.71 36357143
+ 0.14 0.21 0.71 43428571
+ 0.14 0.21 0.71 50500000
+ 0.14 0.21 0.71 57571429
+ 0.14 0.21 0.71 64642857
+ 0.14 0.21 0.71 71714286
+ 0.14 0.21 0.71 78785714
+ 0.14 0.21 0.71 85857143
+ 0.14 0.21 0.71 92928571
+ 0.14 0.21 0.71 100000000
+ 0.14 0.21 0.79 1000000
+ 0.14 0.21 0.79 8071429
+ 0.14 0.21 0.79 15142857
+ 0.14 0.21 0.79 22214286
+ 0.14 0.21 0.79 29285714
+ 0.14 0.21 0.79 36357143
+ 0.14 0.21 0.79 43428571
+ 0.14 0.21 0.79 50500000
+ 0.14 0.21 0.79 57571429
+ 0.14 0.21 0.79 64642857
+ 0.14 0.21 0.79 71714286
+ 0.14 0.21 0.79 78785714
+ 0.14 0.21 0.79 85857143
+ 0.14 0.21 0.79 92928571
+ 0.14 0.21 0.79 100000000
+ 0.14 0.21 0.86 1000000
+ 0.14 0.21 0.86 8071429
+ 0.14 0.21 0.86 15142857
+ 0.14 0.21 0.86 22214286
+ 0.14 0.21 0.86 29285714
+ 0.14 0.21 0.86 36357143
+ 0.14 0.21 0.86 43428571
+ 0.14 0.21 0.86 50500000
+ 0.14 0.21 0.86 57571429
+ 0.14 0.21 0.86 64642857
+ 0.14 0.21 0.86 71714286
+ 0.14 0.21 0.86 78785714
+ 0.14 0.21 0.86 85857143
+ 0.14 0.21 0.86 92928571
+ 0.14 0.21 0.86 100000000
+ 0.14 0.21 0.93 1000000
+ 0.14 0.21 0.93 8071429
+ 0.14 0.21 0.93 15142857
+ 0.14 0.21 0.93 22214286
+ 0.14 0.21 0.93 29285714
+ 0.14 0.21 0.93 36357143
+ 0.14 0.21 0.93 43428571
+ 0.14 0.21 0.93 50500000
+ 0.14 0.21 0.93 57571429
+ 0.14 0.21 0.93 64642857
+ 0.14 0.21 0.93 71714286
+ 0.14 0.21 0.93 78785714
+ 0.14 0.21 0.93 85857143
+ 0.14 0.21 0.93 92928571
+ 0.14 0.21 0.93 100000000
+ 0.14 0.21 1.00 1000000
+ 0.14 0.21 1.00 8071429
+ 0.14 0.21 1.00 15142857
+ 0.14 0.21 1.00 22214286
+ 0.14 0.21 1.00 29285714
+ 0.14 0.21 1.00 36357143
+ 0.14 0.21 1.00 43428571
+ 0.14 0.21 1.00 50500000
+ 0.14 0.21 1.00 57571429
+ 0.14 0.21 1.00 64642857
+ 0.14 0.21 1.00 71714286
+ 0.14 0.21 1.00 78785714
+ 0.14 0.21 1.00 85857143
+ 0.14 0.21 1.00 92928571
+ 0.14 0.21 1.00 100000000
+ 0.14 0.29 0.00 1000000
+ 0.14 0.29 0.00 8071429
+ 0.14 0.29 0.00 15142857
+ 0.14 0.29 0.00 22214286
+ 0.14 0.29 0.00 29285714
+ 0.14 0.29 0.00 36357143
+ 0.14 0.29 0.00 43428571
+ 0.14 0.29 0.00 50500000
+ 0.14 0.29 0.00 57571429
+ 0.14 0.29 0.00 64642857
+ 0.14 0.29 0.00 71714286
+ 0.14 0.29 0.00 78785714
+ 0.14 0.29 0.00 85857143
+ 0.14 0.29 0.00 92928571
+ 0.14 0.29 0.00 100000000
+ 0.14 0.29 0.07 1000000
+ 0.14 0.29 0.07 8071429
+ 0.14 0.29 0.07 15142857
+ 0.14 0.29 0.07 22214286
+ 0.14 0.29 0.07 29285714
+ 0.14 0.29 0.07 36357143
+ 0.14 0.29 0.07 43428571
+ 0.14 0.29 0.07 50500000
+ 0.14 0.29 0.07 57571429
+ 0.14 0.29 0.07 64642857
+ 0.14 0.29 0.07 71714286
+ 0.14 0.29 0.07 78785714
+ 0.14 0.29 0.07 85857143
+ 0.14 0.29 0.07 92928571
+ 0.14 0.29 0.07 100000000
+ 0.14 0.29 0.14 1000000
+ 0.14 0.29 0.14 8071429
+ 0.14 0.29 0.14 15142857
+ 0.14 0.29 0.14 22214286
+ 0.14 0.29 0.14 29285714
+ 0.14 0.29 0.14 36357143
+ 0.14 0.29 0.14 43428571
+ 0.14 0.29 0.14 50500000
+ 0.14 0.29 0.14 57571429
+ 0.14 0.29 0.14 64642857
+ 0.14 0.29 0.14 71714286
+ 0.14 0.29 0.14 78785714
+ 0.14 0.29 0.14 85857143
+ 0.14 0.29 0.14 92928571
+ 0.14 0.29 0.14 100000000
+ 0.14 0.29 0.21 1000000
+ 0.14 0.29 0.21 8071429
+ 0.14 0.29 0.21 15142857
+ 0.14 0.29 0.21 22214286
+ 0.14 0.29 0.21 29285714
+ 0.14 0.29 0.21 36357143
+ 0.14 0.29 0.21 43428571
+ 0.14 0.29 0.21 50500000
+ 0.14 0.29 0.21 57571429
+ 0.14 0.29 0.21 64642857
+ 0.14 0.29 0.21 71714286
+ 0.14 0.29 0.21 78785714
+ 0.14 0.29 0.21 85857143
+ 0.14 0.29 0.21 92928571
+ 0.14 0.29 0.21 100000000
+ 0.14 0.29 0.29 1000000
+ 0.14 0.29 0.29 8071429
+ 0.14 0.29 0.29 15142857
+ 0.14 0.29 0.29 22214286
+ 0.14 0.29 0.29 29285714
+ 0.14 0.29 0.29 36357143
+ 0.14 0.29 0.29 43428571
+ 0.14 0.29 0.29 50500000
+ 0.14 0.29 0.29 57571429
+ 0.14 0.29 0.29 64642857
+ 0.14 0.29 0.29 71714286
+ 0.14 0.29 0.29 78785714
+ 0.14 0.29 0.29 85857143
+ 0.14 0.29 0.29 92928571
+ 0.14 0.29 0.29 100000000
+ 0.14 0.29 0.36 1000000
+ 0.14 0.29 0.36 8071429
+ 0.14 0.29 0.36 15142857
+ 0.14 0.29 0.36 22214286
+ 0.14 0.29 0.36 29285714
+ 0.14 0.29 0.36 36357143
+ 0.14 0.29 0.36 43428571
+ 0.14 0.29 0.36 50500000
+ 0.14 0.29 0.36 57571429
+ 0.14 0.29 0.36 64642857
+ 0.14 0.29 0.36 71714286
+ 0.14 0.29 0.36 78785714
+ 0.14 0.29 0.36 85857143
+ 0.14 0.29 0.36 92928571
+ 0.14 0.29 0.36 100000000
+ 0.14 0.29 0.43 1000000
+ 0.14 0.29 0.43 8071429
+ 0.14 0.29 0.43 15142857
+ 0.14 0.29 0.43 22214286
+ 0.14 0.29 0.43 29285714
+ 0.14 0.29 0.43 36357143
+ 0.14 0.29 0.43 43428571
+ 0.14 0.29 0.43 50500000
+ 0.14 0.29 0.43 57571429
+ 0.14 0.29 0.43 64642857
+ 0.14 0.29 0.43 71714286
+ 0.14 0.29 0.43 78785714
+ 0.14 0.29 0.43 85857143
+ 0.14 0.29 0.43 92928571
+ 0.14 0.29 0.43 100000000
+ 0.14 0.29 0.50 1000000
+ 0.14 0.29 0.50 8071429
+ 0.14 0.29 0.50 15142857
+ 0.14 0.29 0.50 22214286
+ 0.14 0.29 0.50 29285714
+ 0.14 0.29 0.50 36357143
+ 0.14 0.29 0.50 43428571
+ 0.14 0.29 0.50 50500000
+ 0.14 0.29 0.50 57571429
+ 0.14 0.29 0.50 64642857
+ 0.14 0.29 0.50 71714286
+ 0.14 0.29 0.50 78785714
+ 0.14 0.29 0.50 85857143
+ 0.14 0.29 0.50 92928571
+ 0.14 0.29 0.50 100000000
+ 0.14 0.29 0.57 1000000
+ 0.14 0.29 0.57 8071429
+ 0.14 0.29 0.57 15142857
+ 0.14 0.29 0.57 22214286
+ 0.14 0.29 0.57 29285714
+ 0.14 0.29 0.57 36357143
+ 0.14 0.29 0.57 43428571
+ 0.14 0.29 0.57 50500000
+ 0.14 0.29 0.57 57571429
+ 0.14 0.29 0.57 64642857
+ 0.14 0.29 0.57 71714286
+ 0.14 0.29 0.57 78785714
+ 0.14 0.29 0.57 85857143
+ 0.14 0.29 0.57 92928571
+ 0.14 0.29 0.57 100000000
+ 0.14 0.29 0.64 1000000
+ 0.14 0.29 0.64 8071429
+ 0.14 0.29 0.64 15142857
+ 0.14 0.29 0.64 22214286
+ 0.14 0.29 0.64 29285714
+ 0.14 0.29 0.64 36357143
+ 0.14 0.29 0.64 43428571
+ 0.14 0.29 0.64 50500000
+ 0.14 0.29 0.64 57571429
+ 0.14 0.29 0.64 64642857
+ 0.14 0.29 0.64 71714286
+ 0.14 0.29 0.64 78785714
+ 0.14 0.29 0.64 85857143
+ 0.14 0.29 0.64 92928571
+ 0.14 0.29 0.64 100000000
+ 0.14 0.29 0.71 1000000
+ 0.14 0.29 0.71 8071429
+ 0.14 0.29 0.71 15142857
+ 0.14 0.29 0.71 22214286
+ 0.14 0.29 0.71 29285714
+ 0.14 0.29 0.71 36357143
+ 0.14 0.29 0.71 43428571
+ 0.14 0.29 0.71 50500000
+ 0.14 0.29 0.71 57571429
+ 0.14 0.29 0.71 64642857
+ 0.14 0.29 0.71 71714286
+ 0.14 0.29 0.71 78785714
+ 0.14 0.29 0.71 85857143
+ 0.14 0.29 0.71 92928571
+ 0.14 0.29 0.71 100000000
+ 0.14 0.29 0.79 1000000
+ 0.14 0.29 0.79 8071429
+ 0.14 0.29 0.79 15142857
+ 0.14 0.29 0.79 22214286
+ 0.14 0.29 0.79 29285714
+ 0.14 0.29 0.79 36357143
+ 0.14 0.29 0.79 43428571
+ 0.14 0.29 0.79 50500000
+ 0.14 0.29 0.79 57571429
+ 0.14 0.29 0.79 64642857
+ 0.14 0.29 0.79 71714286
+ 0.14 0.29 0.79 78785714
+ 0.14 0.29 0.79 85857143
+ 0.14 0.29 0.79 92928571
+ 0.14 0.29 0.79 100000000
+ 0.14 0.29 0.86 1000000
+ 0.14 0.29 0.86 8071429
+ 0.14 0.29 0.86 15142857
+ 0.14 0.29 0.86 22214286
+ 0.14 0.29 0.86 29285714
+ 0.14 0.29 0.86 36357143
+ 0.14 0.29 0.86 43428571
+ 0.14 0.29 0.86 50500000
+ 0.14 0.29 0.86 57571429
+ 0.14 0.29 0.86 64642857
+ 0.14 0.29 0.86 71714286
+ 0.14 0.29 0.86 78785714
+ 0.14 0.29 0.86 85857143
+ 0.14 0.29 0.86 92928571
+ 0.14 0.29 0.86 100000000
+ 0.14 0.29 0.93 1000000
+ 0.14 0.29 0.93 8071429
+ 0.14 0.29 0.93 15142857
+ 0.14 0.29 0.93 22214286
+ 0.14 0.29 0.93 29285714
+ 0.14 0.29 0.93 36357143
+ 0.14 0.29 0.93 43428571
+ 0.14 0.29 0.93 50500000
+ 0.14 0.29 0.93 57571429
+ 0.14 0.29 0.93 64642857
+ 0.14 0.29 0.93 71714286
+ 0.14 0.29 0.93 78785714
+ 0.14 0.29 0.93 85857143
+ 0.14 0.29 0.93 92928571
+ 0.14 0.29 0.93 100000000
+ 0.14 0.29 1.00 1000000
+ 0.14 0.29 1.00 8071429
+ 0.14 0.29 1.00 15142857
+ 0.14 0.29 1.00 22214286
+ 0.14 0.29 1.00 29285714
+ 0.14 0.29 1.00 36357143
+ 0.14 0.29 1.00 43428571
+ 0.14 0.29 1.00 50500000
+ 0.14 0.29 1.00 57571429
+ 0.14 0.29 1.00 64642857
+ 0.14 0.29 1.00 71714286
+ 0.14 0.29 1.00 78785714
+ 0.14 0.29 1.00 85857143
+ 0.14 0.29 1.00 92928571
+ 0.14 0.29 1.00 100000000
+ 0.14 0.36 0.00 1000000
+ 0.14 0.36 0.00 8071429
+ 0.14 0.36 0.00 15142857
+ 0.14 0.36 0.00 22214286
+ 0.14 0.36 0.00 29285714
+ 0.14 0.36 0.00 36357143
+ 0.14 0.36 0.00 43428571
+ 0.14 0.36 0.00 50500000
+ 0.14 0.36 0.00 57571429
+ 0.14 0.36 0.00 64642857
+ 0.14 0.36 0.00 71714286
+ 0.14 0.36 0.00 78785714
+ 0.14 0.36 0.00 85857143
+ 0.14 0.36 0.00 92928571
+ 0.14 0.36 0.00 100000000
+ 0.14 0.36 0.07 1000000
+ 0.14 0.36 0.07 8071429
+ 0.14 0.36 0.07 15142857
+ 0.14 0.36 0.07 22214286
+ 0.14 0.36 0.07 29285714
+ 0.14 0.36 0.07 36357143
+ 0.14 0.36 0.07 43428571
+ 0.14 0.36 0.07 50500000
+ 0.14 0.36 0.07 57571429
+ 0.14 0.36 0.07 64642857
+ 0.14 0.36 0.07 71714286
+ 0.14 0.36 0.07 78785714
+ 0.14 0.36 0.07 85857143
+ 0.14 0.36 0.07 92928571
+ 0.14 0.36 0.07 100000000
+ 0.14 0.36 0.14 1000000
+ 0.14 0.36 0.14 8071429
+ 0.14 0.36 0.14 15142857
+ 0.14 0.36 0.14 22214286
+ 0.14 0.36 0.14 29285714
+ 0.14 0.36 0.14 36357143
+ 0.14 0.36 0.14 43428571
+ 0.14 0.36 0.14 50500000
+ 0.14 0.36 0.14 57571429
+ 0.14 0.36 0.14 64642857
+ 0.14 0.36 0.14 71714286
+ 0.14 0.36 0.14 78785714
+ 0.14 0.36 0.14 85857143
+ 0.14 0.36 0.14 92928571
+ 0.14 0.36 0.14 100000000
+ 0.14 0.36 0.21 1000000
+ 0.14 0.36 0.21 8071429
+ 0.14 0.36 0.21 15142857
+ 0.14 0.36 0.21 22214286
+ 0.14 0.36 0.21 29285714
+ 0.14 0.36 0.21 36357143
+ 0.14 0.36 0.21 43428571
+ 0.14 0.36 0.21 50500000
+ 0.14 0.36 0.21 57571429
+ 0.14 0.36 0.21 64642857
+ 0.14 0.36 0.21 71714286
+ 0.14 0.36 0.21 78785714
+ 0.14 0.36 0.21 85857143
+ 0.14 0.36 0.21 92928571
+ 0.14 0.36 0.21 100000000
+ 0.14 0.36 0.29 1000000
+ 0.14 0.36 0.29 8071429
+ 0.14 0.36 0.29 15142857
+ 0.14 0.36 0.29 22214286
+ 0.14 0.36 0.29 29285714
+ 0.14 0.36 0.29 36357143
+ 0.14 0.36 0.29 43428571
+ 0.14 0.36 0.29 50500000
+ 0.14 0.36 0.29 57571429
+ 0.14 0.36 0.29 64642857
+ 0.14 0.36 0.29 71714286
+ 0.14 0.36 0.29 78785714
+ 0.14 0.36 0.29 85857143
+ 0.14 0.36 0.29 92928571
+ 0.14 0.36 0.29 100000000
+ 0.14 0.36 0.36 1000000
+ 0.14 0.36 0.36 8071429
+ 0.14 0.36 0.36 15142857
+ 0.14 0.36 0.36 22214286
+ 0.14 0.36 0.36 29285714
+ 0.14 0.36 0.36 36357143
+ 0.14 0.36 0.36 43428571
+ 0.14 0.36 0.36 50500000
+ 0.14 0.36 0.36 57571429
+ 0.14 0.36 0.36 64642857
+ 0.14 0.36 0.36 71714286
+ 0.14 0.36 0.36 78785714
+ 0.14 0.36 0.36 85857143
+ 0.14 0.36 0.36 92928571
+ 0.14 0.36 0.36 100000000
+ 0.14 0.36 0.43 1000000
+ 0.14 0.36 0.43 8071429
+ 0.14 0.36 0.43 15142857
+ 0.14 0.36 0.43 22214286
+ 0.14 0.36 0.43 29285714
+ 0.14 0.36 0.43 36357143
+ 0.14 0.36 0.43 43428571
+ 0.14 0.36 0.43 50500000
+ 0.14 0.36 0.43 57571429
+ 0.14 0.36 0.43 64642857
+ 0.14 0.36 0.43 71714286
+ 0.14 0.36 0.43 78785714
+ 0.14 0.36 0.43 85857143
+ 0.14 0.36 0.43 92928571
+ 0.14 0.36 0.43 100000000
+ 0.14 0.36 0.50 1000000
+ 0.14 0.36 0.50 8071429
+ 0.14 0.36 0.50 15142857
+ 0.14 0.36 0.50 22214286
+ 0.14 0.36 0.50 29285714
+ 0.14 0.36 0.50 36357143
+ 0.14 0.36 0.50 43428571
+ 0.14 0.36 0.50 50500000
+ 0.14 0.36 0.50 57571429
+ 0.14 0.36 0.50 64642857
+ 0.14 0.36 0.50 71714286
+ 0.14 0.36 0.50 78785714
+ 0.14 0.36 0.50 85857143
+ 0.14 0.36 0.50 92928571
+ 0.14 0.36 0.50 100000000
+ 0.14 0.36 0.57 1000000
+ 0.14 0.36 0.57 8071429
+ 0.14 0.36 0.57 15142857
+ 0.14 0.36 0.57 22214286
+ 0.14 0.36 0.57 29285714
+ 0.14 0.36 0.57 36357143
+ 0.14 0.36 0.57 43428571
+ 0.14 0.36 0.57 50500000
+ 0.14 0.36 0.57 57571429
+ 0.14 0.36 0.57 64642857
+ 0.14 0.36 0.57 71714286
+ 0.14 0.36 0.57 78785714
+ 0.14 0.36 0.57 85857143
+ 0.14 0.36 0.57 92928571
+ 0.14 0.36 0.57 100000000
+ 0.14 0.36 0.64 1000000
+ 0.14 0.36 0.64 8071429
+ 0.14 0.36 0.64 15142857
+ 0.14 0.36 0.64 22214286
+ 0.14 0.36 0.64 29285714
+ 0.14 0.36 0.64 36357143
+ 0.14 0.36 0.64 43428571
+ 0.14 0.36 0.64 50500000
+ 0.14 0.36 0.64 57571429
+ 0.14 0.36 0.64 64642857
+ 0.14 0.36 0.64 71714286
+ 0.14 0.36 0.64 78785714
+ 0.14 0.36 0.64 85857143
+ 0.14 0.36 0.64 92928571
+ 0.14 0.36 0.64 100000000
+ 0.14 0.36 0.71 1000000
+ 0.14 0.36 0.71 8071429
+ 0.14 0.36 0.71 15142857
+ 0.14 0.36 0.71 22214286
+ 0.14 0.36 0.71 29285714
+ 0.14 0.36 0.71 36357143
+ 0.14 0.36 0.71 43428571
+ 0.14 0.36 0.71 50500000
+ 0.14 0.36 0.71 57571429
+ 0.14 0.36 0.71 64642857
+ 0.14 0.36 0.71 71714286
+ 0.14 0.36 0.71 78785714
+ 0.14 0.36 0.71 85857143
+ 0.14 0.36 0.71 92928571
+ 0.14 0.36 0.71 100000000
+ 0.14 0.36 0.79 1000000
+ 0.14 0.36 0.79 8071429
+ 0.14 0.36 0.79 15142857
+ 0.14 0.36 0.79 22214286
+ 0.14 0.36 0.79 29285714
+ 0.14 0.36 0.79 36357143
+ 0.14 0.36 0.79 43428571
+ 0.14 0.36 0.79 50500000
+ 0.14 0.36 0.79 57571429
+ 0.14 0.36 0.79 64642857
+ 0.14 0.36 0.79 71714286
+ 0.14 0.36 0.79 78785714
+ 0.14 0.36 0.79 85857143
+ 0.14 0.36 0.79 92928571
+ 0.14 0.36 0.79 100000000
+ 0.14 0.36 0.86 1000000
+ 0.14 0.36 0.86 8071429
+ 0.14 0.36 0.86 15142857
+ 0.14 0.36 0.86 22214286
+ 0.14 0.36 0.86 29285714
+ 0.14 0.36 0.86 36357143
+ 0.14 0.36 0.86 43428571
+ 0.14 0.36 0.86 50500000
+ 0.14 0.36 0.86 57571429
+ 0.14 0.36 0.86 64642857
+ 0.14 0.36 0.86 71714286
+ 0.14 0.36 0.86 78785714
+ 0.14 0.36 0.86 85857143
+ 0.14 0.36 0.86 92928571
+ 0.14 0.36 0.86 100000000
+ 0.14 0.36 0.93 1000000
+ 0.14 0.36 0.93 8071429
+ 0.14 0.36 0.93 15142857
+ 0.14 0.36 0.93 22214286
+ 0.14 0.36 0.93 29285714
+ 0.14 0.36 0.93 36357143
+ 0.14 0.36 0.93 43428571
+ 0.14 0.36 0.93 50500000
+ 0.14 0.36 0.93 57571429
+ 0.14 0.36 0.93 64642857
+ 0.14 0.36 0.93 71714286
+ 0.14 0.36 0.93 78785714
+ 0.14 0.36 0.93 85857143
+ 0.14 0.36 0.93 92928571
+ 0.14 0.36 0.93 100000000
+ 0.14 0.36 1.00 1000000
+ 0.14 0.36 1.00 8071429
+ 0.14 0.36 1.00 15142857
+ 0.14 0.36 1.00 22214286
+ 0.14 0.36 1.00 29285714
+ 0.14 0.36 1.00 36357143
+ 0.14 0.36 1.00 43428571
+ 0.14 0.36 1.00 50500000
+ 0.14 0.36 1.00 57571429
+ 0.14 0.36 1.00 64642857
+ 0.14 0.36 1.00 71714286
+ 0.14 0.36 1.00 78785714
+ 0.14 0.36 1.00 85857143
+ 0.14 0.36 1.00 92928571
+ 0.14 0.36 1.00 100000000
+ 0.14 0.43 0.00 1000000
+ 0.14 0.43 0.00 8071429
+ 0.14 0.43 0.00 15142857
+ 0.14 0.43 0.00 22214286
+ 0.14 0.43 0.00 29285714
+ 0.14 0.43 0.00 36357143
+ 0.14 0.43 0.00 43428571
+ 0.14 0.43 0.00 50500000
+ 0.14 0.43 0.00 57571429
+ 0.14 0.43 0.00 64642857
+ 0.14 0.43 0.00 71714286
+ 0.14 0.43 0.00 78785714
+ 0.14 0.43 0.00 85857143
+ 0.14 0.43 0.00 92928571
+ 0.14 0.43 0.00 100000000
+ 0.14 0.43 0.07 1000000
+ 0.14 0.43 0.07 8071429
+ 0.14 0.43 0.07 15142857
+ 0.14 0.43 0.07 22214286
+ 0.14 0.43 0.07 29285714
+ 0.14 0.43 0.07 36357143
+ 0.14 0.43 0.07 43428571
+ 0.14 0.43 0.07 50500000
+ 0.14 0.43 0.07 57571429
+ 0.14 0.43 0.07 64642857
+ 0.14 0.43 0.07 71714286
+ 0.14 0.43 0.07 78785714
+ 0.14 0.43 0.07 85857143
+ 0.14 0.43 0.07 92928571
+ 0.14 0.43 0.07 100000000
+ 0.14 0.43 0.14 1000000
+ 0.14 0.43 0.14 8071429
+ 0.14 0.43 0.14 15142857
+ 0.14 0.43 0.14 22214286
+ 0.14 0.43 0.14 29285714
+ 0.14 0.43 0.14 36357143
+ 0.14 0.43 0.14 43428571
+ 0.14 0.43 0.14 50500000
+ 0.14 0.43 0.14 57571429
+ 0.14 0.43 0.14 64642857
+ 0.14 0.43 0.14 71714286
+ 0.14 0.43 0.14 78785714
+ 0.14 0.43 0.14 85857143
+ 0.14 0.43 0.14 92928571
+ 0.14 0.43 0.14 100000000
+ 0.14 0.43 0.21 1000000
+ 0.14 0.43 0.21 8071429
+ 0.14 0.43 0.21 15142857
+ 0.14 0.43 0.21 22214286
+ 0.14 0.43 0.21 29285714
+ 0.14 0.43 0.21 36357143
+ 0.14 0.43 0.21 43428571
+ 0.14 0.43 0.21 50500000
+ 0.14 0.43 0.21 57571429
+ 0.14 0.43 0.21 64642857
+ 0.14 0.43 0.21 71714286
+ 0.14 0.43 0.21 78785714
+ 0.14 0.43 0.21 85857143
+ 0.14 0.43 0.21 92928571
+ 0.14 0.43 0.21 100000000
+ 0.14 0.43 0.29 1000000
+ 0.14 0.43 0.29 8071429
+ 0.14 0.43 0.29 15142857
+ 0.14 0.43 0.29 22214286
+ 0.14 0.43 0.29 29285714
+ 0.14 0.43 0.29 36357143
+ 0.14 0.43 0.29 43428571
+ 0.14 0.43 0.29 50500000
+ 0.14 0.43 0.29 57571429
+ 0.14 0.43 0.29 64642857
+ 0.14 0.43 0.29 71714286
+ 0.14 0.43 0.29 78785714
+ 0.14 0.43 0.29 85857143
+ 0.14 0.43 0.29 92928571
+ 0.14 0.43 0.29 100000000
+ 0.14 0.43 0.36 1000000
+ 0.14 0.43 0.36 8071429
+ 0.14 0.43 0.36 15142857
+ 0.14 0.43 0.36 22214286
+ 0.14 0.43 0.36 29285714
+ 0.14 0.43 0.36 36357143
+ 0.14 0.43 0.36 43428571
+ 0.14 0.43 0.36 50500000
+ 0.14 0.43 0.36 57571429
+ 0.14 0.43 0.36 64642857
+ 0.14 0.43 0.36 71714286
+ 0.14 0.43 0.36 78785714
+ 0.14 0.43 0.36 85857143
+ 0.14 0.43 0.36 92928571
+ 0.14 0.43 0.36 100000000
+ 0.14 0.43 0.43 1000000
+ 0.14 0.43 0.43 8071429
+ 0.14 0.43 0.43 15142857
+ 0.14 0.43 0.43 22214286
+ 0.14 0.43 0.43 29285714
+ 0.14 0.43 0.43 36357143
+ 0.14 0.43 0.43 43428571
+ 0.14 0.43 0.43 50500000
+ 0.14 0.43 0.43 57571429
+ 0.14 0.43 0.43 64642857
+ 0.14 0.43 0.43 71714286
+ 0.14 0.43 0.43 78785714
+ 0.14 0.43 0.43 85857143
+ 0.14 0.43 0.43 92928571
+ 0.14 0.43 0.43 100000000
+ 0.14 0.43 0.50 1000000
+ 0.14 0.43 0.50 8071429
+ 0.14 0.43 0.50 15142857
+ 0.14 0.43 0.50 22214286
+ 0.14 0.43 0.50 29285714
+ 0.14 0.43 0.50 36357143
+ 0.14 0.43 0.50 43428571
+ 0.14 0.43 0.50 50500000
+ 0.14 0.43 0.50 57571429
+ 0.14 0.43 0.50 64642857
+ 0.14 0.43 0.50 71714286
+ 0.14 0.43 0.50 78785714
+ 0.14 0.43 0.50 85857143
+ 0.14 0.43 0.50 92928571
+ 0.14 0.43 0.50 100000000
+ 0.14 0.43 0.57 1000000
+ 0.14 0.43 0.57 8071429
+ 0.14 0.43 0.57 15142857
+ 0.14 0.43 0.57 22214286
+ 0.14 0.43 0.57 29285714
+ 0.14 0.43 0.57 36357143
+ 0.14 0.43 0.57 43428571
+ 0.14 0.43 0.57 50500000
+ 0.14 0.43 0.57 57571429
+ 0.14 0.43 0.57 64642857
+ 0.14 0.43 0.57 71714286
+ 0.14 0.43 0.57 78785714
+ 0.14 0.43 0.57 85857143
+ 0.14 0.43 0.57 92928571
+ 0.14 0.43 0.57 100000000
+ 0.14 0.43 0.64 1000000
+ 0.14 0.43 0.64 8071429
+ 0.14 0.43 0.64 15142857
+ 0.14 0.43 0.64 22214286
+ 0.14 0.43 0.64 29285714
+ 0.14 0.43 0.64 36357143
+ 0.14 0.43 0.64 43428571
+ 0.14 0.43 0.64 50500000
+ 0.14 0.43 0.64 57571429
+ 0.14 0.43 0.64 64642857
+ 0.14 0.43 0.64 71714286
+ 0.14 0.43 0.64 78785714
+ 0.14 0.43 0.64 85857143
+ 0.14 0.43 0.64 92928571
+ 0.14 0.43 0.64 100000000
+ 0.14 0.43 0.71 1000000
+ 0.14 0.43 0.71 8071429
+ 0.14 0.43 0.71 15142857
+ 0.14 0.43 0.71 22214286
+ 0.14 0.43 0.71 29285714
+ 0.14 0.43 0.71 36357143
+ 0.14 0.43 0.71 43428571
+ 0.14 0.43 0.71 50500000
+ 0.14 0.43 0.71 57571429
+ 0.14 0.43 0.71 64642857
+ 0.14 0.43 0.71 71714286
+ 0.14 0.43 0.71 78785714
+ 0.14 0.43 0.71 85857143
+ 0.14 0.43 0.71 92928571
+ 0.14 0.43 0.71 100000000
+ 0.14 0.43 0.79 1000000
+ 0.14 0.43 0.79 8071429
+ 0.14 0.43 0.79 15142857
+ 0.14 0.43 0.79 22214286
+ 0.14 0.43 0.79 29285714
+ 0.14 0.43 0.79 36357143
+ 0.14 0.43 0.79 43428571
+ 0.14 0.43 0.79 50500000
+ 0.14 0.43 0.79 57571429
+ 0.14 0.43 0.79 64642857
+ 0.14 0.43 0.79 71714286
+ 0.14 0.43 0.79 78785714
+ 0.14 0.43 0.79 85857143
+ 0.14 0.43 0.79 92928571
+ 0.14 0.43 0.79 100000000
+ 0.14 0.43 0.86 1000000
+ 0.14 0.43 0.86 8071429
+ 0.14 0.43 0.86 15142857
+ 0.14 0.43 0.86 22214286
+ 0.14 0.43 0.86 29285714
+ 0.14 0.43 0.86 36357143
+ 0.14 0.43 0.86 43428571
+ 0.14 0.43 0.86 50500000
+ 0.14 0.43 0.86 57571429
+ 0.14 0.43 0.86 64642857
+ 0.14 0.43 0.86 71714286
+ 0.14 0.43 0.86 78785714
+ 0.14 0.43 0.86 85857143
+ 0.14 0.43 0.86 92928571
+ 0.14 0.43 0.86 100000000
+ 0.14 0.43 0.93 1000000
+ 0.14 0.43 0.93 8071429
+ 0.14 0.43 0.93 15142857
+ 0.14 0.43 0.93 22214286
+ 0.14 0.43 0.93 29285714
+ 0.14 0.43 0.93 36357143
+ 0.14 0.43 0.93 43428571
+ 0.14 0.43 0.93 50500000
+ 0.14 0.43 0.93 57571429
+ 0.14 0.43 0.93 64642857
+ 0.14 0.43 0.93 71714286
+ 0.14 0.43 0.93 78785714
+ 0.14 0.43 0.93 85857143
+ 0.14 0.43 0.93 92928571
+ 0.14 0.43 0.93 100000000
+ 0.14 0.43 1.00 1000000
+ 0.14 0.43 1.00 8071429
+ 0.14 0.43 1.00 15142857
+ 0.14 0.43 1.00 22214286
+ 0.14 0.43 1.00 29285714
+ 0.14 0.43 1.00 36357143
+ 0.14 0.43 1.00 43428571
+ 0.14 0.43 1.00 50500000
+ 0.14 0.43 1.00 57571429
+ 0.14 0.43 1.00 64642857
+ 0.14 0.43 1.00 71714286
+ 0.14 0.43 1.00 78785714
+ 0.14 0.43 1.00 85857143
+ 0.14 0.43 1.00 92928571
+ 0.14 0.43 1.00 100000000
+ 0.14 0.50 0.00 1000000
+ 0.14 0.50 0.00 8071429
+ 0.14 0.50 0.00 15142857
+ 0.14 0.50 0.00 22214286
+ 0.14 0.50 0.00 29285714
+ 0.14 0.50 0.00 36357143
+ 0.14 0.50 0.00 43428571
+ 0.14 0.50 0.00 50500000
+ 0.14 0.50 0.00 57571429
+ 0.14 0.50 0.00 64642857
+ 0.14 0.50 0.00 71714286
+ 0.14 0.50 0.00 78785714
+ 0.14 0.50 0.00 85857143
+ 0.14 0.50 0.00 92928571
+ 0.14 0.50 0.00 100000000
+ 0.14 0.50 0.07 1000000
+ 0.14 0.50 0.07 8071429
+ 0.14 0.50 0.07 15142857
+ 0.14 0.50 0.07 22214286
+ 0.14 0.50 0.07 29285714
+ 0.14 0.50 0.07 36357143
+ 0.14 0.50 0.07 43428571
+ 0.14 0.50 0.07 50500000
+ 0.14 0.50 0.07 57571429
+ 0.14 0.50 0.07 64642857
+ 0.14 0.50 0.07 71714286
+ 0.14 0.50 0.07 78785714
+ 0.14 0.50 0.07 85857143
+ 0.14 0.50 0.07 92928571
+ 0.14 0.50 0.07 100000000
+ 0.14 0.50 0.14 1000000
+ 0.14 0.50 0.14 8071429
+ 0.14 0.50 0.14 15142857
+ 0.14 0.50 0.14 22214286
+ 0.14 0.50 0.14 29285714
+ 0.14 0.50 0.14 36357143
+ 0.14 0.50 0.14 43428571
+ 0.14 0.50 0.14 50500000
+ 0.14 0.50 0.14 57571429
+ 0.14 0.50 0.14 64642857
+ 0.14 0.50 0.14 71714286
+ 0.14 0.50 0.14 78785714
+ 0.14 0.50 0.14 85857143
+ 0.14 0.50 0.14 92928571
+ 0.14 0.50 0.14 100000000
+ 0.14 0.50 0.21 1000000
+ 0.14 0.50 0.21 8071429
+ 0.14 0.50 0.21 15142857
+ 0.14 0.50 0.21 22214286
+ 0.14 0.50 0.21 29285714
+ 0.14 0.50 0.21 36357143
+ 0.14 0.50 0.21 43428571
+ 0.14 0.50 0.21 50500000
+ 0.14 0.50 0.21 57571429
+ 0.14 0.50 0.21 64642857
+ 0.14 0.50 0.21 71714286
+ 0.14 0.50 0.21 78785714
+ 0.14 0.50 0.21 85857143
+ 0.14 0.50 0.21 92928571
+ 0.14 0.50 0.21 100000000
+ 0.14 0.50 0.29 1000000
+ 0.14 0.50 0.29 8071429
+ 0.14 0.50 0.29 15142857
+ 0.14 0.50 0.29 22214286
+ 0.14 0.50 0.29 29285714
+ 0.14 0.50 0.29 36357143
+ 0.14 0.50 0.29 43428571
+ 0.14 0.50 0.29 50500000
+ 0.14 0.50 0.29 57571429
+ 0.14 0.50 0.29 64642857
+ 0.14 0.50 0.29 71714286
+ 0.14 0.50 0.29 78785714
+ 0.14 0.50 0.29 85857143
+ 0.14 0.50 0.29 92928571
+ 0.14 0.50 0.29 100000000
+ 0.14 0.50 0.36 1000000
+ 0.14 0.50 0.36 8071429
+ 0.14 0.50 0.36 15142857
+ 0.14 0.50 0.36 22214286
+ 0.14 0.50 0.36 29285714
+ 0.14 0.50 0.36 36357143
+ 0.14 0.50 0.36 43428571
+ 0.14 0.50 0.36 50500000
+ 0.14 0.50 0.36 57571429
+ 0.14 0.50 0.36 64642857
+ 0.14 0.50 0.36 71714286
+ 0.14 0.50 0.36 78785714
+ 0.14 0.50 0.36 85857143
+ 0.14 0.50 0.36 92928571
+ 0.14 0.50 0.36 100000000
+ 0.14 0.50 0.43 1000000
+ 0.14 0.50 0.43 8071429
+ 0.14 0.50 0.43 15142857
+ 0.14 0.50 0.43 22214286
+ 0.14 0.50 0.43 29285714
+ 0.14 0.50 0.43 36357143
+ 0.14 0.50 0.43 43428571
+ 0.14 0.50 0.43 50500000
+ 0.14 0.50 0.43 57571429
+ 0.14 0.50 0.43 64642857
+ 0.14 0.50 0.43 71714286
+ 0.14 0.50 0.43 78785714
+ 0.14 0.50 0.43 85857143
+ 0.14 0.50 0.43 92928571
+ 0.14 0.50 0.43 100000000
+ 0.14 0.50 0.50 1000000
+ 0.14 0.50 0.50 8071429
+ 0.14 0.50 0.50 15142857
+ 0.14 0.50 0.50 22214286
+ 0.14 0.50 0.50 29285714
+ 0.14 0.50 0.50 36357143
+ 0.14 0.50 0.50 43428571
+ 0.14 0.50 0.50 50500000
+ 0.14 0.50 0.50 57571429
+ 0.14 0.50 0.50 64642857
+ 0.14 0.50 0.50 71714286
+ 0.14 0.50 0.50 78785714
+ 0.14 0.50 0.50 85857143
+ 0.14 0.50 0.50 92928571
+ 0.14 0.50 0.50 100000000
+ 0.14 0.50 0.57 1000000
+ 0.14 0.50 0.57 8071429
+ 0.14 0.50 0.57 15142857
+ 0.14 0.50 0.57 22214286
+ 0.14 0.50 0.57 29285714
+ 0.14 0.50 0.57 36357143
+ 0.14 0.50 0.57 43428571
+ 0.14 0.50 0.57 50500000
+ 0.14 0.50 0.57 57571429
+ 0.14 0.50 0.57 64642857
+ 0.14 0.50 0.57 71714286
+ 0.14 0.50 0.57 78785714
+ 0.14 0.50 0.57 85857143
+ 0.14 0.50 0.57 92928571
+ 0.14 0.50 0.57 100000000
+ 0.14 0.50 0.64 1000000
+ 0.14 0.50 0.64 8071429
+ 0.14 0.50 0.64 15142857
+ 0.14 0.50 0.64 22214286
+ 0.14 0.50 0.64 29285714
+ 0.14 0.50 0.64 36357143
+ 0.14 0.50 0.64 43428571
+ 0.14 0.50 0.64 50500000
+ 0.14 0.50 0.64 57571429
+ 0.14 0.50 0.64 64642857
+ 0.14 0.50 0.64 71714286
+ 0.14 0.50 0.64 78785714
+ 0.14 0.50 0.64 85857143
+ 0.14 0.50 0.64 92928571
+ 0.14 0.50 0.64 100000000
+ 0.14 0.50 0.71 1000000
+ 0.14 0.50 0.71 8071429
+ 0.14 0.50 0.71 15142857
+ 0.14 0.50 0.71 22214286
+ 0.14 0.50 0.71 29285714
+ 0.14 0.50 0.71 36357143
+ 0.14 0.50 0.71 43428571
+ 0.14 0.50 0.71 50500000
+ 0.14 0.50 0.71 57571429
+ 0.14 0.50 0.71 64642857
+ 0.14 0.50 0.71 71714286
+ 0.14 0.50 0.71 78785714
+ 0.14 0.50 0.71 85857143
+ 0.14 0.50 0.71 92928571
+ 0.14 0.50 0.71 100000000
+ 0.14 0.50 0.79 1000000
+ 0.14 0.50 0.79 8071429
+ 0.14 0.50 0.79 15142857
+ 0.14 0.50 0.79 22214286
+ 0.14 0.50 0.79 29285714
+ 0.14 0.50 0.79 36357143
+ 0.14 0.50 0.79 43428571
+ 0.14 0.50 0.79 50500000
+ 0.14 0.50 0.79 57571429
+ 0.14 0.50 0.79 64642857
+ 0.14 0.50 0.79 71714286
+ 0.14 0.50 0.79 78785714
+ 0.14 0.50 0.79 85857143
+ 0.14 0.50 0.79 92928571
+ 0.14 0.50 0.79 100000000
+ 0.14 0.50 0.86 1000000
+ 0.14 0.50 0.86 8071429
+ 0.14 0.50 0.86 15142857
+ 0.14 0.50 0.86 22214286
+ 0.14 0.50 0.86 29285714
+ 0.14 0.50 0.86 36357143
+ 0.14 0.50 0.86 43428571
+ 0.14 0.50 0.86 50500000
+ 0.14 0.50 0.86 57571429
+ 0.14 0.50 0.86 64642857
+ 0.14 0.50 0.86 71714286
+ 0.14 0.50 0.86 78785714
+ 0.14 0.50 0.86 85857143
+ 0.14 0.50 0.86 92928571
+ 0.14 0.50 0.86 100000000
+ 0.14 0.50 0.93 1000000
+ 0.14 0.50 0.93 8071429
+ 0.14 0.50 0.93 15142857
+ 0.14 0.50 0.93 22214286
+ 0.14 0.50 0.93 29285714
+ 0.14 0.50 0.93 36357143
+ 0.14 0.50 0.93 43428571
+ 0.14 0.50 0.93 50500000
+ 0.14 0.50 0.93 57571429
+ 0.14 0.50 0.93 64642857
+ 0.14 0.50 0.93 71714286
+ 0.14 0.50 0.93 78785714
+ 0.14 0.50 0.93 85857143
+ 0.14 0.50 0.93 92928571
+ 0.14 0.50 0.93 100000000
+ 0.14 0.50 1.00 1000000
+ 0.14 0.50 1.00 8071429
+ 0.14 0.50 1.00 15142857
+ 0.14 0.50 1.00 22214286
+ 0.14 0.50 1.00 29285714
+ 0.14 0.50 1.00 36357143
+ 0.14 0.50 1.00 43428571
+ 0.14 0.50 1.00 50500000
+ 0.14 0.50 1.00 57571429
+ 0.14 0.50 1.00 64642857
+ 0.14 0.50 1.00 71714286
+ 0.14 0.50 1.00 78785714
+ 0.14 0.50 1.00 85857143
+ 0.14 0.50 1.00 92928571
+ 0.14 0.50 1.00 100000000
+ 0.14 0.57 0.00 1000000
+ 0.14 0.57 0.00 8071429
+ 0.14 0.57 0.00 15142857
+ 0.14 0.57 0.00 22214286
+ 0.14 0.57 0.00 29285714
+ 0.14 0.57 0.00 36357143
+ 0.14 0.57 0.00 43428571
+ 0.14 0.57 0.00 50500000
+ 0.14 0.57 0.00 57571429
+ 0.14 0.57 0.00 64642857
+ 0.14 0.57 0.00 71714286
+ 0.14 0.57 0.00 78785714
+ 0.14 0.57 0.00 85857143
+ 0.14 0.57 0.00 92928571
+ 0.14 0.57 0.00 100000000
+ 0.14 0.57 0.07 1000000
+ 0.14 0.57 0.07 8071429
+ 0.14 0.57 0.07 15142857
+ 0.14 0.57 0.07 22214286
+ 0.14 0.57 0.07 29285714
+ 0.14 0.57 0.07 36357143
+ 0.14 0.57 0.07 43428571
+ 0.14 0.57 0.07 50500000
+ 0.14 0.57 0.07 57571429
+ 0.14 0.57 0.07 64642857
+ 0.14 0.57 0.07 71714286
+ 0.14 0.57 0.07 78785714
+ 0.14 0.57 0.07 85857143
+ 0.14 0.57 0.07 92928571
+ 0.14 0.57 0.07 100000000
+ 0.14 0.57 0.14 1000000
+ 0.14 0.57 0.14 8071429
+ 0.14 0.57 0.14 15142857
+ 0.14 0.57 0.14 22214286
+ 0.14 0.57 0.14 29285714
+ 0.14 0.57 0.14 36357143
+ 0.14 0.57 0.14 43428571
+ 0.14 0.57 0.14 50500000
+ 0.14 0.57 0.14 57571429
+ 0.14 0.57 0.14 64642857
+ 0.14 0.57 0.14 71714286
+ 0.14 0.57 0.14 78785714
+ 0.14 0.57 0.14 85857143
+ 0.14 0.57 0.14 92928571
+ 0.14 0.57 0.14 100000000
+ 0.14 0.57 0.21 1000000
+ 0.14 0.57 0.21 8071429
+ 0.14 0.57 0.21 15142857
+ 0.14 0.57 0.21 22214286
+ 0.14 0.57 0.21 29285714
+ 0.14 0.57 0.21 36357143
+ 0.14 0.57 0.21 43428571
+ 0.14 0.57 0.21 50500000
+ 0.14 0.57 0.21 57571429
+ 0.14 0.57 0.21 64642857
+ 0.14 0.57 0.21 71714286
+ 0.14 0.57 0.21 78785714
+ 0.14 0.57 0.21 85857143
+ 0.14 0.57 0.21 92928571
+ 0.14 0.57 0.21 100000000
+ 0.14 0.57 0.29 1000000
+ 0.14 0.57 0.29 8071429
+ 0.14 0.57 0.29 15142857
+ 0.14 0.57 0.29 22214286
+ 0.14 0.57 0.29 29285714
+ 0.14 0.57 0.29 36357143
+ 0.14 0.57 0.29 43428571
+ 0.14 0.57 0.29 50500000
+ 0.14 0.57 0.29 57571429
+ 0.14 0.57 0.29 64642857
+ 0.14 0.57 0.29 71714286
+ 0.14 0.57 0.29 78785714
+ 0.14 0.57 0.29 85857143
+ 0.14 0.57 0.29 92928571
+ 0.14 0.57 0.29 100000000
+ 0.14 0.57 0.36 1000000
+ 0.14 0.57 0.36 8071429
+ 0.14 0.57 0.36 15142857
+ 0.14 0.57 0.36 22214286
+ 0.14 0.57 0.36 29285714
+ 0.14 0.57 0.36 36357143
+ 0.14 0.57 0.36 43428571
+ 0.14 0.57 0.36 50500000
+ 0.14 0.57 0.36 57571429
+ 0.14 0.57 0.36 64642857
+ 0.14 0.57 0.36 71714286
+ 0.14 0.57 0.36 78785714
+ 0.14 0.57 0.36 85857143
+ 0.14 0.57 0.36 92928571
+ 0.14 0.57 0.36 100000000
+ 0.14 0.57 0.43 1000000
+ 0.14 0.57 0.43 8071429
+ 0.14 0.57 0.43 15142857
+ 0.14 0.57 0.43 22214286
+ 0.14 0.57 0.43 29285714
+ 0.14 0.57 0.43 36357143
+ 0.14 0.57 0.43 43428571
+ 0.14 0.57 0.43 50500000
+ 0.14 0.57 0.43 57571429
+ 0.14 0.57 0.43 64642857
+ 0.14 0.57 0.43 71714286
+ 0.14 0.57 0.43 78785714
+ 0.14 0.57 0.43 85857143
+ 0.14 0.57 0.43 92928571
+ 0.14 0.57 0.43 100000000
+ 0.14 0.57 0.50 1000000
+ 0.14 0.57 0.50 8071429
+ 0.14 0.57 0.50 15142857
+ 0.14 0.57 0.50 22214286
+ 0.14 0.57 0.50 29285714
+ 0.14 0.57 0.50 36357143
+ 0.14 0.57 0.50 43428571
+ 0.14 0.57 0.50 50500000
+ 0.14 0.57 0.50 57571429
+ 0.14 0.57 0.50 64642857
+ 0.14 0.57 0.50 71714286
+ 0.14 0.57 0.50 78785714
+ 0.14 0.57 0.50 85857143
+ 0.14 0.57 0.50 92928571
+ 0.14 0.57 0.50 100000000
+ 0.14 0.57 0.57 1000000
+ 0.14 0.57 0.57 8071429
+ 0.14 0.57 0.57 15142857
+ 0.14 0.57 0.57 22214286
+ 0.14 0.57 0.57 29285714
+ 0.14 0.57 0.57 36357143
+ 0.14 0.57 0.57 43428571
+ 0.14 0.57 0.57 50500000
+ 0.14 0.57 0.57 57571429
+ 0.14 0.57 0.57 64642857
+ 0.14 0.57 0.57 71714286
+ 0.14 0.57 0.57 78785714
+ 0.14 0.57 0.57 85857143
+ 0.14 0.57 0.57 92928571
+ 0.14 0.57 0.57 100000000
+ 0.14 0.57 0.64 1000000
+ 0.14 0.57 0.64 8071429
+ 0.14 0.57 0.64 15142857
+ 0.14 0.57 0.64 22214286
+ 0.14 0.57 0.64 29285714
+ 0.14 0.57 0.64 36357143
+ 0.14 0.57 0.64 43428571
+ 0.14 0.57 0.64 50500000
+ 0.14 0.57 0.64 57571429
+ 0.14 0.57 0.64 64642857
+ 0.14 0.57 0.64 71714286
+ 0.14 0.57 0.64 78785714
+ 0.14 0.57 0.64 85857143
+ 0.14 0.57 0.64 92928571
+ 0.14 0.57 0.64 100000000
+ 0.14 0.57 0.71 1000000
+ 0.14 0.57 0.71 8071429
+ 0.14 0.57 0.71 15142857
+ 0.14 0.57 0.71 22214286
+ 0.14 0.57 0.71 29285714
+ 0.14 0.57 0.71 36357143
+ 0.14 0.57 0.71 43428571
+ 0.14 0.57 0.71 50500000
+ 0.14 0.57 0.71 57571429
+ 0.14 0.57 0.71 64642857
+ 0.14 0.57 0.71 71714286
+ 0.14 0.57 0.71 78785714
+ 0.14 0.57 0.71 85857143
+ 0.14 0.57 0.71 92928571
+ 0.14 0.57 0.71 100000000
+ 0.14 0.57 0.79 1000000
+ 0.14 0.57 0.79 8071429
+ 0.14 0.57 0.79 15142857
+ 0.14 0.57 0.79 22214286
+ 0.14 0.57 0.79 29285714
+ 0.14 0.57 0.79 36357143
+ 0.14 0.57 0.79 43428571
+ 0.14 0.57 0.79 50500000
+ 0.14 0.57 0.79 57571429
+ 0.14 0.57 0.79 64642857
+ 0.14 0.57 0.79 71714286
+ 0.14 0.57 0.79 78785714
+ 0.14 0.57 0.79 85857143
+ 0.14 0.57 0.79 92928571
+ 0.14 0.57 0.79 100000000
+ 0.14 0.57 0.86 1000000
+ 0.14 0.57 0.86 8071429
+ 0.14 0.57 0.86 15142857
+ 0.14 0.57 0.86 22214286
+ 0.14 0.57 0.86 29285714
+ 0.14 0.57 0.86 36357143
+ 0.14 0.57 0.86 43428571
+ 0.14 0.57 0.86 50500000
+ 0.14 0.57 0.86 57571429
+ 0.14 0.57 0.86 64642857
+ 0.14 0.57 0.86 71714286
+ 0.14 0.57 0.86 78785714
+ 0.14 0.57 0.86 85857143
+ 0.14 0.57 0.86 92928571
+ 0.14 0.57 0.86 100000000
+ 0.14 0.57 0.93 1000000
+ 0.14 0.57 0.93 8071429
+ 0.14 0.57 0.93 15142857
+ 0.14 0.57 0.93 22214286
+ 0.14 0.57 0.93 29285714
+ 0.14 0.57 0.93 36357143
+ 0.14 0.57 0.93 43428571
+ 0.14 0.57 0.93 50500000
+ 0.14 0.57 0.93 57571429
+ 0.14 0.57 0.93 64642857
+ 0.14 0.57 0.93 71714286
+ 0.14 0.57 0.93 78785714
+ 0.14 0.57 0.93 85857143
+ 0.14 0.57 0.93 92928571
+ 0.14 0.57 0.93 100000000
+ 0.14 0.57 1.00 1000000
+ 0.14 0.57 1.00 8071429
+ 0.14 0.57 1.00 15142857
+ 0.14 0.57 1.00 22214286
+ 0.14 0.57 1.00 29285714
+ 0.14 0.57 1.00 36357143
+ 0.14 0.57 1.00 43428571
+ 0.14 0.57 1.00 50500000
+ 0.14 0.57 1.00 57571429
+ 0.14 0.57 1.00 64642857
+ 0.14 0.57 1.00 71714286
+ 0.14 0.57 1.00 78785714
+ 0.14 0.57 1.00 85857143
+ 0.14 0.57 1.00 92928571
+ 0.14 0.57 1.00 100000000
+ 0.14 0.64 0.00 1000000
+ 0.14 0.64 0.00 8071429
+ 0.14 0.64 0.00 15142857
+ 0.14 0.64 0.00 22214286
+ 0.14 0.64 0.00 29285714
+ 0.14 0.64 0.00 36357143
+ 0.14 0.64 0.00 43428571
+ 0.14 0.64 0.00 50500000
+ 0.14 0.64 0.00 57571429
+ 0.14 0.64 0.00 64642857
+ 0.14 0.64 0.00 71714286
+ 0.14 0.64 0.00 78785714
+ 0.14 0.64 0.00 85857143
+ 0.14 0.64 0.00 92928571
+ 0.14 0.64 0.00 100000000
+ 0.14 0.64 0.07 1000000
+ 0.14 0.64 0.07 8071429
+ 0.14 0.64 0.07 15142857
+ 0.14 0.64 0.07 22214286
+ 0.14 0.64 0.07 29285714
+ 0.14 0.64 0.07 36357143
+ 0.14 0.64 0.07 43428571
+ 0.14 0.64 0.07 50500000
+ 0.14 0.64 0.07 57571429
+ 0.14 0.64 0.07 64642857
+ 0.14 0.64 0.07 71714286
+ 0.14 0.64 0.07 78785714
+ 0.14 0.64 0.07 85857143
+ 0.14 0.64 0.07 92928571
+ 0.14 0.64 0.07 100000000
+ 0.14 0.64 0.14 1000000
+ 0.14 0.64 0.14 8071429
+ 0.14 0.64 0.14 15142857
+ 0.14 0.64 0.14 22214286
+ 0.14 0.64 0.14 29285714
+ 0.14 0.64 0.14 36357143
+ 0.14 0.64 0.14 43428571
+ 0.14 0.64 0.14 50500000
+ 0.14 0.64 0.14 57571429
+ 0.14 0.64 0.14 64642857
+ 0.14 0.64 0.14 71714286
+ 0.14 0.64 0.14 78785714
+ 0.14 0.64 0.14 85857143
+ 0.14 0.64 0.14 92928571
+ 0.14 0.64 0.14 100000000
+ 0.14 0.64 0.21 1000000
+ 0.14 0.64 0.21 8071429
+ 0.14 0.64 0.21 15142857
+ 0.14 0.64 0.21 22214286
+ 0.14 0.64 0.21 29285714
+ 0.14 0.64 0.21 36357143
+ 0.14 0.64 0.21 43428571
+ 0.14 0.64 0.21 50500000
+ 0.14 0.64 0.21 57571429
+ 0.14 0.64 0.21 64642857
+ 0.14 0.64 0.21 71714286
+ 0.14 0.64 0.21 78785714
+ 0.14 0.64 0.21 85857143
+ 0.14 0.64 0.21 92928571
+ 0.14 0.64 0.21 100000000
+ 0.14 0.64 0.29 1000000
+ 0.14 0.64 0.29 8071429
+ 0.14 0.64 0.29 15142857
+ 0.14 0.64 0.29 22214286
+ 0.14 0.64 0.29 29285714
+ 0.14 0.64 0.29 36357143
+ 0.14 0.64 0.29 43428571
+ 0.14 0.64 0.29 50500000
+ 0.14 0.64 0.29 57571429
+ 0.14 0.64 0.29 64642857
+ 0.14 0.64 0.29 71714286
+ 0.14 0.64 0.29 78785714
+ 0.14 0.64 0.29 85857143
+ 0.14 0.64 0.29 92928571
+ 0.14 0.64 0.29 100000000
+ 0.14 0.64 0.36 1000000
+ 0.14 0.64 0.36 8071429
+ 0.14 0.64 0.36 15142857
+ 0.14 0.64 0.36 22214286
+ 0.14 0.64 0.36 29285714
+ 0.14 0.64 0.36 36357143
+ 0.14 0.64 0.36 43428571
+ 0.14 0.64 0.36 50500000
+ 0.14 0.64 0.36 57571429
+ 0.14 0.64 0.36 64642857
+ 0.14 0.64 0.36 71714286
+ 0.14 0.64 0.36 78785714
+ 0.14 0.64 0.36 85857143
+ 0.14 0.64 0.36 92928571
+ 0.14 0.64 0.36 100000000
+ 0.14 0.64 0.43 1000000
+ 0.14 0.64 0.43 8071429
+ 0.14 0.64 0.43 15142857
+ 0.14 0.64 0.43 22214286
+ 0.14 0.64 0.43 29285714
+ 0.14 0.64 0.43 36357143
+ 0.14 0.64 0.43 43428571
+ 0.14 0.64 0.43 50500000
+ 0.14 0.64 0.43 57571429
+ 0.14 0.64 0.43 64642857
+ 0.14 0.64 0.43 71714286
+ 0.14 0.64 0.43 78785714
+ 0.14 0.64 0.43 85857143
+ 0.14 0.64 0.43 92928571
+ 0.14 0.64 0.43 100000000
+ 0.14 0.64 0.50 1000000
+ 0.14 0.64 0.50 8071429
+ 0.14 0.64 0.50 15142857
+ 0.14 0.64 0.50 22214286
+ 0.14 0.64 0.50 29285714
+ 0.14 0.64 0.50 36357143
+ 0.14 0.64 0.50 43428571
+ 0.14 0.64 0.50 50500000
+ 0.14 0.64 0.50 57571429
+ 0.14 0.64 0.50 64642857
+ 0.14 0.64 0.50 71714286
+ 0.14 0.64 0.50 78785714
+ 0.14 0.64 0.50 85857143
+ 0.14 0.64 0.50 92928571
+ 0.14 0.64 0.50 100000000
+ 0.14 0.64 0.57 1000000
+ 0.14 0.64 0.57 8071429
+ 0.14 0.64 0.57 15142857
+ 0.14 0.64 0.57 22214286
+ 0.14 0.64 0.57 29285714
+ 0.14 0.64 0.57 36357143
+ 0.14 0.64 0.57 43428571
+ 0.14 0.64 0.57 50500000
+ 0.14 0.64 0.57 57571429
+ 0.14 0.64 0.57 64642857
+ 0.14 0.64 0.57 71714286
+ 0.14 0.64 0.57 78785714
+ 0.14 0.64 0.57 85857143
+ 0.14 0.64 0.57 92928571
+ 0.14 0.64 0.57 100000000
+ 0.14 0.64 0.64 1000000
+ 0.14 0.64 0.64 8071429
+ 0.14 0.64 0.64 15142857
+ 0.14 0.64 0.64 22214286
+ 0.14 0.64 0.64 29285714
+ 0.14 0.64 0.64 36357143
+ 0.14 0.64 0.64 43428571
+ 0.14 0.64 0.64 50500000
+ 0.14 0.64 0.64 57571429
+ 0.14 0.64 0.64 64642857
+ 0.14 0.64 0.64 71714286
+ 0.14 0.64 0.64 78785714
+ 0.14 0.64 0.64 85857143
+ 0.14 0.64 0.64 92928571
+ 0.14 0.64 0.64 100000000
+ 0.14 0.64 0.71 1000000
+ 0.14 0.64 0.71 8071429
+ 0.14 0.64 0.71 15142857
+ 0.14 0.64 0.71 22214286
+ 0.14 0.64 0.71 29285714
+ 0.14 0.64 0.71 36357143
+ 0.14 0.64 0.71 43428571
+ 0.14 0.64 0.71 50500000
+ 0.14 0.64 0.71 57571429
+ 0.14 0.64 0.71 64642857
+ 0.14 0.64 0.71 71714286
+ 0.14 0.64 0.71 78785714
+ 0.14 0.64 0.71 85857143
+ 0.14 0.64 0.71 92928571
+ 0.14 0.64 0.71 100000000
+ 0.14 0.64 0.79 1000000
+ 0.14 0.64 0.79 8071429
+ 0.14 0.64 0.79 15142857
+ 0.14 0.64 0.79 22214286
+ 0.14 0.64 0.79 29285714
+ 0.14 0.64 0.79 36357143
+ 0.14 0.64 0.79 43428571
+ 0.14 0.64 0.79 50500000
+ 0.14 0.64 0.79 57571429
+ 0.14 0.64 0.79 64642857
+ 0.14 0.64 0.79 71714286
+ 0.14 0.64 0.79 78785714
+ 0.14 0.64 0.79 85857143
+ 0.14 0.64 0.79 92928571
+ 0.14 0.64 0.79 100000000
+ 0.14 0.64 0.86 1000000
+ 0.14 0.64 0.86 8071429
+ 0.14 0.64 0.86 15142857
+ 0.14 0.64 0.86 22214286
+ 0.14 0.64 0.86 29285714
+ 0.14 0.64 0.86 36357143
+ 0.14 0.64 0.86 43428571
+ 0.14 0.64 0.86 50500000
+ 0.14 0.64 0.86 57571429
+ 0.14 0.64 0.86 64642857
+ 0.14 0.64 0.86 71714286
+ 0.14 0.64 0.86 78785714
+ 0.14 0.64 0.86 85857143
+ 0.14 0.64 0.86 92928571
+ 0.14 0.64 0.86 100000000
+ 0.14 0.64 0.93 1000000
+ 0.14 0.64 0.93 8071429
+ 0.14 0.64 0.93 15142857
+ 0.14 0.64 0.93 22214286
+ 0.14 0.64 0.93 29285714
+ 0.14 0.64 0.93 36357143
+ 0.14 0.64 0.93 43428571
+ 0.14 0.64 0.93 50500000
+ 0.14 0.64 0.93 57571429
+ 0.14 0.64 0.93 64642857
+ 0.14 0.64 0.93 71714286
+ 0.14 0.64 0.93 78785714
+ 0.14 0.64 0.93 85857143
+ 0.14 0.64 0.93 92928571
+ 0.14 0.64 0.93 100000000
+ 0.14 0.64 1.00 1000000
+ 0.14 0.64 1.00 8071429
+ 0.14 0.64 1.00 15142857
+ 0.14 0.64 1.00 22214286
+ 0.14 0.64 1.00 29285714
+ 0.14 0.64 1.00 36357143
+ 0.14 0.64 1.00 43428571
+ 0.14 0.64 1.00 50500000
+ 0.14 0.64 1.00 57571429
+ 0.14 0.64 1.00 64642857
+ 0.14 0.64 1.00 71714286
+ 0.14 0.64 1.00 78785714
+ 0.14 0.64 1.00 85857143
+ 0.14 0.64 1.00 92928571
+ 0.14 0.64 1.00 100000000
+ 0.14 0.71 0.00 1000000
+ 0.14 0.71 0.00 8071429
+ 0.14 0.71 0.00 15142857
+ 0.14 0.71 0.00 22214286
+ 0.14 0.71 0.00 29285714
+ 0.14 0.71 0.00 36357143
+ 0.14 0.71 0.00 43428571
+ 0.14 0.71 0.00 50500000
+ 0.14 0.71 0.00 57571429
+ 0.14 0.71 0.00 64642857
+ 0.14 0.71 0.00 71714286
+ 0.14 0.71 0.00 78785714
+ 0.14 0.71 0.00 85857143
+ 0.14 0.71 0.00 92928571
+ 0.14 0.71 0.00 100000000
+ 0.14 0.71 0.07 1000000
+ 0.14 0.71 0.07 8071429
+ 0.14 0.71 0.07 15142857
+ 0.14 0.71 0.07 22214286
+ 0.14 0.71 0.07 29285714
+ 0.14 0.71 0.07 36357143
+ 0.14 0.71 0.07 43428571
+ 0.14 0.71 0.07 50500000
+ 0.14 0.71 0.07 57571429
+ 0.14 0.71 0.07 64642857
+ 0.14 0.71 0.07 71714286
+ 0.14 0.71 0.07 78785714
+ 0.14 0.71 0.07 85857143
+ 0.14 0.71 0.07 92928571
+ 0.14 0.71 0.07 100000000
+ 0.14 0.71 0.14 1000000
+ 0.14 0.71 0.14 8071429
+ 0.14 0.71 0.14 15142857
+ 0.14 0.71 0.14 22214286
+ 0.14 0.71 0.14 29285714
+ 0.14 0.71 0.14 36357143
+ 0.14 0.71 0.14 43428571
+ 0.14 0.71 0.14 50500000
+ 0.14 0.71 0.14 57571429
+ 0.14 0.71 0.14 64642857
+ 0.14 0.71 0.14 71714286
+ 0.14 0.71 0.14 78785714
+ 0.14 0.71 0.14 85857143
+ 0.14 0.71 0.14 92928571
+ 0.14 0.71 0.14 100000000
+ 0.14 0.71 0.21 1000000
+ 0.14 0.71 0.21 8071429
+ 0.14 0.71 0.21 15142857
+ 0.14 0.71 0.21 22214286
+ 0.14 0.71 0.21 29285714
+ 0.14 0.71 0.21 36357143
+ 0.14 0.71 0.21 43428571
+ 0.14 0.71 0.21 50500000
+ 0.14 0.71 0.21 57571429
+ 0.14 0.71 0.21 64642857
+ 0.14 0.71 0.21 71714286
+ 0.14 0.71 0.21 78785714
+ 0.14 0.71 0.21 85857143
+ 0.14 0.71 0.21 92928571
+ 0.14 0.71 0.21 100000000
+ 0.14 0.71 0.29 1000000
+ 0.14 0.71 0.29 8071429
+ 0.14 0.71 0.29 15142857
+ 0.14 0.71 0.29 22214286
+ 0.14 0.71 0.29 29285714
+ 0.14 0.71 0.29 36357143
+ 0.14 0.71 0.29 43428571
+ 0.14 0.71 0.29 50500000
+ 0.14 0.71 0.29 57571429
+ 0.14 0.71 0.29 64642857
+ 0.14 0.71 0.29 71714286
+ 0.14 0.71 0.29 78785714
+ 0.14 0.71 0.29 85857143
+ 0.14 0.71 0.29 92928571
+ 0.14 0.71 0.29 100000000
+ 0.14 0.71 0.36 1000000
+ 0.14 0.71 0.36 8071429
+ 0.14 0.71 0.36 15142857
+ 0.14 0.71 0.36 22214286
+ 0.14 0.71 0.36 29285714
+ 0.14 0.71 0.36 36357143
+ 0.14 0.71 0.36 43428571
+ 0.14 0.71 0.36 50500000
+ 0.14 0.71 0.36 57571429
+ 0.14 0.71 0.36 64642857
+ 0.14 0.71 0.36 71714286
+ 0.14 0.71 0.36 78785714
+ 0.14 0.71 0.36 85857143
+ 0.14 0.71 0.36 92928571
+ 0.14 0.71 0.36 100000000
+ 0.14 0.71 0.43 1000000
+ 0.14 0.71 0.43 8071429
+ 0.14 0.71 0.43 15142857
+ 0.14 0.71 0.43 22214286
+ 0.14 0.71 0.43 29285714
+ 0.14 0.71 0.43 36357143
+ 0.14 0.71 0.43 43428571
+ 0.14 0.71 0.43 50500000
+ 0.14 0.71 0.43 57571429
+ 0.14 0.71 0.43 64642857
+ 0.14 0.71 0.43 71714286
+ 0.14 0.71 0.43 78785714
+ 0.14 0.71 0.43 85857143
+ 0.14 0.71 0.43 92928571
+ 0.14 0.71 0.43 100000000
+ 0.14 0.71 0.50 1000000
+ 0.14 0.71 0.50 8071429
+ 0.14 0.71 0.50 15142857
+ 0.14 0.71 0.50 22214286
+ 0.14 0.71 0.50 29285714
+ 0.14 0.71 0.50 36357143
+ 0.14 0.71 0.50 43428571
+ 0.14 0.71 0.50 50500000
+ 0.14 0.71 0.50 57571429
+ 0.14 0.71 0.50 64642857
+ 0.14 0.71 0.50 71714286
+ 0.14 0.71 0.50 78785714
+ 0.14 0.71 0.50 85857143
+ 0.14 0.71 0.50 92928571
+ 0.14 0.71 0.50 100000000
+ 0.14 0.71 0.57 1000000
+ 0.14 0.71 0.57 8071429
+ 0.14 0.71 0.57 15142857
+ 0.14 0.71 0.57 22214286
+ 0.14 0.71 0.57 29285714
+ 0.14 0.71 0.57 36357143
+ 0.14 0.71 0.57 43428571
+ 0.14 0.71 0.57 50500000
+ 0.14 0.71 0.57 57571429
+ 0.14 0.71 0.57 64642857
+ 0.14 0.71 0.57 71714286
+ 0.14 0.71 0.57 78785714
+ 0.14 0.71 0.57 85857143
+ 0.14 0.71 0.57 92928571
+ 0.14 0.71 0.57 100000000
+ 0.14 0.71 0.64 1000000
+ 0.14 0.71 0.64 8071429
+ 0.14 0.71 0.64 15142857
+ 0.14 0.71 0.64 22214286
+ 0.14 0.71 0.64 29285714
+ 0.14 0.71 0.64 36357143
+ 0.14 0.71 0.64 43428571
+ 0.14 0.71 0.64 50500000
+ 0.14 0.71 0.64 57571429
+ 0.14 0.71 0.64 64642857
+ 0.14 0.71 0.64 71714286
+ 0.14 0.71 0.64 78785714
+ 0.14 0.71 0.64 85857143
+ 0.14 0.71 0.64 92928571
+ 0.14 0.71 0.64 100000000
+ 0.14 0.71 0.71 1000000
+ 0.14 0.71 0.71 8071429
+ 0.14 0.71 0.71 15142857
+ 0.14 0.71 0.71 22214286
+ 0.14 0.71 0.71 29285714
+ 0.14 0.71 0.71 36357143
+ 0.14 0.71 0.71 43428571
+ 0.14 0.71 0.71 50500000
+ 0.14 0.71 0.71 57571429
+ 0.14 0.71 0.71 64642857
+ 0.14 0.71 0.71 71714286
+ 0.14 0.71 0.71 78785714
+ 0.14 0.71 0.71 85857143
+ 0.14 0.71 0.71 92928571
+ 0.14 0.71 0.71 100000000
+ 0.14 0.71 0.79 1000000
+ 0.14 0.71 0.79 8071429
+ 0.14 0.71 0.79 15142857
+ 0.14 0.71 0.79 22214286
+ 0.14 0.71 0.79 29285714
+ 0.14 0.71 0.79 36357143
+ 0.14 0.71 0.79 43428571
+ 0.14 0.71 0.79 50500000
+ 0.14 0.71 0.79 57571429
+ 0.14 0.71 0.79 64642857
+ 0.14 0.71 0.79 71714286
+ 0.14 0.71 0.79 78785714
+ 0.14 0.71 0.79 85857143
+ 0.14 0.71 0.79 92928571
+ 0.14 0.71 0.79 100000000
+ 0.14 0.71 0.86 1000000
+ 0.14 0.71 0.86 8071429
+ 0.14 0.71 0.86 15142857
+ 0.14 0.71 0.86 22214286
+ 0.14 0.71 0.86 29285714
+ 0.14 0.71 0.86 36357143
+ 0.14 0.71 0.86 43428571
+ 0.14 0.71 0.86 50500000
+ 0.14 0.71 0.86 57571429
+ 0.14 0.71 0.86 64642857
+ 0.14 0.71 0.86 71714286
+ 0.14 0.71 0.86 78785714
+ 0.14 0.71 0.86 85857143
+ 0.14 0.71 0.86 92928571
+ 0.14 0.71 0.86 100000000
+ 0.14 0.71 0.93 1000000
+ 0.14 0.71 0.93 8071429
+ 0.14 0.71 0.93 15142857
+ 0.14 0.71 0.93 22214286
+ 0.14 0.71 0.93 29285714
+ 0.14 0.71 0.93 36357143
+ 0.14 0.71 0.93 43428571
+ 0.14 0.71 0.93 50500000
+ 0.14 0.71 0.93 57571429
+ 0.14 0.71 0.93 64642857
+ 0.14 0.71 0.93 71714286
+ 0.14 0.71 0.93 78785714
+ 0.14 0.71 0.93 85857143
+ 0.14 0.71 0.93 92928571
+ 0.14 0.71 0.93 100000000
+ 0.14 0.71 1.00 1000000
+ 0.14 0.71 1.00 8071429
+ 0.14 0.71 1.00 15142857
+ 0.14 0.71 1.00 22214286
+ 0.14 0.71 1.00 29285714
+ 0.14 0.71 1.00 36357143
+ 0.14 0.71 1.00 43428571
+ 0.14 0.71 1.00 50500000
+ 0.14 0.71 1.00 57571429
+ 0.14 0.71 1.00 64642857
+ 0.14 0.71 1.00 71714286
+ 0.14 0.71 1.00 78785714
+ 0.14 0.71 1.00 85857143
+ 0.14 0.71 1.00 92928571
+ 0.14 0.71 1.00 100000000
+ 0.14 0.79 0.00 1000000
+ 0.14 0.79 0.00 8071429
+ 0.14 0.79 0.00 15142857
+ 0.14 0.79 0.00 22214286
+ 0.14 0.79 0.00 29285714
+ 0.14 0.79 0.00 36357143
+ 0.14 0.79 0.00 43428571
+ 0.14 0.79 0.00 50500000
+ 0.14 0.79 0.00 57571429
+ 0.14 0.79 0.00 64642857
+ 0.14 0.79 0.00 71714286
+ 0.14 0.79 0.00 78785714
+ 0.14 0.79 0.00 85857143
+ 0.14 0.79 0.00 92928571
+ 0.14 0.79 0.00 100000000
+ 0.14 0.79 0.07 1000000
+ 0.14 0.79 0.07 8071429
+ 0.14 0.79 0.07 15142857
+ 0.14 0.79 0.07 22214286
+ 0.14 0.79 0.07 29285714
+ 0.14 0.79 0.07 36357143
+ 0.14 0.79 0.07 43428571
+ 0.14 0.79 0.07 50500000
+ 0.14 0.79 0.07 57571429
+ 0.14 0.79 0.07 64642857
+ 0.14 0.79 0.07 71714286
+ 0.14 0.79 0.07 78785714
+ 0.14 0.79 0.07 85857143
+ 0.14 0.79 0.07 92928571
+ 0.14 0.79 0.07 100000000
+ 0.14 0.79 0.14 1000000
+ 0.14 0.79 0.14 8071429
+ 0.14 0.79 0.14 15142857
+ 0.14 0.79 0.14 22214286
+ 0.14 0.79 0.14 29285714
+ 0.14 0.79 0.14 36357143
+ 0.14 0.79 0.14 43428571
+ 0.14 0.79 0.14 50500000
+ 0.14 0.79 0.14 57571429
+ 0.14 0.79 0.14 64642857
+ 0.14 0.79 0.14 71714286
+ 0.14 0.79 0.14 78785714
+ 0.14 0.79 0.14 85857143
+ 0.14 0.79 0.14 92928571
+ 0.14 0.79 0.14 100000000
+ 0.14 0.79 0.21 1000000
+ 0.14 0.79 0.21 8071429
+ 0.14 0.79 0.21 15142857
+ 0.14 0.79 0.21 22214286
+ 0.14 0.79 0.21 29285714
+ 0.14 0.79 0.21 36357143
+ 0.14 0.79 0.21 43428571
+ 0.14 0.79 0.21 50500000
+ 0.14 0.79 0.21 57571429
+ 0.14 0.79 0.21 64642857
+ 0.14 0.79 0.21 71714286
+ 0.14 0.79 0.21 78785714
+ 0.14 0.79 0.21 85857143
+ 0.14 0.79 0.21 92928571
+ 0.14 0.79 0.21 100000000
+ 0.14 0.79 0.29 1000000
+ 0.14 0.79 0.29 8071429
+ 0.14 0.79 0.29 15142857
+ 0.14 0.79 0.29 22214286
+ 0.14 0.79 0.29 29285714
+ 0.14 0.79 0.29 36357143
+ 0.14 0.79 0.29 43428571
+ 0.14 0.79 0.29 50500000
+ 0.14 0.79 0.29 57571429
+ 0.14 0.79 0.29 64642857
+ 0.14 0.79 0.29 71714286
+ 0.14 0.79 0.29 78785714
+ 0.14 0.79 0.29 85857143
+ 0.14 0.79 0.29 92928571
+ 0.14 0.79 0.29 100000000
+ 0.14 0.79 0.36 1000000
+ 0.14 0.79 0.36 8071429
+ 0.14 0.79 0.36 15142857
+ 0.14 0.79 0.36 22214286
+ 0.14 0.79 0.36 29285714
+ 0.14 0.79 0.36 36357143
+ 0.14 0.79 0.36 43428571
+ 0.14 0.79 0.36 50500000
+ 0.14 0.79 0.36 57571429
+ 0.14 0.79 0.36 64642857
+ 0.14 0.79 0.36 71714286
+ 0.14 0.79 0.36 78785714
+ 0.14 0.79 0.36 85857143
+ 0.14 0.79 0.36 92928571
+ 0.14 0.79 0.36 100000000
+ 0.14 0.79 0.43 1000000
+ 0.14 0.79 0.43 8071429
+ 0.14 0.79 0.43 15142857
+ 0.14 0.79 0.43 22214286
+ 0.14 0.79 0.43 29285714
+ 0.14 0.79 0.43 36357143
+ 0.14 0.79 0.43 43428571
+ 0.14 0.79 0.43 50500000
+ 0.14 0.79 0.43 57571429
+ 0.14 0.79 0.43 64642857
+ 0.14 0.79 0.43 71714286
+ 0.14 0.79 0.43 78785714
+ 0.14 0.79 0.43 85857143
+ 0.14 0.79 0.43 92928571
+ 0.14 0.79 0.43 100000000
+ 0.14 0.79 0.50 1000000
+ 0.14 0.79 0.50 8071429
+ 0.14 0.79 0.50 15142857
+ 0.14 0.79 0.50 22214286
+ 0.14 0.79 0.50 29285714
+ 0.14 0.79 0.50 36357143
+ 0.14 0.79 0.50 43428571
+ 0.14 0.79 0.50 50500000
+ 0.14 0.79 0.50 57571429
+ 0.14 0.79 0.50 64642857
+ 0.14 0.79 0.50 71714286
+ 0.14 0.79 0.50 78785714
+ 0.14 0.79 0.50 85857143
+ 0.14 0.79 0.50 92928571
+ 0.14 0.79 0.50 100000000
+ 0.14 0.79 0.57 1000000
+ 0.14 0.79 0.57 8071429
+ 0.14 0.79 0.57 15142857
+ 0.14 0.79 0.57 22214286
+ 0.14 0.79 0.57 29285714
+ 0.14 0.79 0.57 36357143
+ 0.14 0.79 0.57 43428571
+ 0.14 0.79 0.57 50500000
+ 0.14 0.79 0.57 57571429
+ 0.14 0.79 0.57 64642857
+ 0.14 0.79 0.57 71714286
+ 0.14 0.79 0.57 78785714
+ 0.14 0.79 0.57 85857143
+ 0.14 0.79 0.57 92928571
+ 0.14 0.79 0.57 100000000
+ 0.14 0.79 0.64 1000000
+ 0.14 0.79 0.64 8071429
+ 0.14 0.79 0.64 15142857
+ 0.14 0.79 0.64 22214286
+ 0.14 0.79 0.64 29285714
+ 0.14 0.79 0.64 36357143
+ 0.14 0.79 0.64 43428571
+ 0.14 0.79 0.64 50500000
+ 0.14 0.79 0.64 57571429
+ 0.14 0.79 0.64 64642857
+ 0.14 0.79 0.64 71714286
+ 0.14 0.79 0.64 78785714
+ 0.14 0.79 0.64 85857143
+ 0.14 0.79 0.64 92928571
+ 0.14 0.79 0.64 100000000
+ 0.14 0.79 0.71 1000000
+ 0.14 0.79 0.71 8071429
+ 0.14 0.79 0.71 15142857
+ 0.14 0.79 0.71 22214286
+ 0.14 0.79 0.71 29285714
+ 0.14 0.79 0.71 36357143
+ 0.14 0.79 0.71 43428571
+ 0.14 0.79 0.71 50500000
+ 0.14 0.79 0.71 57571429
+ 0.14 0.79 0.71 64642857
+ 0.14 0.79 0.71 71714286
+ 0.14 0.79 0.71 78785714
+ 0.14 0.79 0.71 85857143
+ 0.14 0.79 0.71 92928571
+ 0.14 0.79 0.71 100000000
+ 0.14 0.79 0.79 1000000
+ 0.14 0.79 0.79 8071429
+ 0.14 0.79 0.79 15142857
+ 0.14 0.79 0.79 22214286
+ 0.14 0.79 0.79 29285714
+ 0.14 0.79 0.79 36357143
+ 0.14 0.79 0.79 43428571
+ 0.14 0.79 0.79 50500000
+ 0.14 0.79 0.79 57571429
+ 0.14 0.79 0.79 64642857
+ 0.14 0.79 0.79 71714286
+ 0.14 0.79 0.79 78785714
+ 0.14 0.79 0.79 85857143
+ 0.14 0.79 0.79 92928571
+ 0.14 0.79 0.79 100000000
+ 0.14 0.79 0.86 1000000
+ 0.14 0.79 0.86 8071429
+ 0.14 0.79 0.86 15142857
+ 0.14 0.79 0.86 22214286
+ 0.14 0.79 0.86 29285714
+ 0.14 0.79 0.86 36357143
+ 0.14 0.79 0.86 43428571
+ 0.14 0.79 0.86 50500000
+ 0.14 0.79 0.86 57571429
+ 0.14 0.79 0.86 64642857
+ 0.14 0.79 0.86 71714286
+ 0.14 0.79 0.86 78785714
+ 0.14 0.79 0.86 85857143
+ 0.14 0.79 0.86 92928571
+ 0.14 0.79 0.86 100000000
+ 0.14 0.79 0.93 1000000
+ 0.14 0.79 0.93 8071429
+ 0.14 0.79 0.93 15142857
+ 0.14 0.79 0.93 22214286
+ 0.14 0.79 0.93 29285714
+ 0.14 0.79 0.93 36357143
+ 0.14 0.79 0.93 43428571
+ 0.14 0.79 0.93 50500000
+ 0.14 0.79 0.93 57571429
+ 0.14 0.79 0.93 64642857
+ 0.14 0.79 0.93 71714286
+ 0.14 0.79 0.93 78785714
+ 0.14 0.79 0.93 85857143
+ 0.14 0.79 0.93 92928571
+ 0.14 0.79 0.93 100000000
+ 0.14 0.79 1.00 1000000
+ 0.14 0.79 1.00 8071429
+ 0.14 0.79 1.00 15142857
+ 0.14 0.79 1.00 22214286
+ 0.14 0.79 1.00 29285714
+ 0.14 0.79 1.00 36357143
+ 0.14 0.79 1.00 43428571
+ 0.14 0.79 1.00 50500000
+ 0.14 0.79 1.00 57571429
+ 0.14 0.79 1.00 64642857
+ 0.14 0.79 1.00 71714286
+ 0.14 0.79 1.00 78785714
+ 0.14 0.79 1.00 85857143
+ 0.14 0.79 1.00 92928571
+ 0.14 0.79 1.00 100000000
+ 0.14 0.86 0.00 1000000
+ 0.14 0.86 0.00 8071429
+ 0.14 0.86 0.00 15142857
+ 0.14 0.86 0.00 22214286
+ 0.14 0.86 0.00 29285714
+ 0.14 0.86 0.00 36357143
+ 0.14 0.86 0.00 43428571
+ 0.14 0.86 0.00 50500000
+ 0.14 0.86 0.00 57571429
+ 0.14 0.86 0.00 64642857
+ 0.14 0.86 0.00 71714286
+ 0.14 0.86 0.00 78785714
+ 0.14 0.86 0.00 85857143
+ 0.14 0.86 0.00 92928571
+ 0.14 0.86 0.00 100000000
+ 0.14 0.86 0.07 1000000
+ 0.14 0.86 0.07 8071429
+ 0.14 0.86 0.07 15142857
+ 0.14 0.86 0.07 22214286
+ 0.14 0.86 0.07 29285714
+ 0.14 0.86 0.07 36357143
+ 0.14 0.86 0.07 43428571
+ 0.14 0.86 0.07 50500000
+ 0.14 0.86 0.07 57571429
+ 0.14 0.86 0.07 64642857
+ 0.14 0.86 0.07 71714286
+ 0.14 0.86 0.07 78785714
+ 0.14 0.86 0.07 85857143
+ 0.14 0.86 0.07 92928571
+ 0.14 0.86 0.07 100000000
+ 0.14 0.86 0.14 1000000
+ 0.14 0.86 0.14 8071429
+ 0.14 0.86 0.14 15142857
+ 0.14 0.86 0.14 22214286
+ 0.14 0.86 0.14 29285714
+ 0.14 0.86 0.14 36357143
+ 0.14 0.86 0.14 43428571
+ 0.14 0.86 0.14 50500000
+ 0.14 0.86 0.14 57571429
+ 0.14 0.86 0.14 64642857
+ 0.14 0.86 0.14 71714286
+ 0.14 0.86 0.14 78785714
+ 0.14 0.86 0.14 85857143
+ 0.14 0.86 0.14 92928571
+ 0.14 0.86 0.14 100000000
+ 0.14 0.86 0.21 1000000
+ 0.14 0.86 0.21 8071429
+ 0.14 0.86 0.21 15142857
+ 0.14 0.86 0.21 22214286
+ 0.14 0.86 0.21 29285714
+ 0.14 0.86 0.21 36357143
+ 0.14 0.86 0.21 43428571
+ 0.14 0.86 0.21 50500000
+ 0.14 0.86 0.21 57571429
+ 0.14 0.86 0.21 64642857
+ 0.14 0.86 0.21 71714286
+ 0.14 0.86 0.21 78785714
+ 0.14 0.86 0.21 85857143
+ 0.14 0.86 0.21 92928571
+ 0.14 0.86 0.21 100000000
+ 0.14 0.86 0.29 1000000
+ 0.14 0.86 0.29 8071429
+ 0.14 0.86 0.29 15142857
+ 0.14 0.86 0.29 22214286
+ 0.14 0.86 0.29 29285714
+ 0.14 0.86 0.29 36357143
+ 0.14 0.86 0.29 43428571
+ 0.14 0.86 0.29 50500000
+ 0.14 0.86 0.29 57571429
+ 0.14 0.86 0.29 64642857
+ 0.14 0.86 0.29 71714286
+ 0.14 0.86 0.29 78785714
+ 0.14 0.86 0.29 85857143
+ 0.14 0.86 0.29 92928571
+ 0.14 0.86 0.29 100000000
+ 0.14 0.86 0.36 1000000
+ 0.14 0.86 0.36 8071429
+ 0.14 0.86 0.36 15142857
+ 0.14 0.86 0.36 22214286
+ 0.14 0.86 0.36 29285714
+ 0.14 0.86 0.36 36357143
+ 0.14 0.86 0.36 43428571
+ 0.14 0.86 0.36 50500000
+ 0.14 0.86 0.36 57571429
+ 0.14 0.86 0.36 64642857
+ 0.14 0.86 0.36 71714286
+ 0.14 0.86 0.36 78785714
+ 0.14 0.86 0.36 85857143
+ 0.14 0.86 0.36 92928571
+ 0.14 0.86 0.36 100000000
+ 0.14 0.86 0.43 1000000
+ 0.14 0.86 0.43 8071429
+ 0.14 0.86 0.43 15142857
+ 0.14 0.86 0.43 22214286
+ 0.14 0.86 0.43 29285714
+ 0.14 0.86 0.43 36357143
+ 0.14 0.86 0.43 43428571
+ 0.14 0.86 0.43 50500000
+ 0.14 0.86 0.43 57571429
+ 0.14 0.86 0.43 64642857
+ 0.14 0.86 0.43 71714286
+ 0.14 0.86 0.43 78785714
+ 0.14 0.86 0.43 85857143
+ 0.14 0.86 0.43 92928571
+ 0.14 0.86 0.43 100000000
+ 0.14 0.86 0.50 1000000
+ 0.14 0.86 0.50 8071429
+ 0.14 0.86 0.50 15142857
+ 0.14 0.86 0.50 22214286
+ 0.14 0.86 0.50 29285714
+ 0.14 0.86 0.50 36357143
+ 0.14 0.86 0.50 43428571
+ 0.14 0.86 0.50 50500000
+ 0.14 0.86 0.50 57571429
+ 0.14 0.86 0.50 64642857
+ 0.14 0.86 0.50 71714286
+ 0.14 0.86 0.50 78785714
+ 0.14 0.86 0.50 85857143
+ 0.14 0.86 0.50 92928571
+ 0.14 0.86 0.50 100000000
+ 0.14 0.86 0.57 1000000
+ 0.14 0.86 0.57 8071429
+ 0.14 0.86 0.57 15142857
+ 0.14 0.86 0.57 22214286
+ 0.14 0.86 0.57 29285714
+ 0.14 0.86 0.57 36357143
+ 0.14 0.86 0.57 43428571
+ 0.14 0.86 0.57 50500000
+ 0.14 0.86 0.57 57571429
+ 0.14 0.86 0.57 64642857
+ 0.14 0.86 0.57 71714286
+ 0.14 0.86 0.57 78785714
+ 0.14 0.86 0.57 85857143
+ 0.14 0.86 0.57 92928571
+ 0.14 0.86 0.57 100000000
+ 0.14 0.86 0.64 1000000
+ 0.14 0.86 0.64 8071429
+ 0.14 0.86 0.64 15142857
+ 0.14 0.86 0.64 22214286
+ 0.14 0.86 0.64 29285714
+ 0.14 0.86 0.64 36357143
+ 0.14 0.86 0.64 43428571
+ 0.14 0.86 0.64 50500000
+ 0.14 0.86 0.64 57571429
+ 0.14 0.86 0.64 64642857
+ 0.14 0.86 0.64 71714286
+ 0.14 0.86 0.64 78785714
+ 0.14 0.86 0.64 85857143
+ 0.14 0.86 0.64 92928571
+ 0.14 0.86 0.64 100000000
+ 0.14 0.86 0.71 1000000
+ 0.14 0.86 0.71 8071429
+ 0.14 0.86 0.71 15142857
+ 0.14 0.86 0.71 22214286
+ 0.14 0.86 0.71 29285714
+ 0.14 0.86 0.71 36357143
+ 0.14 0.86 0.71 43428571
+ 0.14 0.86 0.71 50500000
+ 0.14 0.86 0.71 57571429
+ 0.14 0.86 0.71 64642857
+ 0.14 0.86 0.71 71714286
+ 0.14 0.86 0.71 78785714
+ 0.14 0.86 0.71 85857143
+ 0.14 0.86 0.71 92928571
+ 0.14 0.86 0.71 100000000
+ 0.14 0.86 0.79 1000000
+ 0.14 0.86 0.79 8071429
+ 0.14 0.86 0.79 15142857
+ 0.14 0.86 0.79 22214286
+ 0.14 0.86 0.79 29285714
+ 0.14 0.86 0.79 36357143
+ 0.14 0.86 0.79 43428571
+ 0.14 0.86 0.79 50500000
+ 0.14 0.86 0.79 57571429
+ 0.14 0.86 0.79 64642857
+ 0.14 0.86 0.79 71714286
+ 0.14 0.86 0.79 78785714
+ 0.14 0.86 0.79 85857143
+ 0.14 0.86 0.79 92928571
+ 0.14 0.86 0.79 100000000
+ 0.14 0.86 0.86 1000000
+ 0.14 0.86 0.86 8071429
+ 0.14 0.86 0.86 15142857
+ 0.14 0.86 0.86 22214286
+ 0.14 0.86 0.86 29285714
+ 0.14 0.86 0.86 36357143
+ 0.14 0.86 0.86 43428571
+ 0.14 0.86 0.86 50500000
+ 0.14 0.86 0.86 57571429
+ 0.14 0.86 0.86 64642857
+ 0.14 0.86 0.86 71714286
+ 0.14 0.86 0.86 78785714
+ 0.14 0.86 0.86 85857143
+ 0.14 0.86 0.86 92928571
+ 0.14 0.86 0.86 100000000
+ 0.14 0.86 0.93 1000000
+ 0.14 0.86 0.93 8071429
+ 0.14 0.86 0.93 15142857
+ 0.14 0.86 0.93 22214286
+ 0.14 0.86 0.93 29285714
+ 0.14 0.86 0.93 36357143
+ 0.14 0.86 0.93 43428571
+ 0.14 0.86 0.93 50500000
+ 0.14 0.86 0.93 57571429
+ 0.14 0.86 0.93 64642857
+ 0.14 0.86 0.93 71714286
+ 0.14 0.86 0.93 78785714
+ 0.14 0.86 0.93 85857143
+ 0.14 0.86 0.93 92928571
+ 0.14 0.86 0.93 100000000
+ 0.14 0.86 1.00 1000000
+ 0.14 0.86 1.00 8071429
+ 0.14 0.86 1.00 15142857
+ 0.14 0.86 1.00 22214286
+ 0.14 0.86 1.00 29285714
+ 0.14 0.86 1.00 36357143
+ 0.14 0.86 1.00 43428571
+ 0.14 0.86 1.00 50500000
+ 0.14 0.86 1.00 57571429
+ 0.14 0.86 1.00 64642857
+ 0.14 0.86 1.00 71714286
+ 0.14 0.86 1.00 78785714
+ 0.14 0.86 1.00 85857143
+ 0.14 0.86 1.00 92928571
+ 0.14 0.86 1.00 100000000
+ 0.14 0.93 0.00 1000000
+ 0.14 0.93 0.00 8071429
+ 0.14 0.93 0.00 15142857
+ 0.14 0.93 0.00 22214286
+ 0.14 0.93 0.00 29285714
+ 0.14 0.93 0.00 36357143
+ 0.14 0.93 0.00 43428571
+ 0.14 0.93 0.00 50500000
+ 0.14 0.93 0.00 57571429
+ 0.14 0.93 0.00 64642857
+ 0.14 0.93 0.00 71714286
+ 0.14 0.93 0.00 78785714
+ 0.14 0.93 0.00 85857143
+ 0.14 0.93 0.00 92928571
+ 0.14 0.93 0.00 100000000
+ 0.14 0.93 0.07 1000000
+ 0.14 0.93 0.07 8071429
+ 0.14 0.93 0.07 15142857
+ 0.14 0.93 0.07 22214286
+ 0.14 0.93 0.07 29285714
+ 0.14 0.93 0.07 36357143
+ 0.14 0.93 0.07 43428571
+ 0.14 0.93 0.07 50500000
+ 0.14 0.93 0.07 57571429
+ 0.14 0.93 0.07 64642857
+ 0.14 0.93 0.07 71714286
+ 0.14 0.93 0.07 78785714
+ 0.14 0.93 0.07 85857143
+ 0.14 0.93 0.07 92928571
+ 0.14 0.93 0.07 100000000
+ 0.14 0.93 0.14 1000000
+ 0.14 0.93 0.14 8071429
+ 0.14 0.93 0.14 15142857
+ 0.14 0.93 0.14 22214286
+ 0.14 0.93 0.14 29285714
+ 0.14 0.93 0.14 36357143
+ 0.14 0.93 0.14 43428571
+ 0.14 0.93 0.14 50500000
+ 0.14 0.93 0.14 57571429
+ 0.14 0.93 0.14 64642857
+ 0.14 0.93 0.14 71714286
+ 0.14 0.93 0.14 78785714
+ 0.14 0.93 0.14 85857143
+ 0.14 0.93 0.14 92928571
+ 0.14 0.93 0.14 100000000
+ 0.14 0.93 0.21 1000000
+ 0.14 0.93 0.21 8071429
+ 0.14 0.93 0.21 15142857
+ 0.14 0.93 0.21 22214286
+ 0.14 0.93 0.21 29285714
+ 0.14 0.93 0.21 36357143
+ 0.14 0.93 0.21 43428571
+ 0.14 0.93 0.21 50500000
+ 0.14 0.93 0.21 57571429
+ 0.14 0.93 0.21 64642857
+ 0.14 0.93 0.21 71714286
+ 0.14 0.93 0.21 78785714
+ 0.14 0.93 0.21 85857143
+ 0.14 0.93 0.21 92928571
+ 0.14 0.93 0.21 100000000
+ 0.14 0.93 0.29 1000000
+ 0.14 0.93 0.29 8071429
+ 0.14 0.93 0.29 15142857
+ 0.14 0.93 0.29 22214286
+ 0.14 0.93 0.29 29285714
+ 0.14 0.93 0.29 36357143
+ 0.14 0.93 0.29 43428571
+ 0.14 0.93 0.29 50500000
+ 0.14 0.93 0.29 57571429
+ 0.14 0.93 0.29 64642857
+ 0.14 0.93 0.29 71714286
+ 0.14 0.93 0.29 78785714
+ 0.14 0.93 0.29 85857143
+ 0.14 0.93 0.29 92928571
+ 0.14 0.93 0.29 100000000
+ 0.14 0.93 0.36 1000000
+ 0.14 0.93 0.36 8071429
+ 0.14 0.93 0.36 15142857
+ 0.14 0.93 0.36 22214286
+ 0.14 0.93 0.36 29285714
+ 0.14 0.93 0.36 36357143
+ 0.14 0.93 0.36 43428571
+ 0.14 0.93 0.36 50500000
+ 0.14 0.93 0.36 57571429
+ 0.14 0.93 0.36 64642857
+ 0.14 0.93 0.36 71714286
+ 0.14 0.93 0.36 78785714
+ 0.14 0.93 0.36 85857143
+ 0.14 0.93 0.36 92928571
+ 0.14 0.93 0.36 100000000
+ 0.14 0.93 0.43 1000000
+ 0.14 0.93 0.43 8071429
+ 0.14 0.93 0.43 15142857
+ 0.14 0.93 0.43 22214286
+ 0.14 0.93 0.43 29285714
+ 0.14 0.93 0.43 36357143
+ 0.14 0.93 0.43 43428571
+ 0.14 0.93 0.43 50500000
+ 0.14 0.93 0.43 57571429
+ 0.14 0.93 0.43 64642857
+ 0.14 0.93 0.43 71714286
+ 0.14 0.93 0.43 78785714
+ 0.14 0.93 0.43 85857143
+ 0.14 0.93 0.43 92928571
+ 0.14 0.93 0.43 100000000
+ 0.14 0.93 0.50 1000000
+ 0.14 0.93 0.50 8071429
+ 0.14 0.93 0.50 15142857
+ 0.14 0.93 0.50 22214286
+ 0.14 0.93 0.50 29285714
+ 0.14 0.93 0.50 36357143
+ 0.14 0.93 0.50 43428571
+ 0.14 0.93 0.50 50500000
+ 0.14 0.93 0.50 57571429
+ 0.14 0.93 0.50 64642857
+ 0.14 0.93 0.50 71714286
+ 0.14 0.93 0.50 78785714
+ 0.14 0.93 0.50 85857143
+ 0.14 0.93 0.50 92928571
+ 0.14 0.93 0.50 100000000
+ 0.14 0.93 0.57 1000000
+ 0.14 0.93 0.57 8071429
+ 0.14 0.93 0.57 15142857
+ 0.14 0.93 0.57 22214286
+ 0.14 0.93 0.57 29285714
+ 0.14 0.93 0.57 36357143
+ 0.14 0.93 0.57 43428571
+ 0.14 0.93 0.57 50500000
+ 0.14 0.93 0.57 57571429
+ 0.14 0.93 0.57 64642857
+ 0.14 0.93 0.57 71714286
+ 0.14 0.93 0.57 78785714
+ 0.14 0.93 0.57 85857143
+ 0.14 0.93 0.57 92928571
+ 0.14 0.93 0.57 100000000
+ 0.14 0.93 0.64 1000000
+ 0.14 0.93 0.64 8071429
+ 0.14 0.93 0.64 15142857
+ 0.14 0.93 0.64 22214286
+ 0.14 0.93 0.64 29285714
+ 0.14 0.93 0.64 36357143
+ 0.14 0.93 0.64 43428571
+ 0.14 0.93 0.64 50500000
+ 0.14 0.93 0.64 57571429
+ 0.14 0.93 0.64 64642857
+ 0.14 0.93 0.64 71714286
+ 0.14 0.93 0.64 78785714
+ 0.14 0.93 0.64 85857143
+ 0.14 0.93 0.64 92928571
+ 0.14 0.93 0.64 100000000
+ 0.14 0.93 0.71 1000000
+ 0.14 0.93 0.71 8071429
+ 0.14 0.93 0.71 15142857
+ 0.14 0.93 0.71 22214286
+ 0.14 0.93 0.71 29285714
+ 0.14 0.93 0.71 36357143
+ 0.14 0.93 0.71 43428571
+ 0.14 0.93 0.71 50500000
+ 0.14 0.93 0.71 57571429
+ 0.14 0.93 0.71 64642857
+ 0.14 0.93 0.71 71714286
+ 0.14 0.93 0.71 78785714
+ 0.14 0.93 0.71 85857143
+ 0.14 0.93 0.71 92928571
+ 0.14 0.93 0.71 100000000
+ 0.14 0.93 0.79 1000000
+ 0.14 0.93 0.79 8071429
+ 0.14 0.93 0.79 15142857
+ 0.14 0.93 0.79 22214286
+ 0.14 0.93 0.79 29285714
+ 0.14 0.93 0.79 36357143
+ 0.14 0.93 0.79 43428571
+ 0.14 0.93 0.79 50500000
+ 0.14 0.93 0.79 57571429
+ 0.14 0.93 0.79 64642857
+ 0.14 0.93 0.79 71714286
+ 0.14 0.93 0.79 78785714
+ 0.14 0.93 0.79 85857143
+ 0.14 0.93 0.79 92928571
+ 0.14 0.93 0.79 100000000
+ 0.14 0.93 0.86 1000000
+ 0.14 0.93 0.86 8071429
+ 0.14 0.93 0.86 15142857
+ 0.14 0.93 0.86 22214286
+ 0.14 0.93 0.86 29285714
+ 0.14 0.93 0.86 36357143
+ 0.14 0.93 0.86 43428571
+ 0.14 0.93 0.86 50500000
+ 0.14 0.93 0.86 57571429
+ 0.14 0.93 0.86 64642857
+ 0.14 0.93 0.86 71714286
+ 0.14 0.93 0.86 78785714
+ 0.14 0.93 0.86 85857143
+ 0.14 0.93 0.86 92928571
+ 0.14 0.93 0.86 100000000
+ 0.14 0.93 0.93 1000000
+ 0.14 0.93 0.93 8071429
+ 0.14 0.93 0.93 15142857
+ 0.14 0.93 0.93 22214286
+ 0.14 0.93 0.93 29285714
+ 0.14 0.93 0.93 36357143
+ 0.14 0.93 0.93 43428571
+ 0.14 0.93 0.93 50500000
+ 0.14 0.93 0.93 57571429
+ 0.14 0.93 0.93 64642857
+ 0.14 0.93 0.93 71714286
+ 0.14 0.93 0.93 78785714
+ 0.14 0.93 0.93 85857143
+ 0.14 0.93 0.93 92928571
+ 0.14 0.93 0.93 100000000
+ 0.14 0.93 1.00 1000000
+ 0.14 0.93 1.00 8071429
+ 0.14 0.93 1.00 15142857
+ 0.14 0.93 1.00 22214286
+ 0.14 0.93 1.00 29285714
+ 0.14 0.93 1.00 36357143
+ 0.14 0.93 1.00 43428571
+ 0.14 0.93 1.00 50500000
+ 0.14 0.93 1.00 57571429
+ 0.14 0.93 1.00 64642857
+ 0.14 0.93 1.00 71714286
+ 0.14 0.93 1.00 78785714
+ 0.14 0.93 1.00 85857143
+ 0.14 0.93 1.00 92928571
+ 0.14 0.93 1.00 100000000
+ 0.14 1.00 0.00 1000000
+ 0.14 1.00 0.00 8071429
+ 0.14 1.00 0.00 15142857
+ 0.14 1.00 0.00 22214286
+ 0.14 1.00 0.00 29285714
+ 0.14 1.00 0.00 36357143
+ 0.14 1.00 0.00 43428571
+ 0.14 1.00 0.00 50500000
+ 0.14 1.00 0.00 57571429
+ 0.14 1.00 0.00 64642857
+ 0.14 1.00 0.00 71714286
+ 0.14 1.00 0.00 78785714
+ 0.14 1.00 0.00 85857143
+ 0.14 1.00 0.00 92928571
+ 0.14 1.00 0.00 100000000
+ 0.14 1.00 0.07 1000000
+ 0.14 1.00 0.07 8071429
+ 0.14 1.00 0.07 15142857
+ 0.14 1.00 0.07 22214286
+ 0.14 1.00 0.07 29285714
+ 0.14 1.00 0.07 36357143
+ 0.14 1.00 0.07 43428571
+ 0.14 1.00 0.07 50500000
+ 0.14 1.00 0.07 57571429
+ 0.14 1.00 0.07 64642857
+ 0.14 1.00 0.07 71714286
+ 0.14 1.00 0.07 78785714
+ 0.14 1.00 0.07 85857143
+ 0.14 1.00 0.07 92928571
+ 0.14 1.00 0.07 100000000
+ 0.14 1.00 0.14 1000000
+ 0.14 1.00 0.14 8071429
+ 0.14 1.00 0.14 15142857
+ 0.14 1.00 0.14 22214286
+ 0.14 1.00 0.14 29285714
+ 0.14 1.00 0.14 36357143
+ 0.14 1.00 0.14 43428571
+ 0.14 1.00 0.14 50500000
+ 0.14 1.00 0.14 57571429
+ 0.14 1.00 0.14 64642857
+ 0.14 1.00 0.14 71714286
+ 0.14 1.00 0.14 78785714
+ 0.14 1.00 0.14 85857143
+ 0.14 1.00 0.14 92928571
+ 0.14 1.00 0.14 100000000
+ 0.14 1.00 0.21 1000000
+ 0.14 1.00 0.21 8071429
+ 0.14 1.00 0.21 15142857
+ 0.14 1.00 0.21 22214286
+ 0.14 1.00 0.21 29285714
+ 0.14 1.00 0.21 36357143
+ 0.14 1.00 0.21 43428571
+ 0.14 1.00 0.21 50500000
+ 0.14 1.00 0.21 57571429
+ 0.14 1.00 0.21 64642857
+ 0.14 1.00 0.21 71714286
+ 0.14 1.00 0.21 78785714
+ 0.14 1.00 0.21 85857143
+ 0.14 1.00 0.21 92928571
+ 0.14 1.00 0.21 100000000
+ 0.14 1.00 0.29 1000000
+ 0.14 1.00 0.29 8071429
+ 0.14 1.00 0.29 15142857
+ 0.14 1.00 0.29 22214286
+ 0.14 1.00 0.29 29285714
+ 0.14 1.00 0.29 36357143
+ 0.14 1.00 0.29 43428571
+ 0.14 1.00 0.29 50500000
+ 0.14 1.00 0.29 57571429
+ 0.14 1.00 0.29 64642857
+ 0.14 1.00 0.29 71714286
+ 0.14 1.00 0.29 78785714
+ 0.14 1.00 0.29 85857143
+ 0.14 1.00 0.29 92928571
+ 0.14 1.00 0.29 100000000
+ 0.14 1.00 0.36 1000000
+ 0.14 1.00 0.36 8071429
+ 0.14 1.00 0.36 15142857
+ 0.14 1.00 0.36 22214286
+ 0.14 1.00 0.36 29285714
+ 0.14 1.00 0.36 36357143
+ 0.14 1.00 0.36 43428571
+ 0.14 1.00 0.36 50500000
+ 0.14 1.00 0.36 57571429
+ 0.14 1.00 0.36 64642857
+ 0.14 1.00 0.36 71714286
+ 0.14 1.00 0.36 78785714
+ 0.14 1.00 0.36 85857143
+ 0.14 1.00 0.36 92928571
+ 0.14 1.00 0.36 100000000
+ 0.14 1.00 0.43 1000000
+ 0.14 1.00 0.43 8071429
+ 0.14 1.00 0.43 15142857
+ 0.14 1.00 0.43 22214286
+ 0.14 1.00 0.43 29285714
+ 0.14 1.00 0.43 36357143
+ 0.14 1.00 0.43 43428571
+ 0.14 1.00 0.43 50500000
+ 0.14 1.00 0.43 57571429
+ 0.14 1.00 0.43 64642857
+ 0.14 1.00 0.43 71714286
+ 0.14 1.00 0.43 78785714
+ 0.14 1.00 0.43 85857143
+ 0.14 1.00 0.43 92928571
+ 0.14 1.00 0.43 100000000
+ 0.14 1.00 0.50 1000000
+ 0.14 1.00 0.50 8071429
+ 0.14 1.00 0.50 15142857
+ 0.14 1.00 0.50 22214286
+ 0.14 1.00 0.50 29285714
+ 0.14 1.00 0.50 36357143
+ 0.14 1.00 0.50 43428571
+ 0.14 1.00 0.50 50500000
+ 0.14 1.00 0.50 57571429
+ 0.14 1.00 0.50 64642857
+ 0.14 1.00 0.50 71714286
+ 0.14 1.00 0.50 78785714
+ 0.14 1.00 0.50 85857143
+ 0.14 1.00 0.50 92928571
+ 0.14 1.00 0.50 100000000
+ 0.14 1.00 0.57 1000000
+ 0.14 1.00 0.57 8071429
+ 0.14 1.00 0.57 15142857
+ 0.14 1.00 0.57 22214286
+ 0.14 1.00 0.57 29285714
+ 0.14 1.00 0.57 36357143
+ 0.14 1.00 0.57 43428571
+ 0.14 1.00 0.57 50500000
+ 0.14 1.00 0.57 57571429
+ 0.14 1.00 0.57 64642857
+ 0.14 1.00 0.57 71714286
+ 0.14 1.00 0.57 78785714
+ 0.14 1.00 0.57 85857143
+ 0.14 1.00 0.57 92928571
+ 0.14 1.00 0.57 100000000
+ 0.14 1.00 0.64 1000000
+ 0.14 1.00 0.64 8071429
+ 0.14 1.00 0.64 15142857
+ 0.14 1.00 0.64 22214286
+ 0.14 1.00 0.64 29285714
+ 0.14 1.00 0.64 36357143
+ 0.14 1.00 0.64 43428571
+ 0.14 1.00 0.64 50500000
+ 0.14 1.00 0.64 57571429
+ 0.14 1.00 0.64 64642857
+ 0.14 1.00 0.64 71714286
+ 0.14 1.00 0.64 78785714
+ 0.14 1.00 0.64 85857143
+ 0.14 1.00 0.64 92928571
+ 0.14 1.00 0.64 100000000
+ 0.14 1.00 0.71 1000000
+ 0.14 1.00 0.71 8071429
+ 0.14 1.00 0.71 15142857
+ 0.14 1.00 0.71 22214286
+ 0.14 1.00 0.71 29285714
+ 0.14 1.00 0.71 36357143
+ 0.14 1.00 0.71 43428571
+ 0.14 1.00 0.71 50500000
+ 0.14 1.00 0.71 57571429
+ 0.14 1.00 0.71 64642857
+ 0.14 1.00 0.71 71714286
+ 0.14 1.00 0.71 78785714
+ 0.14 1.00 0.71 85857143
+ 0.14 1.00 0.71 92928571
+ 0.14 1.00 0.71 100000000
+ 0.14 1.00 0.79 1000000
+ 0.14 1.00 0.79 8071429
+ 0.14 1.00 0.79 15142857
+ 0.14 1.00 0.79 22214286
+ 0.14 1.00 0.79 29285714
+ 0.14 1.00 0.79 36357143
+ 0.14 1.00 0.79 43428571
+ 0.14 1.00 0.79 50500000
+ 0.14 1.00 0.79 57571429
+ 0.14 1.00 0.79 64642857
+ 0.14 1.00 0.79 71714286
+ 0.14 1.00 0.79 78785714
+ 0.14 1.00 0.79 85857143
+ 0.14 1.00 0.79 92928571
+ 0.14 1.00 0.79 100000000
+ 0.14 1.00 0.86 1000000
+ 0.14 1.00 0.86 8071429
+ 0.14 1.00 0.86 15142857
+ 0.14 1.00 0.86 22214286
+ 0.14 1.00 0.86 29285714
+ 0.14 1.00 0.86 36357143
+ 0.14 1.00 0.86 43428571
+ 0.14 1.00 0.86 50500000
+ 0.14 1.00 0.86 57571429
+ 0.14 1.00 0.86 64642857
+ 0.14 1.00 0.86 71714286
+ 0.14 1.00 0.86 78785714
+ 0.14 1.00 0.86 85857143
+ 0.14 1.00 0.86 92928571
+ 0.14 1.00 0.86 100000000
+ 0.14 1.00 0.93 1000000
+ 0.14 1.00 0.93 8071429
+ 0.14 1.00 0.93 15142857
+ 0.14 1.00 0.93 22214286
+ 0.14 1.00 0.93 29285714
+ 0.14 1.00 0.93 36357143
+ 0.14 1.00 0.93 43428571
+ 0.14 1.00 0.93 50500000
+ 0.14 1.00 0.93 57571429
+ 0.14 1.00 0.93 64642857
+ 0.14 1.00 0.93 71714286
+ 0.14 1.00 0.93 78785714
+ 0.14 1.00 0.93 85857143
+ 0.14 1.00 0.93 92928571
+ 0.14 1.00 0.93 100000000
+ 0.14 1.00 1.00 1000000
+ 0.14 1.00 1.00 8071429
+ 0.14 1.00 1.00 15142857
+ 0.14 1.00 1.00 22214286
+ 0.14 1.00 1.00 29285714
+ 0.14 1.00 1.00 36357143
+ 0.14 1.00 1.00 43428571
+ 0.14 1.00 1.00 50500000
+ 0.14 1.00 1.00 57571429
+ 0.14 1.00 1.00 64642857
+ 0.14 1.00 1.00 71714286
+ 0.14 1.00 1.00 78785714
+ 0.14 1.00 1.00 85857143
+ 0.14 1.00 1.00 92928571
+ 0.14 1.00 1.00 100000000
+ 0.21 0.00 0.00 1000000
+ 0.21 0.00 0.00 8071429
+ 0.21 0.00 0.00 15142857
+ 0.21 0.00 0.00 22214286
+ 0.21 0.00 0.00 29285714
+ 0.21 0.00 0.00 36357143
+ 0.21 0.00 0.00 43428571
+ 0.21 0.00 0.00 50500000
+ 0.21 0.00 0.00 57571429
+ 0.21 0.00 0.00 64642857
+ 0.21 0.00 0.00 71714286
+ 0.21 0.00 0.00 78785714
+ 0.21 0.00 0.00 85857143
+ 0.21 0.00 0.00 92928571
+ 0.21 0.00 0.00 100000000
+ 0.21 0.00 0.07 1000000
+ 0.21 0.00 0.07 8071429
+ 0.21 0.00 0.07 15142857
+ 0.21 0.00 0.07 22214286
+ 0.21 0.00 0.07 29285714
+ 0.21 0.00 0.07 36357143
+ 0.21 0.00 0.07 43428571
+ 0.21 0.00 0.07 50500000
+ 0.21 0.00 0.07 57571429
+ 0.21 0.00 0.07 64642857
+ 0.21 0.00 0.07 71714286
+ 0.21 0.00 0.07 78785714
+ 0.21 0.00 0.07 85857143
+ 0.21 0.00 0.07 92928571
+ 0.21 0.00 0.07 100000000
+ 0.21 0.00 0.14 1000000
+ 0.21 0.00 0.14 8071429
+ 0.21 0.00 0.14 15142857
+ 0.21 0.00 0.14 22214286
+ 0.21 0.00 0.14 29285714
+ 0.21 0.00 0.14 36357143
+ 0.21 0.00 0.14 43428571
+ 0.21 0.00 0.14 50500000
+ 0.21 0.00 0.14 57571429
+ 0.21 0.00 0.14 64642857
+ 0.21 0.00 0.14 71714286
+ 0.21 0.00 0.14 78785714
+ 0.21 0.00 0.14 85857143
+ 0.21 0.00 0.14 92928571
+ 0.21 0.00 0.14 100000000
+ 0.21 0.00 0.21 1000000
+ 0.21 0.00 0.21 8071429
+ 0.21 0.00 0.21 15142857
+ 0.21 0.00 0.21 22214286
+ 0.21 0.00 0.21 29285714
+ 0.21 0.00 0.21 36357143
+ 0.21 0.00 0.21 43428571
+ 0.21 0.00 0.21 50500000
+ 0.21 0.00 0.21 57571429
+ 0.21 0.00 0.21 64642857
+ 0.21 0.00 0.21 71714286
+ 0.21 0.00 0.21 78785714
+ 0.21 0.00 0.21 85857143
+ 0.21 0.00 0.21 92928571
+ 0.21 0.00 0.21 100000000
+ 0.21 0.00 0.29 1000000
+ 0.21 0.00 0.29 8071429
+ 0.21 0.00 0.29 15142857
+ 0.21 0.00 0.29 22214286
+ 0.21 0.00 0.29 29285714
+ 0.21 0.00 0.29 36357143
+ 0.21 0.00 0.29 43428571
+ 0.21 0.00 0.29 50500000
+ 0.21 0.00 0.29 57571429
+ 0.21 0.00 0.29 64642857
+ 0.21 0.00 0.29 71714286
+ 0.21 0.00 0.29 78785714
+ 0.21 0.00 0.29 85857143
+ 0.21 0.00 0.29 92928571
+ 0.21 0.00 0.29 100000000
+ 0.21 0.00 0.36 1000000
+ 0.21 0.00 0.36 8071429
+ 0.21 0.00 0.36 15142857
+ 0.21 0.00 0.36 22214286
+ 0.21 0.00 0.36 29285714
+ 0.21 0.00 0.36 36357143
+ 0.21 0.00 0.36 43428571
+ 0.21 0.00 0.36 50500000
+ 0.21 0.00 0.36 57571429
+ 0.21 0.00 0.36 64642857
+ 0.21 0.00 0.36 71714286
+ 0.21 0.00 0.36 78785714
+ 0.21 0.00 0.36 85857143
+ 0.21 0.00 0.36 92928571
+ 0.21 0.00 0.36 100000000
+ 0.21 0.00 0.43 1000000
+ 0.21 0.00 0.43 8071429
+ 0.21 0.00 0.43 15142857
+ 0.21 0.00 0.43 22214286
+ 0.21 0.00 0.43 29285714
+ 0.21 0.00 0.43 36357143
+ 0.21 0.00 0.43 43428571
+ 0.21 0.00 0.43 50500000
+ 0.21 0.00 0.43 57571429
+ 0.21 0.00 0.43 64642857
+ 0.21 0.00 0.43 71714286
+ 0.21 0.00 0.43 78785714
+ 0.21 0.00 0.43 85857143
+ 0.21 0.00 0.43 92928571
+ 0.21 0.00 0.43 100000000
+ 0.21 0.00 0.50 1000000
+ 0.21 0.00 0.50 8071429
+ 0.21 0.00 0.50 15142857
+ 0.21 0.00 0.50 22214286
+ 0.21 0.00 0.50 29285714
+ 0.21 0.00 0.50 36357143
+ 0.21 0.00 0.50 43428571
+ 0.21 0.00 0.50 50500000
+ 0.21 0.00 0.50 57571429
+ 0.21 0.00 0.50 64642857
+ 0.21 0.00 0.50 71714286
+ 0.21 0.00 0.50 78785714
+ 0.21 0.00 0.50 85857143
+ 0.21 0.00 0.50 92928571
+ 0.21 0.00 0.50 100000000
+ 0.21 0.00 0.57 1000000
+ 0.21 0.00 0.57 8071429
+ 0.21 0.00 0.57 15142857
+ 0.21 0.00 0.57 22214286
+ 0.21 0.00 0.57 29285714
+ 0.21 0.00 0.57 36357143
+ 0.21 0.00 0.57 43428571
+ 0.21 0.00 0.57 50500000
+ 0.21 0.00 0.57 57571429
+ 0.21 0.00 0.57 64642857
+ 0.21 0.00 0.57 71714286
+ 0.21 0.00 0.57 78785714
+ 0.21 0.00 0.57 85857143
+ 0.21 0.00 0.57 92928571
+ 0.21 0.00 0.57 100000000
+ 0.21 0.00 0.64 1000000
+ 0.21 0.00 0.64 8071429
+ 0.21 0.00 0.64 15142857
+ 0.21 0.00 0.64 22214286
+ 0.21 0.00 0.64 29285714
+ 0.21 0.00 0.64 36357143
+ 0.21 0.00 0.64 43428571
+ 0.21 0.00 0.64 50500000
+ 0.21 0.00 0.64 57571429
+ 0.21 0.00 0.64 64642857
+ 0.21 0.00 0.64 71714286
+ 0.21 0.00 0.64 78785714
+ 0.21 0.00 0.64 85857143
+ 0.21 0.00 0.64 92928571
+ 0.21 0.00 0.64 100000000
+ 0.21 0.00 0.71 1000000
+ 0.21 0.00 0.71 8071429
+ 0.21 0.00 0.71 15142857
+ 0.21 0.00 0.71 22214286
+ 0.21 0.00 0.71 29285714
+ 0.21 0.00 0.71 36357143
+ 0.21 0.00 0.71 43428571
+ 0.21 0.00 0.71 50500000
+ 0.21 0.00 0.71 57571429
+ 0.21 0.00 0.71 64642857
+ 0.21 0.00 0.71 71714286
+ 0.21 0.00 0.71 78785714
+ 0.21 0.00 0.71 85857143
+ 0.21 0.00 0.71 92928571
+ 0.21 0.00 0.71 100000000
+ 0.21 0.00 0.79 1000000
+ 0.21 0.00 0.79 8071429
+ 0.21 0.00 0.79 15142857
+ 0.21 0.00 0.79 22214286
+ 0.21 0.00 0.79 29285714
+ 0.21 0.00 0.79 36357143
+ 0.21 0.00 0.79 43428571
+ 0.21 0.00 0.79 50500000
+ 0.21 0.00 0.79 57571429
+ 0.21 0.00 0.79 64642857
+ 0.21 0.00 0.79 71714286
+ 0.21 0.00 0.79 78785714
+ 0.21 0.00 0.79 85857143
+ 0.21 0.00 0.79 92928571
+ 0.21 0.00 0.79 100000000
+ 0.21 0.00 0.86 1000000
+ 0.21 0.00 0.86 8071429
+ 0.21 0.00 0.86 15142857
+ 0.21 0.00 0.86 22214286
+ 0.21 0.00 0.86 29285714
+ 0.21 0.00 0.86 36357143
+ 0.21 0.00 0.86 43428571
+ 0.21 0.00 0.86 50500000
+ 0.21 0.00 0.86 57571429
+ 0.21 0.00 0.86 64642857
+ 0.21 0.00 0.86 71714286
+ 0.21 0.00 0.86 78785714
+ 0.21 0.00 0.86 85857143
+ 0.21 0.00 0.86 92928571
+ 0.21 0.00 0.86 100000000
+ 0.21 0.00 0.93 1000000
+ 0.21 0.00 0.93 8071429
+ 0.21 0.00 0.93 15142857
+ 0.21 0.00 0.93 22214286
+ 0.21 0.00 0.93 29285714
+ 0.21 0.00 0.93 36357143
+ 0.21 0.00 0.93 43428571
+ 0.21 0.00 0.93 50500000
+ 0.21 0.00 0.93 57571429
+ 0.21 0.00 0.93 64642857
+ 0.21 0.00 0.93 71714286
+ 0.21 0.00 0.93 78785714
+ 0.21 0.00 0.93 85857143
+ 0.21 0.00 0.93 92928571
+ 0.21 0.00 0.93 100000000
+ 0.21 0.00 1.00 1000000
+ 0.21 0.00 1.00 8071429
+ 0.21 0.00 1.00 15142857
+ 0.21 0.00 1.00 22214286
+ 0.21 0.00 1.00 29285714
+ 0.21 0.00 1.00 36357143
+ 0.21 0.00 1.00 43428571
+ 0.21 0.00 1.00 50500000
+ 0.21 0.00 1.00 57571429
+ 0.21 0.00 1.00 64642857
+ 0.21 0.00 1.00 71714286
+ 0.21 0.00 1.00 78785714
+ 0.21 0.00 1.00 85857143
+ 0.21 0.00 1.00 92928571
+ 0.21 0.00 1.00 100000000
+ 0.21 0.07 0.00 1000000
+ 0.21 0.07 0.00 8071429
+ 0.21 0.07 0.00 15142857
+ 0.21 0.07 0.00 22214286
+ 0.21 0.07 0.00 29285714
+ 0.21 0.07 0.00 36357143
+ 0.21 0.07 0.00 43428571
+ 0.21 0.07 0.00 50500000
+ 0.21 0.07 0.00 57571429
+ 0.21 0.07 0.00 64642857
+ 0.21 0.07 0.00 71714286
+ 0.21 0.07 0.00 78785714
+ 0.21 0.07 0.00 85857143
+ 0.21 0.07 0.00 92928571
+ 0.21 0.07 0.00 100000000
+ 0.21 0.07 0.07 1000000
+ 0.21 0.07 0.07 8071429
+ 0.21 0.07 0.07 15142857
+ 0.21 0.07 0.07 22214286
+ 0.21 0.07 0.07 29285714
+ 0.21 0.07 0.07 36357143
+ 0.21 0.07 0.07 43428571
+ 0.21 0.07 0.07 50500000
+ 0.21 0.07 0.07 57571429
+ 0.21 0.07 0.07 64642857
+ 0.21 0.07 0.07 71714286
+ 0.21 0.07 0.07 78785714
+ 0.21 0.07 0.07 85857143
+ 0.21 0.07 0.07 92928571
+ 0.21 0.07 0.07 100000000
+ 0.21 0.07 0.14 1000000
+ 0.21 0.07 0.14 8071429
+ 0.21 0.07 0.14 15142857
+ 0.21 0.07 0.14 22214286
+ 0.21 0.07 0.14 29285714
+ 0.21 0.07 0.14 36357143
+ 0.21 0.07 0.14 43428571
+ 0.21 0.07 0.14 50500000
+ 0.21 0.07 0.14 57571429
+ 0.21 0.07 0.14 64642857
+ 0.21 0.07 0.14 71714286
+ 0.21 0.07 0.14 78785714
+ 0.21 0.07 0.14 85857143
+ 0.21 0.07 0.14 92928571
+ 0.21 0.07 0.14 100000000
+ 0.21 0.07 0.21 1000000
+ 0.21 0.07 0.21 8071429
+ 0.21 0.07 0.21 15142857
+ 0.21 0.07 0.21 22214286
+ 0.21 0.07 0.21 29285714
+ 0.21 0.07 0.21 36357143
+ 0.21 0.07 0.21 43428571
+ 0.21 0.07 0.21 50500000
+ 0.21 0.07 0.21 57571429
+ 0.21 0.07 0.21 64642857
+ 0.21 0.07 0.21 71714286
+ 0.21 0.07 0.21 78785714
+ 0.21 0.07 0.21 85857143
+ 0.21 0.07 0.21 92928571
+ 0.21 0.07 0.21 100000000
+ 0.21 0.07 0.29 1000000
+ 0.21 0.07 0.29 8071429
+ 0.21 0.07 0.29 15142857
+ 0.21 0.07 0.29 22214286
+ 0.21 0.07 0.29 29285714
+ 0.21 0.07 0.29 36357143
+ 0.21 0.07 0.29 43428571
+ 0.21 0.07 0.29 50500000
+ 0.21 0.07 0.29 57571429
+ 0.21 0.07 0.29 64642857
+ 0.21 0.07 0.29 71714286
+ 0.21 0.07 0.29 78785714
+ 0.21 0.07 0.29 85857143
+ 0.21 0.07 0.29 92928571
+ 0.21 0.07 0.29 100000000
+ 0.21 0.07 0.36 1000000
+ 0.21 0.07 0.36 8071429
+ 0.21 0.07 0.36 15142857
+ 0.21 0.07 0.36 22214286
+ 0.21 0.07 0.36 29285714
+ 0.21 0.07 0.36 36357143
+ 0.21 0.07 0.36 43428571
+ 0.21 0.07 0.36 50500000
+ 0.21 0.07 0.36 57571429
+ 0.21 0.07 0.36 64642857
+ 0.21 0.07 0.36 71714286
+ 0.21 0.07 0.36 78785714
+ 0.21 0.07 0.36 85857143
+ 0.21 0.07 0.36 92928571
+ 0.21 0.07 0.36 100000000
+ 0.21 0.07 0.43 1000000
+ 0.21 0.07 0.43 8071429
+ 0.21 0.07 0.43 15142857
+ 0.21 0.07 0.43 22214286
+ 0.21 0.07 0.43 29285714
+ 0.21 0.07 0.43 36357143
+ 0.21 0.07 0.43 43428571
+ 0.21 0.07 0.43 50500000
+ 0.21 0.07 0.43 57571429
+ 0.21 0.07 0.43 64642857
+ 0.21 0.07 0.43 71714286
+ 0.21 0.07 0.43 78785714
+ 0.21 0.07 0.43 85857143
+ 0.21 0.07 0.43 92928571
+ 0.21 0.07 0.43 100000000
+ 0.21 0.07 0.50 1000000
+ 0.21 0.07 0.50 8071429
+ 0.21 0.07 0.50 15142857
+ 0.21 0.07 0.50 22214286
+ 0.21 0.07 0.50 29285714
+ 0.21 0.07 0.50 36357143
+ 0.21 0.07 0.50 43428571
+ 0.21 0.07 0.50 50500000
+ 0.21 0.07 0.50 57571429
+ 0.21 0.07 0.50 64642857
+ 0.21 0.07 0.50 71714286
+ 0.21 0.07 0.50 78785714
+ 0.21 0.07 0.50 85857143
+ 0.21 0.07 0.50 92928571
+ 0.21 0.07 0.50 100000000
+ 0.21 0.07 0.57 1000000
+ 0.21 0.07 0.57 8071429
+ 0.21 0.07 0.57 15142857
+ 0.21 0.07 0.57 22214286
+ 0.21 0.07 0.57 29285714
+ 0.21 0.07 0.57 36357143
+ 0.21 0.07 0.57 43428571
+ 0.21 0.07 0.57 50500000
+ 0.21 0.07 0.57 57571429
+ 0.21 0.07 0.57 64642857
+ 0.21 0.07 0.57 71714286
+ 0.21 0.07 0.57 78785714
+ 0.21 0.07 0.57 85857143
+ 0.21 0.07 0.57 92928571
+ 0.21 0.07 0.57 100000000
+ 0.21 0.07 0.64 1000000
+ 0.21 0.07 0.64 8071429
+ 0.21 0.07 0.64 15142857
+ 0.21 0.07 0.64 22214286
+ 0.21 0.07 0.64 29285714
+ 0.21 0.07 0.64 36357143
+ 0.21 0.07 0.64 43428571
+ 0.21 0.07 0.64 50500000
+ 0.21 0.07 0.64 57571429
+ 0.21 0.07 0.64 64642857
+ 0.21 0.07 0.64 71714286
+ 0.21 0.07 0.64 78785714
+ 0.21 0.07 0.64 85857143
+ 0.21 0.07 0.64 92928571
+ 0.21 0.07 0.64 100000000
+ 0.21 0.07 0.71 1000000
+ 0.21 0.07 0.71 8071429
+ 0.21 0.07 0.71 15142857
+ 0.21 0.07 0.71 22214286
+ 0.21 0.07 0.71 29285714
+ 0.21 0.07 0.71 36357143
+ 0.21 0.07 0.71 43428571
+ 0.21 0.07 0.71 50500000
+ 0.21 0.07 0.71 57571429
+ 0.21 0.07 0.71 64642857
+ 0.21 0.07 0.71 71714286
+ 0.21 0.07 0.71 78785714
+ 0.21 0.07 0.71 85857143
+ 0.21 0.07 0.71 92928571
+ 0.21 0.07 0.71 100000000
+ 0.21 0.07 0.79 1000000
+ 0.21 0.07 0.79 8071429
+ 0.21 0.07 0.79 15142857
+ 0.21 0.07 0.79 22214286
+ 0.21 0.07 0.79 29285714
+ 0.21 0.07 0.79 36357143
+ 0.21 0.07 0.79 43428571
+ 0.21 0.07 0.79 50500000
+ 0.21 0.07 0.79 57571429
+ 0.21 0.07 0.79 64642857
+ 0.21 0.07 0.79 71714286
+ 0.21 0.07 0.79 78785714
+ 0.21 0.07 0.79 85857143
+ 0.21 0.07 0.79 92928571
+ 0.21 0.07 0.79 100000000
+ 0.21 0.07 0.86 1000000
+ 0.21 0.07 0.86 8071429
+ 0.21 0.07 0.86 15142857
+ 0.21 0.07 0.86 22214286
+ 0.21 0.07 0.86 29285714
+ 0.21 0.07 0.86 36357143
+ 0.21 0.07 0.86 43428571
+ 0.21 0.07 0.86 50500000
+ 0.21 0.07 0.86 57571429
+ 0.21 0.07 0.86 64642857
+ 0.21 0.07 0.86 71714286
+ 0.21 0.07 0.86 78785714
+ 0.21 0.07 0.86 85857143
+ 0.21 0.07 0.86 92928571
+ 0.21 0.07 0.86 100000000
+ 0.21 0.07 0.93 1000000
+ 0.21 0.07 0.93 8071429
+ 0.21 0.07 0.93 15142857
+ 0.21 0.07 0.93 22214286
+ 0.21 0.07 0.93 29285714
+ 0.21 0.07 0.93 36357143
+ 0.21 0.07 0.93 43428571
+ 0.21 0.07 0.93 50500000
+ 0.21 0.07 0.93 57571429
+ 0.21 0.07 0.93 64642857
+ 0.21 0.07 0.93 71714286
+ 0.21 0.07 0.93 78785714
+ 0.21 0.07 0.93 85857143
+ 0.21 0.07 0.93 92928571
+ 0.21 0.07 0.93 100000000
+ 0.21 0.07 1.00 1000000
+ 0.21 0.07 1.00 8071429
+ 0.21 0.07 1.00 15142857
+ 0.21 0.07 1.00 22214286
+ 0.21 0.07 1.00 29285714
+ 0.21 0.07 1.00 36357143
+ 0.21 0.07 1.00 43428571
+ 0.21 0.07 1.00 50500000
+ 0.21 0.07 1.00 57571429
+ 0.21 0.07 1.00 64642857
+ 0.21 0.07 1.00 71714286
+ 0.21 0.07 1.00 78785714
+ 0.21 0.07 1.00 85857143
+ 0.21 0.07 1.00 92928571
+ 0.21 0.07 1.00 100000000
+ 0.21 0.14 0.00 1000000
+ 0.21 0.14 0.00 8071429
+ 0.21 0.14 0.00 15142857
+ 0.21 0.14 0.00 22214286
+ 0.21 0.14 0.00 29285714
+ 0.21 0.14 0.00 36357143
+ 0.21 0.14 0.00 43428571
+ 0.21 0.14 0.00 50500000
+ 0.21 0.14 0.00 57571429
+ 0.21 0.14 0.00 64642857
+ 0.21 0.14 0.00 71714286
+ 0.21 0.14 0.00 78785714
+ 0.21 0.14 0.00 85857143
+ 0.21 0.14 0.00 92928571
+ 0.21 0.14 0.00 100000000
+ 0.21 0.14 0.07 1000000
+ 0.21 0.14 0.07 8071429
+ 0.21 0.14 0.07 15142857
+ 0.21 0.14 0.07 22214286
+ 0.21 0.14 0.07 29285714
+ 0.21 0.14 0.07 36357143
+ 0.21 0.14 0.07 43428571
+ 0.21 0.14 0.07 50500000
+ 0.21 0.14 0.07 57571429
+ 0.21 0.14 0.07 64642857
+ 0.21 0.14 0.07 71714286
+ 0.21 0.14 0.07 78785714
+ 0.21 0.14 0.07 85857143
+ 0.21 0.14 0.07 92928571
+ 0.21 0.14 0.07 100000000
+ 0.21 0.14 0.14 1000000
+ 0.21 0.14 0.14 8071429
+ 0.21 0.14 0.14 15142857
+ 0.21 0.14 0.14 22214286
+ 0.21 0.14 0.14 29285714
+ 0.21 0.14 0.14 36357143
+ 0.21 0.14 0.14 43428571
+ 0.21 0.14 0.14 50500000
+ 0.21 0.14 0.14 57571429
+ 0.21 0.14 0.14 64642857
+ 0.21 0.14 0.14 71714286
+ 0.21 0.14 0.14 78785714
+ 0.21 0.14 0.14 85857143
+ 0.21 0.14 0.14 92928571
+ 0.21 0.14 0.14 100000000
+ 0.21 0.14 0.21 1000000
+ 0.21 0.14 0.21 8071429
+ 0.21 0.14 0.21 15142857
+ 0.21 0.14 0.21 22214286
+ 0.21 0.14 0.21 29285714
+ 0.21 0.14 0.21 36357143
+ 0.21 0.14 0.21 43428571
+ 0.21 0.14 0.21 50500000
+ 0.21 0.14 0.21 57571429
+ 0.21 0.14 0.21 64642857
+ 0.21 0.14 0.21 71714286
+ 0.21 0.14 0.21 78785714
+ 0.21 0.14 0.21 85857143
+ 0.21 0.14 0.21 92928571
+ 0.21 0.14 0.21 100000000
+ 0.21 0.14 0.29 1000000
+ 0.21 0.14 0.29 8071429
+ 0.21 0.14 0.29 15142857
+ 0.21 0.14 0.29 22214286
+ 0.21 0.14 0.29 29285714
+ 0.21 0.14 0.29 36357143
+ 0.21 0.14 0.29 43428571
+ 0.21 0.14 0.29 50500000
+ 0.21 0.14 0.29 57571429
+ 0.21 0.14 0.29 64642857
+ 0.21 0.14 0.29 71714286
+ 0.21 0.14 0.29 78785714
+ 0.21 0.14 0.29 85857143
+ 0.21 0.14 0.29 92928571
+ 0.21 0.14 0.29 100000000
+ 0.21 0.14 0.36 1000000
+ 0.21 0.14 0.36 8071429
+ 0.21 0.14 0.36 15142857
+ 0.21 0.14 0.36 22214286
+ 0.21 0.14 0.36 29285714
+ 0.21 0.14 0.36 36357143
+ 0.21 0.14 0.36 43428571
+ 0.21 0.14 0.36 50500000
+ 0.21 0.14 0.36 57571429
+ 0.21 0.14 0.36 64642857
+ 0.21 0.14 0.36 71714286
+ 0.21 0.14 0.36 78785714
+ 0.21 0.14 0.36 85857143
+ 0.21 0.14 0.36 92928571
+ 0.21 0.14 0.36 100000000
+ 0.21 0.14 0.43 1000000
+ 0.21 0.14 0.43 8071429
+ 0.21 0.14 0.43 15142857
+ 0.21 0.14 0.43 22214286
+ 0.21 0.14 0.43 29285714
+ 0.21 0.14 0.43 36357143
+ 0.21 0.14 0.43 43428571
+ 0.21 0.14 0.43 50500000
+ 0.21 0.14 0.43 57571429
+ 0.21 0.14 0.43 64642857
+ 0.21 0.14 0.43 71714286
+ 0.21 0.14 0.43 78785714
+ 0.21 0.14 0.43 85857143
+ 0.21 0.14 0.43 92928571
+ 0.21 0.14 0.43 100000000
+ 0.21 0.14 0.50 1000000
+ 0.21 0.14 0.50 8071429
+ 0.21 0.14 0.50 15142857
+ 0.21 0.14 0.50 22214286
+ 0.21 0.14 0.50 29285714
+ 0.21 0.14 0.50 36357143
+ 0.21 0.14 0.50 43428571
+ 0.21 0.14 0.50 50500000
+ 0.21 0.14 0.50 57571429
+ 0.21 0.14 0.50 64642857
+ 0.21 0.14 0.50 71714286
+ 0.21 0.14 0.50 78785714
+ 0.21 0.14 0.50 85857143
+ 0.21 0.14 0.50 92928571
+ 0.21 0.14 0.50 100000000
+ 0.21 0.14 0.57 1000000
+ 0.21 0.14 0.57 8071429
+ 0.21 0.14 0.57 15142857
+ 0.21 0.14 0.57 22214286
+ 0.21 0.14 0.57 29285714
+ 0.21 0.14 0.57 36357143
+ 0.21 0.14 0.57 43428571
+ 0.21 0.14 0.57 50500000
+ 0.21 0.14 0.57 57571429
+ 0.21 0.14 0.57 64642857
+ 0.21 0.14 0.57 71714286
+ 0.21 0.14 0.57 78785714
+ 0.21 0.14 0.57 85857143
+ 0.21 0.14 0.57 92928571
+ 0.21 0.14 0.57 100000000
+ 0.21 0.14 0.64 1000000
+ 0.21 0.14 0.64 8071429
+ 0.21 0.14 0.64 15142857
+ 0.21 0.14 0.64 22214286
+ 0.21 0.14 0.64 29285714
+ 0.21 0.14 0.64 36357143
+ 0.21 0.14 0.64 43428571
+ 0.21 0.14 0.64 50500000
+ 0.21 0.14 0.64 57571429
+ 0.21 0.14 0.64 64642857
+ 0.21 0.14 0.64 71714286
+ 0.21 0.14 0.64 78785714
+ 0.21 0.14 0.64 85857143
+ 0.21 0.14 0.64 92928571
+ 0.21 0.14 0.64 100000000
+ 0.21 0.14 0.71 1000000
+ 0.21 0.14 0.71 8071429
+ 0.21 0.14 0.71 15142857
+ 0.21 0.14 0.71 22214286
+ 0.21 0.14 0.71 29285714
+ 0.21 0.14 0.71 36357143
+ 0.21 0.14 0.71 43428571
+ 0.21 0.14 0.71 50500000
+ 0.21 0.14 0.71 57571429
+ 0.21 0.14 0.71 64642857
+ 0.21 0.14 0.71 71714286
+ 0.21 0.14 0.71 78785714
+ 0.21 0.14 0.71 85857143
+ 0.21 0.14 0.71 92928571
+ 0.21 0.14 0.71 100000000
+ 0.21 0.14 0.79 1000000
+ 0.21 0.14 0.79 8071429
+ 0.21 0.14 0.79 15142857
+ 0.21 0.14 0.79 22214286
+ 0.21 0.14 0.79 29285714
+ 0.21 0.14 0.79 36357143
+ 0.21 0.14 0.79 43428571
+ 0.21 0.14 0.79 50500000
+ 0.21 0.14 0.79 57571429
+ 0.21 0.14 0.79 64642857
+ 0.21 0.14 0.79 71714286
+ 0.21 0.14 0.79 78785714
+ 0.21 0.14 0.79 85857143
+ 0.21 0.14 0.79 92928571
+ 0.21 0.14 0.79 100000000
+ 0.21 0.14 0.86 1000000
+ 0.21 0.14 0.86 8071429
+ 0.21 0.14 0.86 15142857
+ 0.21 0.14 0.86 22214286
+ 0.21 0.14 0.86 29285714
+ 0.21 0.14 0.86 36357143
+ 0.21 0.14 0.86 43428571
+ 0.21 0.14 0.86 50500000
+ 0.21 0.14 0.86 57571429
+ 0.21 0.14 0.86 64642857
+ 0.21 0.14 0.86 71714286
+ 0.21 0.14 0.86 78785714
+ 0.21 0.14 0.86 85857143
+ 0.21 0.14 0.86 92928571
+ 0.21 0.14 0.86 100000000
+ 0.21 0.14 0.93 1000000
+ 0.21 0.14 0.93 8071429
+ 0.21 0.14 0.93 15142857
+ 0.21 0.14 0.93 22214286
+ 0.21 0.14 0.93 29285714
+ 0.21 0.14 0.93 36357143
+ 0.21 0.14 0.93 43428571
+ 0.21 0.14 0.93 50500000
+ 0.21 0.14 0.93 57571429
+ 0.21 0.14 0.93 64642857
+ 0.21 0.14 0.93 71714286
+ 0.21 0.14 0.93 78785714
+ 0.21 0.14 0.93 85857143
+ 0.21 0.14 0.93 92928571
+ 0.21 0.14 0.93 100000000
+ 0.21 0.14 1.00 1000000
+ 0.21 0.14 1.00 8071429
+ 0.21 0.14 1.00 15142857
+ 0.21 0.14 1.00 22214286
+ 0.21 0.14 1.00 29285714
+ 0.21 0.14 1.00 36357143
+ 0.21 0.14 1.00 43428571
+ 0.21 0.14 1.00 50500000
+ 0.21 0.14 1.00 57571429
+ 0.21 0.14 1.00 64642857
+ 0.21 0.14 1.00 71714286
+ 0.21 0.14 1.00 78785714
+ 0.21 0.14 1.00 85857143
+ 0.21 0.14 1.00 92928571
+ 0.21 0.14 1.00 100000000
+ 0.21 0.21 0.00 1000000
+ 0.21 0.21 0.00 8071429
+ 0.21 0.21 0.00 15142857
+ 0.21 0.21 0.00 22214286
+ 0.21 0.21 0.00 29285714
+ 0.21 0.21 0.00 36357143
+ 0.21 0.21 0.00 43428571
+ 0.21 0.21 0.00 50500000
+ 0.21 0.21 0.00 57571429
+ 0.21 0.21 0.00 64642857
+ 0.21 0.21 0.00 71714286
+ 0.21 0.21 0.00 78785714
+ 0.21 0.21 0.00 85857143
+ 0.21 0.21 0.00 92928571
+ 0.21 0.21 0.00 100000000
+ 0.21 0.21 0.07 1000000
+ 0.21 0.21 0.07 8071429
+ 0.21 0.21 0.07 15142857
+ 0.21 0.21 0.07 22214286
+ 0.21 0.21 0.07 29285714
+ 0.21 0.21 0.07 36357143
+ 0.21 0.21 0.07 43428571
+ 0.21 0.21 0.07 50500000
+ 0.21 0.21 0.07 57571429
+ 0.21 0.21 0.07 64642857
+ 0.21 0.21 0.07 71714286
+ 0.21 0.21 0.07 78785714
+ 0.21 0.21 0.07 85857143
+ 0.21 0.21 0.07 92928571
+ 0.21 0.21 0.07 100000000
+ 0.21 0.21 0.14 1000000
+ 0.21 0.21 0.14 8071429
+ 0.21 0.21 0.14 15142857
+ 0.21 0.21 0.14 22214286
+ 0.21 0.21 0.14 29285714
+ 0.21 0.21 0.14 36357143
+ 0.21 0.21 0.14 43428571
+ 0.21 0.21 0.14 50500000
+ 0.21 0.21 0.14 57571429
+ 0.21 0.21 0.14 64642857
+ 0.21 0.21 0.14 71714286
+ 0.21 0.21 0.14 78785714
+ 0.21 0.21 0.14 85857143
+ 0.21 0.21 0.14 92928571
+ 0.21 0.21 0.14 100000000
+ 0.21 0.21 0.21 1000000
+ 0.21 0.21 0.21 8071429
+ 0.21 0.21 0.21 15142857
+ 0.21 0.21 0.21 22214286
+ 0.21 0.21 0.21 29285714
+ 0.21 0.21 0.21 36357143
+ 0.21 0.21 0.21 43428571
+ 0.21 0.21 0.21 50500000
+ 0.21 0.21 0.21 57571429
+ 0.21 0.21 0.21 64642857
+ 0.21 0.21 0.21 71714286
+ 0.21 0.21 0.21 78785714
+ 0.21 0.21 0.21 85857143
+ 0.21 0.21 0.21 92928571
+ 0.21 0.21 0.21 100000000
+ 0.21 0.21 0.29 1000000
+ 0.21 0.21 0.29 8071429
+ 0.21 0.21 0.29 15142857
+ 0.21 0.21 0.29 22214286
+ 0.21 0.21 0.29 29285714
+ 0.21 0.21 0.29 36357143
+ 0.21 0.21 0.29 43428571
+ 0.21 0.21 0.29 50500000
+ 0.21 0.21 0.29 57571429
+ 0.21 0.21 0.29 64642857
+ 0.21 0.21 0.29 71714286
+ 0.21 0.21 0.29 78785714
+ 0.21 0.21 0.29 85857143
+ 0.21 0.21 0.29 92928571
+ 0.21 0.21 0.29 100000000
+ 0.21 0.21 0.36 1000000
+ 0.21 0.21 0.36 8071429
+ 0.21 0.21 0.36 15142857
+ 0.21 0.21 0.36 22214286
+ 0.21 0.21 0.36 29285714
+ 0.21 0.21 0.36 36357143
+ 0.21 0.21 0.36 43428571
+ 0.21 0.21 0.36 50500000
+ 0.21 0.21 0.36 57571429
+ 0.21 0.21 0.36 64642857
+ 0.21 0.21 0.36 71714286
+ 0.21 0.21 0.36 78785714
+ 0.21 0.21 0.36 85857143
+ 0.21 0.21 0.36 92928571
+ 0.21 0.21 0.36 100000000
+ 0.21 0.21 0.43 1000000
+ 0.21 0.21 0.43 8071429
+ 0.21 0.21 0.43 15142857
+ 0.21 0.21 0.43 22214286
+ 0.21 0.21 0.43 29285714
+ 0.21 0.21 0.43 36357143
+ 0.21 0.21 0.43 43428571
+ 0.21 0.21 0.43 50500000
+ 0.21 0.21 0.43 57571429
+ 0.21 0.21 0.43 64642857
+ 0.21 0.21 0.43 71714286
+ 0.21 0.21 0.43 78785714
+ 0.21 0.21 0.43 85857143
+ 0.21 0.21 0.43 92928571
+ 0.21 0.21 0.43 100000000
+ 0.21 0.21 0.50 1000000
+ 0.21 0.21 0.50 8071429
+ 0.21 0.21 0.50 15142857
+ 0.21 0.21 0.50 22214286
+ 0.21 0.21 0.50 29285714
+ 0.21 0.21 0.50 36357143
+ 0.21 0.21 0.50 43428571
+ 0.21 0.21 0.50 50500000
+ 0.21 0.21 0.50 57571429
+ 0.21 0.21 0.50 64642857
+ 0.21 0.21 0.50 71714286
+ 0.21 0.21 0.50 78785714
+ 0.21 0.21 0.50 85857143
+ 0.21 0.21 0.50 92928571
+ 0.21 0.21 0.50 100000000
+ 0.21 0.21 0.57 1000000
+ 0.21 0.21 0.57 8071429
+ 0.21 0.21 0.57 15142857
+ 0.21 0.21 0.57 22214286
+ 0.21 0.21 0.57 29285714
+ 0.21 0.21 0.57 36357143
+ 0.21 0.21 0.57 43428571
+ 0.21 0.21 0.57 50500000
+ 0.21 0.21 0.57 57571429
+ 0.21 0.21 0.57 64642857
+ 0.21 0.21 0.57 71714286
+ 0.21 0.21 0.57 78785714
+ 0.21 0.21 0.57 85857143
+ 0.21 0.21 0.57 92928571
+ 0.21 0.21 0.57 100000000
+ 0.21 0.21 0.64 1000000
+ 0.21 0.21 0.64 8071429
+ 0.21 0.21 0.64 15142857
+ 0.21 0.21 0.64 22214286
+ 0.21 0.21 0.64 29285714
+ 0.21 0.21 0.64 36357143
+ 0.21 0.21 0.64 43428571
+ 0.21 0.21 0.64 50500000
+ 0.21 0.21 0.64 57571429
+ 0.21 0.21 0.64 64642857
+ 0.21 0.21 0.64 71714286
+ 0.21 0.21 0.64 78785714
+ 0.21 0.21 0.64 85857143
+ 0.21 0.21 0.64 92928571
+ 0.21 0.21 0.64 100000000
+ 0.21 0.21 0.71 1000000
+ 0.21 0.21 0.71 8071429
+ 0.21 0.21 0.71 15142857
+ 0.21 0.21 0.71 22214286
+ 0.21 0.21 0.71 29285714
+ 0.21 0.21 0.71 36357143
+ 0.21 0.21 0.71 43428571
+ 0.21 0.21 0.71 50500000
+ 0.21 0.21 0.71 57571429
+ 0.21 0.21 0.71 64642857
+ 0.21 0.21 0.71 71714286
+ 0.21 0.21 0.71 78785714
+ 0.21 0.21 0.71 85857143
+ 0.21 0.21 0.71 92928571
+ 0.21 0.21 0.71 100000000
+ 0.21 0.21 0.79 1000000
+ 0.21 0.21 0.79 8071429
+ 0.21 0.21 0.79 15142857
+ 0.21 0.21 0.79 22214286
+ 0.21 0.21 0.79 29285714
+ 0.21 0.21 0.79 36357143
+ 0.21 0.21 0.79 43428571
+ 0.21 0.21 0.79 50500000
+ 0.21 0.21 0.79 57571429
+ 0.21 0.21 0.79 64642857
+ 0.21 0.21 0.79 71714286
+ 0.21 0.21 0.79 78785714
+ 0.21 0.21 0.79 85857143
+ 0.21 0.21 0.79 92928571
+ 0.21 0.21 0.79 100000000
+ 0.21 0.21 0.86 1000000
+ 0.21 0.21 0.86 8071429
+ 0.21 0.21 0.86 15142857
+ 0.21 0.21 0.86 22214286
+ 0.21 0.21 0.86 29285714
+ 0.21 0.21 0.86 36357143
+ 0.21 0.21 0.86 43428571
+ 0.21 0.21 0.86 50500000
+ 0.21 0.21 0.86 57571429
+ 0.21 0.21 0.86 64642857
+ 0.21 0.21 0.86 71714286
+ 0.21 0.21 0.86 78785714
+ 0.21 0.21 0.86 85857143
+ 0.21 0.21 0.86 92928571
+ 0.21 0.21 0.86 100000000
+ 0.21 0.21 0.93 1000000
+ 0.21 0.21 0.93 8071429
+ 0.21 0.21 0.93 15142857
+ 0.21 0.21 0.93 22214286
+ 0.21 0.21 0.93 29285714
+ 0.21 0.21 0.93 36357143
+ 0.21 0.21 0.93 43428571
+ 0.21 0.21 0.93 50500000
+ 0.21 0.21 0.93 57571429
+ 0.21 0.21 0.93 64642857
+ 0.21 0.21 0.93 71714286
+ 0.21 0.21 0.93 78785714
+ 0.21 0.21 0.93 85857143
+ 0.21 0.21 0.93 92928571
+ 0.21 0.21 0.93 100000000
+ 0.21 0.21 1.00 1000000
+ 0.21 0.21 1.00 8071429
+ 0.21 0.21 1.00 15142857
+ 0.21 0.21 1.00 22214286
+ 0.21 0.21 1.00 29285714
+ 0.21 0.21 1.00 36357143
+ 0.21 0.21 1.00 43428571
+ 0.21 0.21 1.00 50500000
+ 0.21 0.21 1.00 57571429
+ 0.21 0.21 1.00 64642857
+ 0.21 0.21 1.00 71714286
+ 0.21 0.21 1.00 78785714
+ 0.21 0.21 1.00 85857143
+ 0.21 0.21 1.00 92928571
+ 0.21 0.21 1.00 100000000
+ 0.21 0.29 0.00 1000000
+ 0.21 0.29 0.00 8071429
+ 0.21 0.29 0.00 15142857
+ 0.21 0.29 0.00 22214286
+ 0.21 0.29 0.00 29285714
+ 0.21 0.29 0.00 36357143
+ 0.21 0.29 0.00 43428571
+ 0.21 0.29 0.00 50500000
+ 0.21 0.29 0.00 57571429
+ 0.21 0.29 0.00 64642857
+ 0.21 0.29 0.00 71714286
+ 0.21 0.29 0.00 78785714
+ 0.21 0.29 0.00 85857143
+ 0.21 0.29 0.00 92928571
+ 0.21 0.29 0.00 100000000
+ 0.21 0.29 0.07 1000000
+ 0.21 0.29 0.07 8071429
+ 0.21 0.29 0.07 15142857
+ 0.21 0.29 0.07 22214286
+ 0.21 0.29 0.07 29285714
+ 0.21 0.29 0.07 36357143
+ 0.21 0.29 0.07 43428571
+ 0.21 0.29 0.07 50500000
+ 0.21 0.29 0.07 57571429
+ 0.21 0.29 0.07 64642857
+ 0.21 0.29 0.07 71714286
+ 0.21 0.29 0.07 78785714
+ 0.21 0.29 0.07 85857143
+ 0.21 0.29 0.07 92928571
+ 0.21 0.29 0.07 100000000
+ 0.21 0.29 0.14 1000000
+ 0.21 0.29 0.14 8071429
+ 0.21 0.29 0.14 15142857
+ 0.21 0.29 0.14 22214286
+ 0.21 0.29 0.14 29285714
+ 0.21 0.29 0.14 36357143
+ 0.21 0.29 0.14 43428571
+ 0.21 0.29 0.14 50500000
+ 0.21 0.29 0.14 57571429
+ 0.21 0.29 0.14 64642857
+ 0.21 0.29 0.14 71714286
+ 0.21 0.29 0.14 78785714
+ 0.21 0.29 0.14 85857143
+ 0.21 0.29 0.14 92928571
+ 0.21 0.29 0.14 100000000
+ 0.21 0.29 0.21 1000000
+ 0.21 0.29 0.21 8071429
+ 0.21 0.29 0.21 15142857
+ 0.21 0.29 0.21 22214286
+ 0.21 0.29 0.21 29285714
+ 0.21 0.29 0.21 36357143
+ 0.21 0.29 0.21 43428571
+ 0.21 0.29 0.21 50500000
+ 0.21 0.29 0.21 57571429
+ 0.21 0.29 0.21 64642857
+ 0.21 0.29 0.21 71714286
+ 0.21 0.29 0.21 78785714
+ 0.21 0.29 0.21 85857143
+ 0.21 0.29 0.21 92928571
+ 0.21 0.29 0.21 100000000
+ 0.21 0.29 0.29 1000000
+ 0.21 0.29 0.29 8071429
+ 0.21 0.29 0.29 15142857
+ 0.21 0.29 0.29 22214286
+ 0.21 0.29 0.29 29285714
+ 0.21 0.29 0.29 36357143
+ 0.21 0.29 0.29 43428571
+ 0.21 0.29 0.29 50500000
+ 0.21 0.29 0.29 57571429
+ 0.21 0.29 0.29 64642857
+ 0.21 0.29 0.29 71714286
+ 0.21 0.29 0.29 78785714
+ 0.21 0.29 0.29 85857143
+ 0.21 0.29 0.29 92928571
+ 0.21 0.29 0.29 100000000
+ 0.21 0.29 0.36 1000000
+ 0.21 0.29 0.36 8071429
+ 0.21 0.29 0.36 15142857
+ 0.21 0.29 0.36 22214286
+ 0.21 0.29 0.36 29285714
+ 0.21 0.29 0.36 36357143
+ 0.21 0.29 0.36 43428571
+ 0.21 0.29 0.36 50500000
+ 0.21 0.29 0.36 57571429
+ 0.21 0.29 0.36 64642857
+ 0.21 0.29 0.36 71714286
+ 0.21 0.29 0.36 78785714
+ 0.21 0.29 0.36 85857143
+ 0.21 0.29 0.36 92928571
+ 0.21 0.29 0.36 100000000
+ 0.21 0.29 0.43 1000000
+ 0.21 0.29 0.43 8071429
+ 0.21 0.29 0.43 15142857
+ 0.21 0.29 0.43 22214286
+ 0.21 0.29 0.43 29285714
+ 0.21 0.29 0.43 36357143
+ 0.21 0.29 0.43 43428571
+ 0.21 0.29 0.43 50500000
+ 0.21 0.29 0.43 57571429
+ 0.21 0.29 0.43 64642857
+ 0.21 0.29 0.43 71714286
+ 0.21 0.29 0.43 78785714
+ 0.21 0.29 0.43 85857143
+ 0.21 0.29 0.43 92928571
+ 0.21 0.29 0.43 100000000
+ 0.21 0.29 0.50 1000000
+ 0.21 0.29 0.50 8071429
+ 0.21 0.29 0.50 15142857
+ 0.21 0.29 0.50 22214286
+ 0.21 0.29 0.50 29285714
+ 0.21 0.29 0.50 36357143
+ 0.21 0.29 0.50 43428571
+ 0.21 0.29 0.50 50500000
+ 0.21 0.29 0.50 57571429
+ 0.21 0.29 0.50 64642857
+ 0.21 0.29 0.50 71714286
+ 0.21 0.29 0.50 78785714
+ 0.21 0.29 0.50 85857143
+ 0.21 0.29 0.50 92928571
+ 0.21 0.29 0.50 100000000
+ 0.21 0.29 0.57 1000000
+ 0.21 0.29 0.57 8071429
+ 0.21 0.29 0.57 15142857
+ 0.21 0.29 0.57 22214286
+ 0.21 0.29 0.57 29285714
+ 0.21 0.29 0.57 36357143
+ 0.21 0.29 0.57 43428571
+ 0.21 0.29 0.57 50500000
+ 0.21 0.29 0.57 57571429
+ 0.21 0.29 0.57 64642857
+ 0.21 0.29 0.57 71714286
+ 0.21 0.29 0.57 78785714
+ 0.21 0.29 0.57 85857143
+ 0.21 0.29 0.57 92928571
+ 0.21 0.29 0.57 100000000
+ 0.21 0.29 0.64 1000000
+ 0.21 0.29 0.64 8071429
+ 0.21 0.29 0.64 15142857
+ 0.21 0.29 0.64 22214286
+ 0.21 0.29 0.64 29285714
+ 0.21 0.29 0.64 36357143
+ 0.21 0.29 0.64 43428571
+ 0.21 0.29 0.64 50500000
+ 0.21 0.29 0.64 57571429
+ 0.21 0.29 0.64 64642857
+ 0.21 0.29 0.64 71714286
+ 0.21 0.29 0.64 78785714
+ 0.21 0.29 0.64 85857143
+ 0.21 0.29 0.64 92928571
+ 0.21 0.29 0.64 100000000
+ 0.21 0.29 0.71 1000000
+ 0.21 0.29 0.71 8071429
+ 0.21 0.29 0.71 15142857
+ 0.21 0.29 0.71 22214286
+ 0.21 0.29 0.71 29285714
+ 0.21 0.29 0.71 36357143
+ 0.21 0.29 0.71 43428571
+ 0.21 0.29 0.71 50500000
+ 0.21 0.29 0.71 57571429
+ 0.21 0.29 0.71 64642857
+ 0.21 0.29 0.71 71714286
+ 0.21 0.29 0.71 78785714
+ 0.21 0.29 0.71 85857143
+ 0.21 0.29 0.71 92928571
+ 0.21 0.29 0.71 100000000
+ 0.21 0.29 0.79 1000000
+ 0.21 0.29 0.79 8071429
+ 0.21 0.29 0.79 15142857
+ 0.21 0.29 0.79 22214286
+ 0.21 0.29 0.79 29285714
+ 0.21 0.29 0.79 36357143
+ 0.21 0.29 0.79 43428571
+ 0.21 0.29 0.79 50500000
+ 0.21 0.29 0.79 57571429
+ 0.21 0.29 0.79 64642857
+ 0.21 0.29 0.79 71714286
+ 0.21 0.29 0.79 78785714
+ 0.21 0.29 0.79 85857143
+ 0.21 0.29 0.79 92928571
+ 0.21 0.29 0.79 100000000
+ 0.21 0.29 0.86 1000000
+ 0.21 0.29 0.86 8071429
+ 0.21 0.29 0.86 15142857
+ 0.21 0.29 0.86 22214286
+ 0.21 0.29 0.86 29285714
+ 0.21 0.29 0.86 36357143
+ 0.21 0.29 0.86 43428571
+ 0.21 0.29 0.86 50500000
+ 0.21 0.29 0.86 57571429
+ 0.21 0.29 0.86 64642857
+ 0.21 0.29 0.86 71714286
+ 0.21 0.29 0.86 78785714
+ 0.21 0.29 0.86 85857143
+ 0.21 0.29 0.86 92928571
+ 0.21 0.29 0.86 100000000
+ 0.21 0.29 0.93 1000000
+ 0.21 0.29 0.93 8071429
+ 0.21 0.29 0.93 15142857
+ 0.21 0.29 0.93 22214286
+ 0.21 0.29 0.93 29285714
+ 0.21 0.29 0.93 36357143
+ 0.21 0.29 0.93 43428571
+ 0.21 0.29 0.93 50500000
+ 0.21 0.29 0.93 57571429
+ 0.21 0.29 0.93 64642857
+ 0.21 0.29 0.93 71714286
+ 0.21 0.29 0.93 78785714
+ 0.21 0.29 0.93 85857143
+ 0.21 0.29 0.93 92928571
+ 0.21 0.29 0.93 100000000
+ 0.21 0.29 1.00 1000000
+ 0.21 0.29 1.00 8071429
+ 0.21 0.29 1.00 15142857
+ 0.21 0.29 1.00 22214286
+ 0.21 0.29 1.00 29285714
+ 0.21 0.29 1.00 36357143
+ 0.21 0.29 1.00 43428571
+ 0.21 0.29 1.00 50500000
+ 0.21 0.29 1.00 57571429
+ 0.21 0.29 1.00 64642857
+ 0.21 0.29 1.00 71714286
+ 0.21 0.29 1.00 78785714
+ 0.21 0.29 1.00 85857143
+ 0.21 0.29 1.00 92928571
+ 0.21 0.29 1.00 100000000
+ 0.21 0.36 0.00 1000000
+ 0.21 0.36 0.00 8071429
+ 0.21 0.36 0.00 15142857
+ 0.21 0.36 0.00 22214286
+ 0.21 0.36 0.00 29285714
+ 0.21 0.36 0.00 36357143
+ 0.21 0.36 0.00 43428571
+ 0.21 0.36 0.00 50500000
+ 0.21 0.36 0.00 57571429
+ 0.21 0.36 0.00 64642857
+ 0.21 0.36 0.00 71714286
+ 0.21 0.36 0.00 78785714
+ 0.21 0.36 0.00 85857143
+ 0.21 0.36 0.00 92928571
+ 0.21 0.36 0.00 100000000
+ 0.21 0.36 0.07 1000000
+ 0.21 0.36 0.07 8071429
+ 0.21 0.36 0.07 15142857
+ 0.21 0.36 0.07 22214286
+ 0.21 0.36 0.07 29285714
+ 0.21 0.36 0.07 36357143
+ 0.21 0.36 0.07 43428571
+ 0.21 0.36 0.07 50500000
+ 0.21 0.36 0.07 57571429
+ 0.21 0.36 0.07 64642857
+ 0.21 0.36 0.07 71714286
+ 0.21 0.36 0.07 78785714
+ 0.21 0.36 0.07 85857143
+ 0.21 0.36 0.07 92928571
+ 0.21 0.36 0.07 100000000
+ 0.21 0.36 0.14 1000000
+ 0.21 0.36 0.14 8071429
+ 0.21 0.36 0.14 15142857
+ 0.21 0.36 0.14 22214286
+ 0.21 0.36 0.14 29285714
+ 0.21 0.36 0.14 36357143
+ 0.21 0.36 0.14 43428571
+ 0.21 0.36 0.14 50500000
+ 0.21 0.36 0.14 57571429
+ 0.21 0.36 0.14 64642857
+ 0.21 0.36 0.14 71714286
+ 0.21 0.36 0.14 78785714
+ 0.21 0.36 0.14 85857143
+ 0.21 0.36 0.14 92928571
+ 0.21 0.36 0.14 100000000
+ 0.21 0.36 0.21 1000000
+ 0.21 0.36 0.21 8071429
+ 0.21 0.36 0.21 15142857
+ 0.21 0.36 0.21 22214286
+ 0.21 0.36 0.21 29285714
+ 0.21 0.36 0.21 36357143
+ 0.21 0.36 0.21 43428571
+ 0.21 0.36 0.21 50500000
+ 0.21 0.36 0.21 57571429
+ 0.21 0.36 0.21 64642857
+ 0.21 0.36 0.21 71714286
+ 0.21 0.36 0.21 78785714
+ 0.21 0.36 0.21 85857143
+ 0.21 0.36 0.21 92928571
+ 0.21 0.36 0.21 100000000
+ 0.21 0.36 0.29 1000000
+ 0.21 0.36 0.29 8071429
+ 0.21 0.36 0.29 15142857
+ 0.21 0.36 0.29 22214286
+ 0.21 0.36 0.29 29285714
+ 0.21 0.36 0.29 36357143
+ 0.21 0.36 0.29 43428571
+ 0.21 0.36 0.29 50500000
+ 0.21 0.36 0.29 57571429
+ 0.21 0.36 0.29 64642857
+ 0.21 0.36 0.29 71714286
+ 0.21 0.36 0.29 78785714
+ 0.21 0.36 0.29 85857143
+ 0.21 0.36 0.29 92928571
+ 0.21 0.36 0.29 100000000
+ 0.21 0.36 0.36 1000000
+ 0.21 0.36 0.36 8071429
+ 0.21 0.36 0.36 15142857
+ 0.21 0.36 0.36 22214286
+ 0.21 0.36 0.36 29285714
+ 0.21 0.36 0.36 36357143
+ 0.21 0.36 0.36 43428571
+ 0.21 0.36 0.36 50500000
+ 0.21 0.36 0.36 57571429
+ 0.21 0.36 0.36 64642857
+ 0.21 0.36 0.36 71714286
+ 0.21 0.36 0.36 78785714
+ 0.21 0.36 0.36 85857143
+ 0.21 0.36 0.36 92928571
+ 0.21 0.36 0.36 100000000
+ 0.21 0.36 0.43 1000000
+ 0.21 0.36 0.43 8071429
+ 0.21 0.36 0.43 15142857
+ 0.21 0.36 0.43 22214286
+ 0.21 0.36 0.43 29285714
+ 0.21 0.36 0.43 36357143
+ 0.21 0.36 0.43 43428571
+ 0.21 0.36 0.43 50500000
+ 0.21 0.36 0.43 57571429
+ 0.21 0.36 0.43 64642857
+ 0.21 0.36 0.43 71714286
+ 0.21 0.36 0.43 78785714
+ 0.21 0.36 0.43 85857143
+ 0.21 0.36 0.43 92928571
+ 0.21 0.36 0.43 100000000
+ 0.21 0.36 0.50 1000000
+ 0.21 0.36 0.50 8071429
+ 0.21 0.36 0.50 15142857
+ 0.21 0.36 0.50 22214286
+ 0.21 0.36 0.50 29285714
+ 0.21 0.36 0.50 36357143
+ 0.21 0.36 0.50 43428571
+ 0.21 0.36 0.50 50500000
+ 0.21 0.36 0.50 57571429
+ 0.21 0.36 0.50 64642857
+ 0.21 0.36 0.50 71714286
+ 0.21 0.36 0.50 78785714
+ 0.21 0.36 0.50 85857143
+ 0.21 0.36 0.50 92928571
+ 0.21 0.36 0.50 100000000
+ 0.21 0.36 0.57 1000000
+ 0.21 0.36 0.57 8071429
+ 0.21 0.36 0.57 15142857
+ 0.21 0.36 0.57 22214286
+ 0.21 0.36 0.57 29285714
+ 0.21 0.36 0.57 36357143
+ 0.21 0.36 0.57 43428571
+ 0.21 0.36 0.57 50500000
+ 0.21 0.36 0.57 57571429
+ 0.21 0.36 0.57 64642857
+ 0.21 0.36 0.57 71714286
+ 0.21 0.36 0.57 78785714
+ 0.21 0.36 0.57 85857143
+ 0.21 0.36 0.57 92928571
+ 0.21 0.36 0.57 100000000
+ 0.21 0.36 0.64 1000000
+ 0.21 0.36 0.64 8071429
+ 0.21 0.36 0.64 15142857
+ 0.21 0.36 0.64 22214286
+ 0.21 0.36 0.64 29285714
+ 0.21 0.36 0.64 36357143
+ 0.21 0.36 0.64 43428571
+ 0.21 0.36 0.64 50500000
+ 0.21 0.36 0.64 57571429
+ 0.21 0.36 0.64 64642857
+ 0.21 0.36 0.64 71714286
+ 0.21 0.36 0.64 78785714
+ 0.21 0.36 0.64 85857143
+ 0.21 0.36 0.64 92928571
+ 0.21 0.36 0.64 100000000
+ 0.21 0.36 0.71 1000000
+ 0.21 0.36 0.71 8071429
+ 0.21 0.36 0.71 15142857
+ 0.21 0.36 0.71 22214286
+ 0.21 0.36 0.71 29285714
+ 0.21 0.36 0.71 36357143
+ 0.21 0.36 0.71 43428571
+ 0.21 0.36 0.71 50500000
+ 0.21 0.36 0.71 57571429
+ 0.21 0.36 0.71 64642857
+ 0.21 0.36 0.71 71714286
+ 0.21 0.36 0.71 78785714
+ 0.21 0.36 0.71 85857143
+ 0.21 0.36 0.71 92928571
+ 0.21 0.36 0.71 100000000
+ 0.21 0.36 0.79 1000000
+ 0.21 0.36 0.79 8071429
+ 0.21 0.36 0.79 15142857
+ 0.21 0.36 0.79 22214286
+ 0.21 0.36 0.79 29285714
+ 0.21 0.36 0.79 36357143
+ 0.21 0.36 0.79 43428571
+ 0.21 0.36 0.79 50500000
+ 0.21 0.36 0.79 57571429
+ 0.21 0.36 0.79 64642857
+ 0.21 0.36 0.79 71714286
+ 0.21 0.36 0.79 78785714
+ 0.21 0.36 0.79 85857143
+ 0.21 0.36 0.79 92928571
+ 0.21 0.36 0.79 100000000
+ 0.21 0.36 0.86 1000000
+ 0.21 0.36 0.86 8071429
+ 0.21 0.36 0.86 15142857
+ 0.21 0.36 0.86 22214286
+ 0.21 0.36 0.86 29285714
+ 0.21 0.36 0.86 36357143
+ 0.21 0.36 0.86 43428571
+ 0.21 0.36 0.86 50500000
+ 0.21 0.36 0.86 57571429
+ 0.21 0.36 0.86 64642857
+ 0.21 0.36 0.86 71714286
+ 0.21 0.36 0.86 78785714
+ 0.21 0.36 0.86 85857143
+ 0.21 0.36 0.86 92928571
+ 0.21 0.36 0.86 100000000
+ 0.21 0.36 0.93 1000000
+ 0.21 0.36 0.93 8071429
+ 0.21 0.36 0.93 15142857
+ 0.21 0.36 0.93 22214286
+ 0.21 0.36 0.93 29285714
+ 0.21 0.36 0.93 36357143
+ 0.21 0.36 0.93 43428571
+ 0.21 0.36 0.93 50500000
+ 0.21 0.36 0.93 57571429
+ 0.21 0.36 0.93 64642857
+ 0.21 0.36 0.93 71714286
+ 0.21 0.36 0.93 78785714
+ 0.21 0.36 0.93 85857143
+ 0.21 0.36 0.93 92928571
+ 0.21 0.36 0.93 100000000
+ 0.21 0.36 1.00 1000000
+ 0.21 0.36 1.00 8071429
+ 0.21 0.36 1.00 15142857
+ 0.21 0.36 1.00 22214286
+ 0.21 0.36 1.00 29285714
+ 0.21 0.36 1.00 36357143
+ 0.21 0.36 1.00 43428571
+ 0.21 0.36 1.00 50500000
+ 0.21 0.36 1.00 57571429
+ 0.21 0.36 1.00 64642857
+ 0.21 0.36 1.00 71714286
+ 0.21 0.36 1.00 78785714
+ 0.21 0.36 1.00 85857143
+ 0.21 0.36 1.00 92928571
+ 0.21 0.36 1.00 100000000
+ 0.21 0.43 0.00 1000000
+ 0.21 0.43 0.00 8071429
+ 0.21 0.43 0.00 15142857
+ 0.21 0.43 0.00 22214286
+ 0.21 0.43 0.00 29285714
+ 0.21 0.43 0.00 36357143
+ 0.21 0.43 0.00 43428571
+ 0.21 0.43 0.00 50500000
+ 0.21 0.43 0.00 57571429
+ 0.21 0.43 0.00 64642857
+ 0.21 0.43 0.00 71714286
+ 0.21 0.43 0.00 78785714
+ 0.21 0.43 0.00 85857143
+ 0.21 0.43 0.00 92928571
+ 0.21 0.43 0.00 100000000
+ 0.21 0.43 0.07 1000000
+ 0.21 0.43 0.07 8071429
+ 0.21 0.43 0.07 15142857
+ 0.21 0.43 0.07 22214286
+ 0.21 0.43 0.07 29285714
+ 0.21 0.43 0.07 36357143
+ 0.21 0.43 0.07 43428571
+ 0.21 0.43 0.07 50500000
+ 0.21 0.43 0.07 57571429
+ 0.21 0.43 0.07 64642857
+ 0.21 0.43 0.07 71714286
+ 0.21 0.43 0.07 78785714
+ 0.21 0.43 0.07 85857143
+ 0.21 0.43 0.07 92928571
+ 0.21 0.43 0.07 100000000
+ 0.21 0.43 0.14 1000000
+ 0.21 0.43 0.14 8071429
+ 0.21 0.43 0.14 15142857
+ 0.21 0.43 0.14 22214286
+ 0.21 0.43 0.14 29285714
+ 0.21 0.43 0.14 36357143
+ 0.21 0.43 0.14 43428571
+ 0.21 0.43 0.14 50500000
+ 0.21 0.43 0.14 57571429
+ 0.21 0.43 0.14 64642857
+ 0.21 0.43 0.14 71714286
+ 0.21 0.43 0.14 78785714
+ 0.21 0.43 0.14 85857143
+ 0.21 0.43 0.14 92928571
+ 0.21 0.43 0.14 100000000
+ 0.21 0.43 0.21 1000000
+ 0.21 0.43 0.21 8071429
+ 0.21 0.43 0.21 15142857
+ 0.21 0.43 0.21 22214286
+ 0.21 0.43 0.21 29285714
+ 0.21 0.43 0.21 36357143
+ 0.21 0.43 0.21 43428571
+ 0.21 0.43 0.21 50500000
+ 0.21 0.43 0.21 57571429
+ 0.21 0.43 0.21 64642857
+ 0.21 0.43 0.21 71714286
+ 0.21 0.43 0.21 78785714
+ 0.21 0.43 0.21 85857143
+ 0.21 0.43 0.21 92928571
+ 0.21 0.43 0.21 100000000
+ 0.21 0.43 0.29 1000000
+ 0.21 0.43 0.29 8071429
+ 0.21 0.43 0.29 15142857
+ 0.21 0.43 0.29 22214286
+ 0.21 0.43 0.29 29285714
+ 0.21 0.43 0.29 36357143
+ 0.21 0.43 0.29 43428571
+ 0.21 0.43 0.29 50500000
+ 0.21 0.43 0.29 57571429
+ 0.21 0.43 0.29 64642857
+ 0.21 0.43 0.29 71714286
+ 0.21 0.43 0.29 78785714
+ 0.21 0.43 0.29 85857143
+ 0.21 0.43 0.29 92928571
+ 0.21 0.43 0.29 100000000
+ 0.21 0.43 0.36 1000000
+ 0.21 0.43 0.36 8071429
+ 0.21 0.43 0.36 15142857
+ 0.21 0.43 0.36 22214286
+ 0.21 0.43 0.36 29285714
+ 0.21 0.43 0.36 36357143
+ 0.21 0.43 0.36 43428571
+ 0.21 0.43 0.36 50500000
+ 0.21 0.43 0.36 57571429
+ 0.21 0.43 0.36 64642857
+ 0.21 0.43 0.36 71714286
+ 0.21 0.43 0.36 78785714
+ 0.21 0.43 0.36 85857143
+ 0.21 0.43 0.36 92928571
+ 0.21 0.43 0.36 100000000
+ 0.21 0.43 0.43 1000000
+ 0.21 0.43 0.43 8071429
+ 0.21 0.43 0.43 15142857
+ 0.21 0.43 0.43 22214286
+ 0.21 0.43 0.43 29285714
+ 0.21 0.43 0.43 36357143
+ 0.21 0.43 0.43 43428571
+ 0.21 0.43 0.43 50500000
+ 0.21 0.43 0.43 57571429
+ 0.21 0.43 0.43 64642857
+ 0.21 0.43 0.43 71714286
+ 0.21 0.43 0.43 78785714
+ 0.21 0.43 0.43 85857143
+ 0.21 0.43 0.43 92928571
+ 0.21 0.43 0.43 100000000
+ 0.21 0.43 0.50 1000000
+ 0.21 0.43 0.50 8071429
+ 0.21 0.43 0.50 15142857
+ 0.21 0.43 0.50 22214286
+ 0.21 0.43 0.50 29285714
+ 0.21 0.43 0.50 36357143
+ 0.21 0.43 0.50 43428571
+ 0.21 0.43 0.50 50500000
+ 0.21 0.43 0.50 57571429
+ 0.21 0.43 0.50 64642857
+ 0.21 0.43 0.50 71714286
+ 0.21 0.43 0.50 78785714
+ 0.21 0.43 0.50 85857143
+ 0.21 0.43 0.50 92928571
+ 0.21 0.43 0.50 100000000
+ 0.21 0.43 0.57 1000000
+ 0.21 0.43 0.57 8071429
+ 0.21 0.43 0.57 15142857
+ 0.21 0.43 0.57 22214286
+ 0.21 0.43 0.57 29285714
+ 0.21 0.43 0.57 36357143
+ 0.21 0.43 0.57 43428571
+ 0.21 0.43 0.57 50500000
+ 0.21 0.43 0.57 57571429
+ 0.21 0.43 0.57 64642857
+ 0.21 0.43 0.57 71714286
+ 0.21 0.43 0.57 78785714
+ 0.21 0.43 0.57 85857143
+ 0.21 0.43 0.57 92928571
+ 0.21 0.43 0.57 100000000
+ 0.21 0.43 0.64 1000000
+ 0.21 0.43 0.64 8071429
+ 0.21 0.43 0.64 15142857
+ 0.21 0.43 0.64 22214286
+ 0.21 0.43 0.64 29285714
+ 0.21 0.43 0.64 36357143
+ 0.21 0.43 0.64 43428571
+ 0.21 0.43 0.64 50500000
+ 0.21 0.43 0.64 57571429
+ 0.21 0.43 0.64 64642857
+ 0.21 0.43 0.64 71714286
+ 0.21 0.43 0.64 78785714
+ 0.21 0.43 0.64 85857143
+ 0.21 0.43 0.64 92928571
+ 0.21 0.43 0.64 100000000
+ 0.21 0.43 0.71 1000000
+ 0.21 0.43 0.71 8071429
+ 0.21 0.43 0.71 15142857
+ 0.21 0.43 0.71 22214286
+ 0.21 0.43 0.71 29285714
+ 0.21 0.43 0.71 36357143
+ 0.21 0.43 0.71 43428571
+ 0.21 0.43 0.71 50500000
+ 0.21 0.43 0.71 57571429
+ 0.21 0.43 0.71 64642857
+ 0.21 0.43 0.71 71714286
+ 0.21 0.43 0.71 78785714
+ 0.21 0.43 0.71 85857143
+ 0.21 0.43 0.71 92928571
+ 0.21 0.43 0.71 100000000
+ 0.21 0.43 0.79 1000000
+ 0.21 0.43 0.79 8071429
+ 0.21 0.43 0.79 15142857
+ 0.21 0.43 0.79 22214286
+ 0.21 0.43 0.79 29285714
+ 0.21 0.43 0.79 36357143
+ 0.21 0.43 0.79 43428571
+ 0.21 0.43 0.79 50500000
+ 0.21 0.43 0.79 57571429
+ 0.21 0.43 0.79 64642857
+ 0.21 0.43 0.79 71714286
+ 0.21 0.43 0.79 78785714
+ 0.21 0.43 0.79 85857143
+ 0.21 0.43 0.79 92928571
+ 0.21 0.43 0.79 100000000
+ 0.21 0.43 0.86 1000000
+ 0.21 0.43 0.86 8071429
+ 0.21 0.43 0.86 15142857
+ 0.21 0.43 0.86 22214286
+ 0.21 0.43 0.86 29285714
+ 0.21 0.43 0.86 36357143
+ 0.21 0.43 0.86 43428571
+ 0.21 0.43 0.86 50500000
+ 0.21 0.43 0.86 57571429
+ 0.21 0.43 0.86 64642857
+ 0.21 0.43 0.86 71714286
+ 0.21 0.43 0.86 78785714
+ 0.21 0.43 0.86 85857143
+ 0.21 0.43 0.86 92928571
+ 0.21 0.43 0.86 100000000
+ 0.21 0.43 0.93 1000000
+ 0.21 0.43 0.93 8071429
+ 0.21 0.43 0.93 15142857
+ 0.21 0.43 0.93 22214286
+ 0.21 0.43 0.93 29285714
+ 0.21 0.43 0.93 36357143
+ 0.21 0.43 0.93 43428571
+ 0.21 0.43 0.93 50500000
+ 0.21 0.43 0.93 57571429
+ 0.21 0.43 0.93 64642857
+ 0.21 0.43 0.93 71714286
+ 0.21 0.43 0.93 78785714
+ 0.21 0.43 0.93 85857143
+ 0.21 0.43 0.93 92928571
+ 0.21 0.43 0.93 100000000
+ 0.21 0.43 1.00 1000000
+ 0.21 0.43 1.00 8071429
+ 0.21 0.43 1.00 15142857
+ 0.21 0.43 1.00 22214286
+ 0.21 0.43 1.00 29285714
+ 0.21 0.43 1.00 36357143
+ 0.21 0.43 1.00 43428571
+ 0.21 0.43 1.00 50500000
+ 0.21 0.43 1.00 57571429
+ 0.21 0.43 1.00 64642857
+ 0.21 0.43 1.00 71714286
+ 0.21 0.43 1.00 78785714
+ 0.21 0.43 1.00 85857143
+ 0.21 0.43 1.00 92928571
+ 0.21 0.43 1.00 100000000
+ 0.21 0.50 0.00 1000000
+ 0.21 0.50 0.00 8071429
+ 0.21 0.50 0.00 15142857
+ 0.21 0.50 0.00 22214286
+ 0.21 0.50 0.00 29285714
+ 0.21 0.50 0.00 36357143
+ 0.21 0.50 0.00 43428571
+ 0.21 0.50 0.00 50500000
+ 0.21 0.50 0.00 57571429
+ 0.21 0.50 0.00 64642857
+ 0.21 0.50 0.00 71714286
+ 0.21 0.50 0.00 78785714
+ 0.21 0.50 0.00 85857143
+ 0.21 0.50 0.00 92928571
+ 0.21 0.50 0.00 100000000
+ 0.21 0.50 0.07 1000000
+ 0.21 0.50 0.07 8071429
+ 0.21 0.50 0.07 15142857
+ 0.21 0.50 0.07 22214286
+ 0.21 0.50 0.07 29285714
+ 0.21 0.50 0.07 36357143
+ 0.21 0.50 0.07 43428571
+ 0.21 0.50 0.07 50500000
+ 0.21 0.50 0.07 57571429
+ 0.21 0.50 0.07 64642857
+ 0.21 0.50 0.07 71714286
+ 0.21 0.50 0.07 78785714
+ 0.21 0.50 0.07 85857143
+ 0.21 0.50 0.07 92928571
+ 0.21 0.50 0.07 100000000
+ 0.21 0.50 0.14 1000000
+ 0.21 0.50 0.14 8071429
+ 0.21 0.50 0.14 15142857
+ 0.21 0.50 0.14 22214286
+ 0.21 0.50 0.14 29285714
+ 0.21 0.50 0.14 36357143
+ 0.21 0.50 0.14 43428571
+ 0.21 0.50 0.14 50500000
+ 0.21 0.50 0.14 57571429
+ 0.21 0.50 0.14 64642857
+ 0.21 0.50 0.14 71714286
+ 0.21 0.50 0.14 78785714
+ 0.21 0.50 0.14 85857143
+ 0.21 0.50 0.14 92928571
+ 0.21 0.50 0.14 100000000
+ 0.21 0.50 0.21 1000000
+ 0.21 0.50 0.21 8071429
+ 0.21 0.50 0.21 15142857
+ 0.21 0.50 0.21 22214286
+ 0.21 0.50 0.21 29285714
+ 0.21 0.50 0.21 36357143
+ 0.21 0.50 0.21 43428571
+ 0.21 0.50 0.21 50500000
+ 0.21 0.50 0.21 57571429
+ 0.21 0.50 0.21 64642857
+ 0.21 0.50 0.21 71714286
+ 0.21 0.50 0.21 78785714
+ 0.21 0.50 0.21 85857143
+ 0.21 0.50 0.21 92928571
+ 0.21 0.50 0.21 100000000
+ 0.21 0.50 0.29 1000000
+ 0.21 0.50 0.29 8071429
+ 0.21 0.50 0.29 15142857
+ 0.21 0.50 0.29 22214286
+ 0.21 0.50 0.29 29285714
+ 0.21 0.50 0.29 36357143
+ 0.21 0.50 0.29 43428571
+ 0.21 0.50 0.29 50500000
+ 0.21 0.50 0.29 57571429
+ 0.21 0.50 0.29 64642857
+ 0.21 0.50 0.29 71714286
+ 0.21 0.50 0.29 78785714
+ 0.21 0.50 0.29 85857143
+ 0.21 0.50 0.29 92928571
+ 0.21 0.50 0.29 100000000
+ 0.21 0.50 0.36 1000000
+ 0.21 0.50 0.36 8071429
+ 0.21 0.50 0.36 15142857
+ 0.21 0.50 0.36 22214286
+ 0.21 0.50 0.36 29285714
+ 0.21 0.50 0.36 36357143
+ 0.21 0.50 0.36 43428571
+ 0.21 0.50 0.36 50500000
+ 0.21 0.50 0.36 57571429
+ 0.21 0.50 0.36 64642857
+ 0.21 0.50 0.36 71714286
+ 0.21 0.50 0.36 78785714
+ 0.21 0.50 0.36 85857143
+ 0.21 0.50 0.36 92928571
+ 0.21 0.50 0.36 100000000
+ 0.21 0.50 0.43 1000000
+ 0.21 0.50 0.43 8071429
+ 0.21 0.50 0.43 15142857
+ 0.21 0.50 0.43 22214286
+ 0.21 0.50 0.43 29285714
+ 0.21 0.50 0.43 36357143
+ 0.21 0.50 0.43 43428571
+ 0.21 0.50 0.43 50500000
+ 0.21 0.50 0.43 57571429
+ 0.21 0.50 0.43 64642857
+ 0.21 0.50 0.43 71714286
+ 0.21 0.50 0.43 78785714
+ 0.21 0.50 0.43 85857143
+ 0.21 0.50 0.43 92928571
+ 0.21 0.50 0.43 100000000
+ 0.21 0.50 0.50 1000000
+ 0.21 0.50 0.50 8071429
+ 0.21 0.50 0.50 15142857
+ 0.21 0.50 0.50 22214286
+ 0.21 0.50 0.50 29285714
+ 0.21 0.50 0.50 36357143
+ 0.21 0.50 0.50 43428571
+ 0.21 0.50 0.50 50500000
+ 0.21 0.50 0.50 57571429
+ 0.21 0.50 0.50 64642857
+ 0.21 0.50 0.50 71714286
+ 0.21 0.50 0.50 78785714
+ 0.21 0.50 0.50 85857143
+ 0.21 0.50 0.50 92928571
+ 0.21 0.50 0.50 100000000
+ 0.21 0.50 0.57 1000000
+ 0.21 0.50 0.57 8071429
+ 0.21 0.50 0.57 15142857
+ 0.21 0.50 0.57 22214286
+ 0.21 0.50 0.57 29285714
+ 0.21 0.50 0.57 36357143
+ 0.21 0.50 0.57 43428571
+ 0.21 0.50 0.57 50500000
+ 0.21 0.50 0.57 57571429
+ 0.21 0.50 0.57 64642857
+ 0.21 0.50 0.57 71714286
+ 0.21 0.50 0.57 78785714
+ 0.21 0.50 0.57 85857143
+ 0.21 0.50 0.57 92928571
+ 0.21 0.50 0.57 100000000
+ 0.21 0.50 0.64 1000000
+ 0.21 0.50 0.64 8071429
+ 0.21 0.50 0.64 15142857
+ 0.21 0.50 0.64 22214286
+ 0.21 0.50 0.64 29285714
+ 0.21 0.50 0.64 36357143
+ 0.21 0.50 0.64 43428571
+ 0.21 0.50 0.64 50500000
+ 0.21 0.50 0.64 57571429
+ 0.21 0.50 0.64 64642857
+ 0.21 0.50 0.64 71714286
+ 0.21 0.50 0.64 78785714
+ 0.21 0.50 0.64 85857143
+ 0.21 0.50 0.64 92928571
+ 0.21 0.50 0.64 100000000
+ 0.21 0.50 0.71 1000000
+ 0.21 0.50 0.71 8071429
+ 0.21 0.50 0.71 15142857
+ 0.21 0.50 0.71 22214286
+ 0.21 0.50 0.71 29285714
+ 0.21 0.50 0.71 36357143
+ 0.21 0.50 0.71 43428571
+ 0.21 0.50 0.71 50500000
+ 0.21 0.50 0.71 57571429
+ 0.21 0.50 0.71 64642857
+ 0.21 0.50 0.71 71714286
+ 0.21 0.50 0.71 78785714
+ 0.21 0.50 0.71 85857143
+ 0.21 0.50 0.71 92928571
+ 0.21 0.50 0.71 100000000
+ 0.21 0.50 0.79 1000000
+ 0.21 0.50 0.79 8071429
+ 0.21 0.50 0.79 15142857
+ 0.21 0.50 0.79 22214286
+ 0.21 0.50 0.79 29285714
+ 0.21 0.50 0.79 36357143
+ 0.21 0.50 0.79 43428571
+ 0.21 0.50 0.79 50500000
+ 0.21 0.50 0.79 57571429
+ 0.21 0.50 0.79 64642857
+ 0.21 0.50 0.79 71714286
+ 0.21 0.50 0.79 78785714
+ 0.21 0.50 0.79 85857143
+ 0.21 0.50 0.79 92928571
+ 0.21 0.50 0.79 100000000
+ 0.21 0.50 0.86 1000000
+ 0.21 0.50 0.86 8071429
+ 0.21 0.50 0.86 15142857
+ 0.21 0.50 0.86 22214286
+ 0.21 0.50 0.86 29285714
+ 0.21 0.50 0.86 36357143
+ 0.21 0.50 0.86 43428571
+ 0.21 0.50 0.86 50500000
+ 0.21 0.50 0.86 57571429
+ 0.21 0.50 0.86 64642857
+ 0.21 0.50 0.86 71714286
+ 0.21 0.50 0.86 78785714
+ 0.21 0.50 0.86 85857143
+ 0.21 0.50 0.86 92928571
+ 0.21 0.50 0.86 100000000
+ 0.21 0.50 0.93 1000000
+ 0.21 0.50 0.93 8071429
+ 0.21 0.50 0.93 15142857
+ 0.21 0.50 0.93 22214286
+ 0.21 0.50 0.93 29285714
+ 0.21 0.50 0.93 36357143
+ 0.21 0.50 0.93 43428571
+ 0.21 0.50 0.93 50500000
+ 0.21 0.50 0.93 57571429
+ 0.21 0.50 0.93 64642857
+ 0.21 0.50 0.93 71714286
+ 0.21 0.50 0.93 78785714
+ 0.21 0.50 0.93 85857143
+ 0.21 0.50 0.93 92928571
+ 0.21 0.50 0.93 100000000
+ 0.21 0.50 1.00 1000000
+ 0.21 0.50 1.00 8071429
+ 0.21 0.50 1.00 15142857
+ 0.21 0.50 1.00 22214286
+ 0.21 0.50 1.00 29285714
+ 0.21 0.50 1.00 36357143
+ 0.21 0.50 1.00 43428571
+ 0.21 0.50 1.00 50500000
+ 0.21 0.50 1.00 57571429
+ 0.21 0.50 1.00 64642857
+ 0.21 0.50 1.00 71714286
+ 0.21 0.50 1.00 78785714
+ 0.21 0.50 1.00 85857143
+ 0.21 0.50 1.00 92928571
+ 0.21 0.50 1.00 100000000
+ 0.21 0.57 0.00 1000000
+ 0.21 0.57 0.00 8071429
+ 0.21 0.57 0.00 15142857
+ 0.21 0.57 0.00 22214286
+ 0.21 0.57 0.00 29285714
+ 0.21 0.57 0.00 36357143
+ 0.21 0.57 0.00 43428571
+ 0.21 0.57 0.00 50500000
+ 0.21 0.57 0.00 57571429
+ 0.21 0.57 0.00 64642857
+ 0.21 0.57 0.00 71714286
+ 0.21 0.57 0.00 78785714
+ 0.21 0.57 0.00 85857143
+ 0.21 0.57 0.00 92928571
+ 0.21 0.57 0.00 100000000
+ 0.21 0.57 0.07 1000000
+ 0.21 0.57 0.07 8071429
+ 0.21 0.57 0.07 15142857
+ 0.21 0.57 0.07 22214286
+ 0.21 0.57 0.07 29285714
+ 0.21 0.57 0.07 36357143
+ 0.21 0.57 0.07 43428571
+ 0.21 0.57 0.07 50500000
+ 0.21 0.57 0.07 57571429
+ 0.21 0.57 0.07 64642857
+ 0.21 0.57 0.07 71714286
+ 0.21 0.57 0.07 78785714
+ 0.21 0.57 0.07 85857143
+ 0.21 0.57 0.07 92928571
+ 0.21 0.57 0.07 100000000
+ 0.21 0.57 0.14 1000000
+ 0.21 0.57 0.14 8071429
+ 0.21 0.57 0.14 15142857
+ 0.21 0.57 0.14 22214286
+ 0.21 0.57 0.14 29285714
+ 0.21 0.57 0.14 36357143
+ 0.21 0.57 0.14 43428571
+ 0.21 0.57 0.14 50500000
+ 0.21 0.57 0.14 57571429
+ 0.21 0.57 0.14 64642857
+ 0.21 0.57 0.14 71714286
+ 0.21 0.57 0.14 78785714
+ 0.21 0.57 0.14 85857143
+ 0.21 0.57 0.14 92928571
+ 0.21 0.57 0.14 100000000
+ 0.21 0.57 0.21 1000000
+ 0.21 0.57 0.21 8071429
+ 0.21 0.57 0.21 15142857
+ 0.21 0.57 0.21 22214286
+ 0.21 0.57 0.21 29285714
+ 0.21 0.57 0.21 36357143
+ 0.21 0.57 0.21 43428571
+ 0.21 0.57 0.21 50500000
+ 0.21 0.57 0.21 57571429
+ 0.21 0.57 0.21 64642857
+ 0.21 0.57 0.21 71714286
+ 0.21 0.57 0.21 78785714
+ 0.21 0.57 0.21 85857143
+ 0.21 0.57 0.21 92928571
+ 0.21 0.57 0.21 100000000
+ 0.21 0.57 0.29 1000000
+ 0.21 0.57 0.29 8071429
+ 0.21 0.57 0.29 15142857
+ 0.21 0.57 0.29 22214286
+ 0.21 0.57 0.29 29285714
+ 0.21 0.57 0.29 36357143
+ 0.21 0.57 0.29 43428571
+ 0.21 0.57 0.29 50500000
+ 0.21 0.57 0.29 57571429
+ 0.21 0.57 0.29 64642857
+ 0.21 0.57 0.29 71714286
+ 0.21 0.57 0.29 78785714
+ 0.21 0.57 0.29 85857143
+ 0.21 0.57 0.29 92928571
+ 0.21 0.57 0.29 100000000
+ 0.21 0.57 0.36 1000000
+ 0.21 0.57 0.36 8071429
+ 0.21 0.57 0.36 15142857
+ 0.21 0.57 0.36 22214286
+ 0.21 0.57 0.36 29285714
+ 0.21 0.57 0.36 36357143
+ 0.21 0.57 0.36 43428571
+ 0.21 0.57 0.36 50500000
+ 0.21 0.57 0.36 57571429
+ 0.21 0.57 0.36 64642857
+ 0.21 0.57 0.36 71714286
+ 0.21 0.57 0.36 78785714
+ 0.21 0.57 0.36 85857143
+ 0.21 0.57 0.36 92928571
+ 0.21 0.57 0.36 100000000
+ 0.21 0.57 0.43 1000000
+ 0.21 0.57 0.43 8071429
+ 0.21 0.57 0.43 15142857
+ 0.21 0.57 0.43 22214286
+ 0.21 0.57 0.43 29285714
+ 0.21 0.57 0.43 36357143
+ 0.21 0.57 0.43 43428571
+ 0.21 0.57 0.43 50500000
+ 0.21 0.57 0.43 57571429
+ 0.21 0.57 0.43 64642857
+ 0.21 0.57 0.43 71714286
+ 0.21 0.57 0.43 78785714
+ 0.21 0.57 0.43 85857143
+ 0.21 0.57 0.43 92928571
+ 0.21 0.57 0.43 100000000
+ 0.21 0.57 0.50 1000000
+ 0.21 0.57 0.50 8071429
+ 0.21 0.57 0.50 15142857
+ 0.21 0.57 0.50 22214286
+ 0.21 0.57 0.50 29285714
+ 0.21 0.57 0.50 36357143
+ 0.21 0.57 0.50 43428571
+ 0.21 0.57 0.50 50500000
+ 0.21 0.57 0.50 57571429
+ 0.21 0.57 0.50 64642857
+ 0.21 0.57 0.50 71714286
+ 0.21 0.57 0.50 78785714
+ 0.21 0.57 0.50 85857143
+ 0.21 0.57 0.50 92928571
+ 0.21 0.57 0.50 100000000
+ 0.21 0.57 0.57 1000000
+ 0.21 0.57 0.57 8071429
+ 0.21 0.57 0.57 15142857
+ 0.21 0.57 0.57 22214286
+ 0.21 0.57 0.57 29285714
+ 0.21 0.57 0.57 36357143
+ 0.21 0.57 0.57 43428571
+ 0.21 0.57 0.57 50500000
+ 0.21 0.57 0.57 57571429
+ 0.21 0.57 0.57 64642857
+ 0.21 0.57 0.57 71714286
+ 0.21 0.57 0.57 78785714
+ 0.21 0.57 0.57 85857143
+ 0.21 0.57 0.57 92928571
+ 0.21 0.57 0.57 100000000
+ 0.21 0.57 0.64 1000000
+ 0.21 0.57 0.64 8071429
+ 0.21 0.57 0.64 15142857
+ 0.21 0.57 0.64 22214286
+ 0.21 0.57 0.64 29285714
+ 0.21 0.57 0.64 36357143
+ 0.21 0.57 0.64 43428571
+ 0.21 0.57 0.64 50500000
+ 0.21 0.57 0.64 57571429
+ 0.21 0.57 0.64 64642857
+ 0.21 0.57 0.64 71714286
+ 0.21 0.57 0.64 78785714
+ 0.21 0.57 0.64 85857143
+ 0.21 0.57 0.64 92928571
+ 0.21 0.57 0.64 100000000
+ 0.21 0.57 0.71 1000000
+ 0.21 0.57 0.71 8071429
+ 0.21 0.57 0.71 15142857
+ 0.21 0.57 0.71 22214286
+ 0.21 0.57 0.71 29285714
+ 0.21 0.57 0.71 36357143
+ 0.21 0.57 0.71 43428571
+ 0.21 0.57 0.71 50500000
+ 0.21 0.57 0.71 57571429
+ 0.21 0.57 0.71 64642857
+ 0.21 0.57 0.71 71714286
+ 0.21 0.57 0.71 78785714
+ 0.21 0.57 0.71 85857143
+ 0.21 0.57 0.71 92928571
+ 0.21 0.57 0.71 100000000
+ 0.21 0.57 0.79 1000000
+ 0.21 0.57 0.79 8071429
+ 0.21 0.57 0.79 15142857
+ 0.21 0.57 0.79 22214286
+ 0.21 0.57 0.79 29285714
+ 0.21 0.57 0.79 36357143
+ 0.21 0.57 0.79 43428571
+ 0.21 0.57 0.79 50500000
+ 0.21 0.57 0.79 57571429
+ 0.21 0.57 0.79 64642857
+ 0.21 0.57 0.79 71714286
+ 0.21 0.57 0.79 78785714
+ 0.21 0.57 0.79 85857143
+ 0.21 0.57 0.79 92928571
+ 0.21 0.57 0.79 100000000
+ 0.21 0.57 0.86 1000000
+ 0.21 0.57 0.86 8071429
+ 0.21 0.57 0.86 15142857
+ 0.21 0.57 0.86 22214286
+ 0.21 0.57 0.86 29285714
+ 0.21 0.57 0.86 36357143
+ 0.21 0.57 0.86 43428571
+ 0.21 0.57 0.86 50500000
+ 0.21 0.57 0.86 57571429
+ 0.21 0.57 0.86 64642857
+ 0.21 0.57 0.86 71714286
+ 0.21 0.57 0.86 78785714
+ 0.21 0.57 0.86 85857143
+ 0.21 0.57 0.86 92928571
+ 0.21 0.57 0.86 100000000
+ 0.21 0.57 0.93 1000000
+ 0.21 0.57 0.93 8071429
+ 0.21 0.57 0.93 15142857
+ 0.21 0.57 0.93 22214286
+ 0.21 0.57 0.93 29285714
+ 0.21 0.57 0.93 36357143
+ 0.21 0.57 0.93 43428571
+ 0.21 0.57 0.93 50500000
+ 0.21 0.57 0.93 57571429
+ 0.21 0.57 0.93 64642857
+ 0.21 0.57 0.93 71714286
+ 0.21 0.57 0.93 78785714
+ 0.21 0.57 0.93 85857143
+ 0.21 0.57 0.93 92928571
+ 0.21 0.57 0.93 100000000
+ 0.21 0.57 1.00 1000000
+ 0.21 0.57 1.00 8071429
+ 0.21 0.57 1.00 15142857
+ 0.21 0.57 1.00 22214286
+ 0.21 0.57 1.00 29285714
+ 0.21 0.57 1.00 36357143
+ 0.21 0.57 1.00 43428571
+ 0.21 0.57 1.00 50500000
+ 0.21 0.57 1.00 57571429
+ 0.21 0.57 1.00 64642857
+ 0.21 0.57 1.00 71714286
+ 0.21 0.57 1.00 78785714
+ 0.21 0.57 1.00 85857143
+ 0.21 0.57 1.00 92928571
+ 0.21 0.57 1.00 100000000
+ 0.21 0.64 0.00 1000000
+ 0.21 0.64 0.00 8071429
+ 0.21 0.64 0.00 15142857
+ 0.21 0.64 0.00 22214286
+ 0.21 0.64 0.00 29285714
+ 0.21 0.64 0.00 36357143
+ 0.21 0.64 0.00 43428571
+ 0.21 0.64 0.00 50500000
+ 0.21 0.64 0.00 57571429
+ 0.21 0.64 0.00 64642857
+ 0.21 0.64 0.00 71714286
+ 0.21 0.64 0.00 78785714
+ 0.21 0.64 0.00 85857143
+ 0.21 0.64 0.00 92928571
+ 0.21 0.64 0.00 100000000
+ 0.21 0.64 0.07 1000000
+ 0.21 0.64 0.07 8071429
+ 0.21 0.64 0.07 15142857
+ 0.21 0.64 0.07 22214286
+ 0.21 0.64 0.07 29285714
+ 0.21 0.64 0.07 36357143
+ 0.21 0.64 0.07 43428571
+ 0.21 0.64 0.07 50500000
+ 0.21 0.64 0.07 57571429
+ 0.21 0.64 0.07 64642857
+ 0.21 0.64 0.07 71714286
+ 0.21 0.64 0.07 78785714
+ 0.21 0.64 0.07 85857143
+ 0.21 0.64 0.07 92928571
+ 0.21 0.64 0.07 100000000
+ 0.21 0.64 0.14 1000000
+ 0.21 0.64 0.14 8071429
+ 0.21 0.64 0.14 15142857
+ 0.21 0.64 0.14 22214286
+ 0.21 0.64 0.14 29285714
+ 0.21 0.64 0.14 36357143
+ 0.21 0.64 0.14 43428571
+ 0.21 0.64 0.14 50500000
+ 0.21 0.64 0.14 57571429
+ 0.21 0.64 0.14 64642857
+ 0.21 0.64 0.14 71714286
+ 0.21 0.64 0.14 78785714
+ 0.21 0.64 0.14 85857143
+ 0.21 0.64 0.14 92928571
+ 0.21 0.64 0.14 100000000
+ 0.21 0.64 0.21 1000000
+ 0.21 0.64 0.21 8071429
+ 0.21 0.64 0.21 15142857
+ 0.21 0.64 0.21 22214286
+ 0.21 0.64 0.21 29285714
+ 0.21 0.64 0.21 36357143
+ 0.21 0.64 0.21 43428571
+ 0.21 0.64 0.21 50500000
+ 0.21 0.64 0.21 57571429
+ 0.21 0.64 0.21 64642857
+ 0.21 0.64 0.21 71714286
+ 0.21 0.64 0.21 78785714
+ 0.21 0.64 0.21 85857143
+ 0.21 0.64 0.21 92928571
+ 0.21 0.64 0.21 100000000
+ 0.21 0.64 0.29 1000000
+ 0.21 0.64 0.29 8071429
+ 0.21 0.64 0.29 15142857
+ 0.21 0.64 0.29 22214286
+ 0.21 0.64 0.29 29285714
+ 0.21 0.64 0.29 36357143
+ 0.21 0.64 0.29 43428571
+ 0.21 0.64 0.29 50500000
+ 0.21 0.64 0.29 57571429
+ 0.21 0.64 0.29 64642857
+ 0.21 0.64 0.29 71714286
+ 0.21 0.64 0.29 78785714
+ 0.21 0.64 0.29 85857143
+ 0.21 0.64 0.29 92928571
+ 0.21 0.64 0.29 100000000
+ 0.21 0.64 0.36 1000000
+ 0.21 0.64 0.36 8071429
+ 0.21 0.64 0.36 15142857
+ 0.21 0.64 0.36 22214286
+ 0.21 0.64 0.36 29285714
+ 0.21 0.64 0.36 36357143
+ 0.21 0.64 0.36 43428571
+ 0.21 0.64 0.36 50500000
+ 0.21 0.64 0.36 57571429
+ 0.21 0.64 0.36 64642857
+ 0.21 0.64 0.36 71714286
+ 0.21 0.64 0.36 78785714
+ 0.21 0.64 0.36 85857143
+ 0.21 0.64 0.36 92928571
+ 0.21 0.64 0.36 100000000
+ 0.21 0.64 0.43 1000000
+ 0.21 0.64 0.43 8071429
+ 0.21 0.64 0.43 15142857
+ 0.21 0.64 0.43 22214286
+ 0.21 0.64 0.43 29285714
+ 0.21 0.64 0.43 36357143
+ 0.21 0.64 0.43 43428571
+ 0.21 0.64 0.43 50500000
+ 0.21 0.64 0.43 57571429
+ 0.21 0.64 0.43 64642857
+ 0.21 0.64 0.43 71714286
+ 0.21 0.64 0.43 78785714
+ 0.21 0.64 0.43 85857143
+ 0.21 0.64 0.43 92928571
+ 0.21 0.64 0.43 100000000
+ 0.21 0.64 0.50 1000000
+ 0.21 0.64 0.50 8071429
+ 0.21 0.64 0.50 15142857
+ 0.21 0.64 0.50 22214286
+ 0.21 0.64 0.50 29285714
+ 0.21 0.64 0.50 36357143
+ 0.21 0.64 0.50 43428571
+ 0.21 0.64 0.50 50500000
+ 0.21 0.64 0.50 57571429
+ 0.21 0.64 0.50 64642857
+ 0.21 0.64 0.50 71714286
+ 0.21 0.64 0.50 78785714
+ 0.21 0.64 0.50 85857143
+ 0.21 0.64 0.50 92928571
+ 0.21 0.64 0.50 100000000
+ 0.21 0.64 0.57 1000000
+ 0.21 0.64 0.57 8071429
+ 0.21 0.64 0.57 15142857
+ 0.21 0.64 0.57 22214286
+ 0.21 0.64 0.57 29285714
+ 0.21 0.64 0.57 36357143
+ 0.21 0.64 0.57 43428571
+ 0.21 0.64 0.57 50500000
+ 0.21 0.64 0.57 57571429
+ 0.21 0.64 0.57 64642857
+ 0.21 0.64 0.57 71714286
+ 0.21 0.64 0.57 78785714
+ 0.21 0.64 0.57 85857143
+ 0.21 0.64 0.57 92928571
+ 0.21 0.64 0.57 100000000
+ 0.21 0.64 0.64 1000000
+ 0.21 0.64 0.64 8071429
+ 0.21 0.64 0.64 15142857
+ 0.21 0.64 0.64 22214286
+ 0.21 0.64 0.64 29285714
+ 0.21 0.64 0.64 36357143
+ 0.21 0.64 0.64 43428571
+ 0.21 0.64 0.64 50500000
+ 0.21 0.64 0.64 57571429
+ 0.21 0.64 0.64 64642857
+ 0.21 0.64 0.64 71714286
+ 0.21 0.64 0.64 78785714
+ 0.21 0.64 0.64 85857143
+ 0.21 0.64 0.64 92928571
+ 0.21 0.64 0.64 100000000
+ 0.21 0.64 0.71 1000000
+ 0.21 0.64 0.71 8071429
+ 0.21 0.64 0.71 15142857
+ 0.21 0.64 0.71 22214286
+ 0.21 0.64 0.71 29285714
+ 0.21 0.64 0.71 36357143
+ 0.21 0.64 0.71 43428571
+ 0.21 0.64 0.71 50500000
+ 0.21 0.64 0.71 57571429
+ 0.21 0.64 0.71 64642857
+ 0.21 0.64 0.71 71714286
+ 0.21 0.64 0.71 78785714
+ 0.21 0.64 0.71 85857143
+ 0.21 0.64 0.71 92928571
+ 0.21 0.64 0.71 100000000
+ 0.21 0.64 0.79 1000000
+ 0.21 0.64 0.79 8071429
+ 0.21 0.64 0.79 15142857
+ 0.21 0.64 0.79 22214286
+ 0.21 0.64 0.79 29285714
+ 0.21 0.64 0.79 36357143
+ 0.21 0.64 0.79 43428571
+ 0.21 0.64 0.79 50500000
+ 0.21 0.64 0.79 57571429
+ 0.21 0.64 0.79 64642857
+ 0.21 0.64 0.79 71714286
+ 0.21 0.64 0.79 78785714
+ 0.21 0.64 0.79 85857143
+ 0.21 0.64 0.79 92928571
+ 0.21 0.64 0.79 100000000
+ 0.21 0.64 0.86 1000000
+ 0.21 0.64 0.86 8071429
+ 0.21 0.64 0.86 15142857
+ 0.21 0.64 0.86 22214286
+ 0.21 0.64 0.86 29285714
+ 0.21 0.64 0.86 36357143
+ 0.21 0.64 0.86 43428571
+ 0.21 0.64 0.86 50500000
+ 0.21 0.64 0.86 57571429
+ 0.21 0.64 0.86 64642857
+ 0.21 0.64 0.86 71714286
+ 0.21 0.64 0.86 78785714
+ 0.21 0.64 0.86 85857143
+ 0.21 0.64 0.86 92928571
+ 0.21 0.64 0.86 100000000
+ 0.21 0.64 0.93 1000000
+ 0.21 0.64 0.93 8071429
+ 0.21 0.64 0.93 15142857
+ 0.21 0.64 0.93 22214286
+ 0.21 0.64 0.93 29285714
+ 0.21 0.64 0.93 36357143
+ 0.21 0.64 0.93 43428571
+ 0.21 0.64 0.93 50500000
+ 0.21 0.64 0.93 57571429
+ 0.21 0.64 0.93 64642857
+ 0.21 0.64 0.93 71714286
+ 0.21 0.64 0.93 78785714
+ 0.21 0.64 0.93 85857143
+ 0.21 0.64 0.93 92928571
+ 0.21 0.64 0.93 100000000
+ 0.21 0.64 1.00 1000000
+ 0.21 0.64 1.00 8071429
+ 0.21 0.64 1.00 15142857
+ 0.21 0.64 1.00 22214286
+ 0.21 0.64 1.00 29285714
+ 0.21 0.64 1.00 36357143
+ 0.21 0.64 1.00 43428571
+ 0.21 0.64 1.00 50500000
+ 0.21 0.64 1.00 57571429
+ 0.21 0.64 1.00 64642857
+ 0.21 0.64 1.00 71714286
+ 0.21 0.64 1.00 78785714
+ 0.21 0.64 1.00 85857143
+ 0.21 0.64 1.00 92928571
+ 0.21 0.64 1.00 100000000
+ 0.21 0.71 0.00 1000000
+ 0.21 0.71 0.00 8071429
+ 0.21 0.71 0.00 15142857
+ 0.21 0.71 0.00 22214286
+ 0.21 0.71 0.00 29285714
+ 0.21 0.71 0.00 36357143
+ 0.21 0.71 0.00 43428571
+ 0.21 0.71 0.00 50500000
+ 0.21 0.71 0.00 57571429
+ 0.21 0.71 0.00 64642857
+ 0.21 0.71 0.00 71714286
+ 0.21 0.71 0.00 78785714
+ 0.21 0.71 0.00 85857143
+ 0.21 0.71 0.00 92928571
+ 0.21 0.71 0.00 100000000
+ 0.21 0.71 0.07 1000000
+ 0.21 0.71 0.07 8071429
+ 0.21 0.71 0.07 15142857
+ 0.21 0.71 0.07 22214286
+ 0.21 0.71 0.07 29285714
+ 0.21 0.71 0.07 36357143
+ 0.21 0.71 0.07 43428571
+ 0.21 0.71 0.07 50500000
+ 0.21 0.71 0.07 57571429
+ 0.21 0.71 0.07 64642857
+ 0.21 0.71 0.07 71714286
+ 0.21 0.71 0.07 78785714
+ 0.21 0.71 0.07 85857143
+ 0.21 0.71 0.07 92928571
+ 0.21 0.71 0.07 100000000
+ 0.21 0.71 0.14 1000000
+ 0.21 0.71 0.14 8071429
+ 0.21 0.71 0.14 15142857
+ 0.21 0.71 0.14 22214286
+ 0.21 0.71 0.14 29285714
+ 0.21 0.71 0.14 36357143
+ 0.21 0.71 0.14 43428571
+ 0.21 0.71 0.14 50500000
+ 0.21 0.71 0.14 57571429
+ 0.21 0.71 0.14 64642857
+ 0.21 0.71 0.14 71714286
+ 0.21 0.71 0.14 78785714
+ 0.21 0.71 0.14 85857143
+ 0.21 0.71 0.14 92928571
+ 0.21 0.71 0.14 100000000
+ 0.21 0.71 0.21 1000000
+ 0.21 0.71 0.21 8071429
+ 0.21 0.71 0.21 15142857
+ 0.21 0.71 0.21 22214286
+ 0.21 0.71 0.21 29285714
+ 0.21 0.71 0.21 36357143
+ 0.21 0.71 0.21 43428571
+ 0.21 0.71 0.21 50500000
+ 0.21 0.71 0.21 57571429
+ 0.21 0.71 0.21 64642857
+ 0.21 0.71 0.21 71714286
+ 0.21 0.71 0.21 78785714
+ 0.21 0.71 0.21 85857143
+ 0.21 0.71 0.21 92928571
+ 0.21 0.71 0.21 100000000
+ 0.21 0.71 0.29 1000000
+ 0.21 0.71 0.29 8071429
+ 0.21 0.71 0.29 15142857
+ 0.21 0.71 0.29 22214286
+ 0.21 0.71 0.29 29285714
+ 0.21 0.71 0.29 36357143
+ 0.21 0.71 0.29 43428571
+ 0.21 0.71 0.29 50500000
+ 0.21 0.71 0.29 57571429
+ 0.21 0.71 0.29 64642857
+ 0.21 0.71 0.29 71714286
+ 0.21 0.71 0.29 78785714
+ 0.21 0.71 0.29 85857143
+ 0.21 0.71 0.29 92928571
+ 0.21 0.71 0.29 100000000
+ 0.21 0.71 0.36 1000000
+ 0.21 0.71 0.36 8071429
+ 0.21 0.71 0.36 15142857
+ 0.21 0.71 0.36 22214286
+ 0.21 0.71 0.36 29285714
+ 0.21 0.71 0.36 36357143
+ 0.21 0.71 0.36 43428571
+ 0.21 0.71 0.36 50500000
+ 0.21 0.71 0.36 57571429
+ 0.21 0.71 0.36 64642857
+ 0.21 0.71 0.36 71714286
+ 0.21 0.71 0.36 78785714
+ 0.21 0.71 0.36 85857143
+ 0.21 0.71 0.36 92928571
+ 0.21 0.71 0.36 100000000
+ 0.21 0.71 0.43 1000000
+ 0.21 0.71 0.43 8071429
+ 0.21 0.71 0.43 15142857
+ 0.21 0.71 0.43 22214286
+ 0.21 0.71 0.43 29285714
+ 0.21 0.71 0.43 36357143
+ 0.21 0.71 0.43 43428571
+ 0.21 0.71 0.43 50500000
+ 0.21 0.71 0.43 57571429
+ 0.21 0.71 0.43 64642857
+ 0.21 0.71 0.43 71714286
+ 0.21 0.71 0.43 78785714
+ 0.21 0.71 0.43 85857143
+ 0.21 0.71 0.43 92928571
+ 0.21 0.71 0.43 100000000
+ 0.21 0.71 0.50 1000000
+ 0.21 0.71 0.50 8071429
+ 0.21 0.71 0.50 15142857
+ 0.21 0.71 0.50 22214286
+ 0.21 0.71 0.50 29285714
+ 0.21 0.71 0.50 36357143
+ 0.21 0.71 0.50 43428571
+ 0.21 0.71 0.50 50500000
+ 0.21 0.71 0.50 57571429
+ 0.21 0.71 0.50 64642857
+ 0.21 0.71 0.50 71714286
+ 0.21 0.71 0.50 78785714
+ 0.21 0.71 0.50 85857143
+ 0.21 0.71 0.50 92928571
+ 0.21 0.71 0.50 100000000
+ 0.21 0.71 0.57 1000000
+ 0.21 0.71 0.57 8071429
+ 0.21 0.71 0.57 15142857
+ 0.21 0.71 0.57 22214286
+ 0.21 0.71 0.57 29285714
+ 0.21 0.71 0.57 36357143
+ 0.21 0.71 0.57 43428571
+ 0.21 0.71 0.57 50500000
+ 0.21 0.71 0.57 57571429
+ 0.21 0.71 0.57 64642857
+ 0.21 0.71 0.57 71714286
+ 0.21 0.71 0.57 78785714
+ 0.21 0.71 0.57 85857143
+ 0.21 0.71 0.57 92928571
+ 0.21 0.71 0.57 100000000
+ 0.21 0.71 0.64 1000000
+ 0.21 0.71 0.64 8071429
+ 0.21 0.71 0.64 15142857
+ 0.21 0.71 0.64 22214286
+ 0.21 0.71 0.64 29285714
+ 0.21 0.71 0.64 36357143
+ 0.21 0.71 0.64 43428571
+ 0.21 0.71 0.64 50500000
+ 0.21 0.71 0.64 57571429
+ 0.21 0.71 0.64 64642857
+ 0.21 0.71 0.64 71714286
+ 0.21 0.71 0.64 78785714
+ 0.21 0.71 0.64 85857143
+ 0.21 0.71 0.64 92928571
+ 0.21 0.71 0.64 100000000
+ 0.21 0.71 0.71 1000000
+ 0.21 0.71 0.71 8071429
+ 0.21 0.71 0.71 15142857
+ 0.21 0.71 0.71 22214286
+ 0.21 0.71 0.71 29285714
+ 0.21 0.71 0.71 36357143
+ 0.21 0.71 0.71 43428571
+ 0.21 0.71 0.71 50500000
+ 0.21 0.71 0.71 57571429
+ 0.21 0.71 0.71 64642857
+ 0.21 0.71 0.71 71714286
+ 0.21 0.71 0.71 78785714
+ 0.21 0.71 0.71 85857143
+ 0.21 0.71 0.71 92928571
+ 0.21 0.71 0.71 100000000
+ 0.21 0.71 0.79 1000000
+ 0.21 0.71 0.79 8071429
+ 0.21 0.71 0.79 15142857
+ 0.21 0.71 0.79 22214286
+ 0.21 0.71 0.79 29285714
+ 0.21 0.71 0.79 36357143
+ 0.21 0.71 0.79 43428571
+ 0.21 0.71 0.79 50500000
+ 0.21 0.71 0.79 57571429
+ 0.21 0.71 0.79 64642857
+ 0.21 0.71 0.79 71714286
+ 0.21 0.71 0.79 78785714
+ 0.21 0.71 0.79 85857143
+ 0.21 0.71 0.79 92928571
+ 0.21 0.71 0.79 100000000
+ 0.21 0.71 0.86 1000000
+ 0.21 0.71 0.86 8071429
+ 0.21 0.71 0.86 15142857
+ 0.21 0.71 0.86 22214286
+ 0.21 0.71 0.86 29285714
+ 0.21 0.71 0.86 36357143
+ 0.21 0.71 0.86 43428571
+ 0.21 0.71 0.86 50500000
+ 0.21 0.71 0.86 57571429
+ 0.21 0.71 0.86 64642857
+ 0.21 0.71 0.86 71714286
+ 0.21 0.71 0.86 78785714
+ 0.21 0.71 0.86 85857143
+ 0.21 0.71 0.86 92928571
+ 0.21 0.71 0.86 100000000
+ 0.21 0.71 0.93 1000000
+ 0.21 0.71 0.93 8071429
+ 0.21 0.71 0.93 15142857
+ 0.21 0.71 0.93 22214286
+ 0.21 0.71 0.93 29285714
+ 0.21 0.71 0.93 36357143
+ 0.21 0.71 0.93 43428571
+ 0.21 0.71 0.93 50500000
+ 0.21 0.71 0.93 57571429
+ 0.21 0.71 0.93 64642857
+ 0.21 0.71 0.93 71714286
+ 0.21 0.71 0.93 78785714
+ 0.21 0.71 0.93 85857143
+ 0.21 0.71 0.93 92928571
+ 0.21 0.71 0.93 100000000
+ 0.21 0.71 1.00 1000000
+ 0.21 0.71 1.00 8071429
+ 0.21 0.71 1.00 15142857
+ 0.21 0.71 1.00 22214286
+ 0.21 0.71 1.00 29285714
+ 0.21 0.71 1.00 36357143
+ 0.21 0.71 1.00 43428571
+ 0.21 0.71 1.00 50500000
+ 0.21 0.71 1.00 57571429
+ 0.21 0.71 1.00 64642857
+ 0.21 0.71 1.00 71714286
+ 0.21 0.71 1.00 78785714
+ 0.21 0.71 1.00 85857143
+ 0.21 0.71 1.00 92928571
+ 0.21 0.71 1.00 100000000
+ 0.21 0.79 0.00 1000000
+ 0.21 0.79 0.00 8071429
+ 0.21 0.79 0.00 15142857
+ 0.21 0.79 0.00 22214286
+ 0.21 0.79 0.00 29285714
+ 0.21 0.79 0.00 36357143
+ 0.21 0.79 0.00 43428571
+ 0.21 0.79 0.00 50500000
+ 0.21 0.79 0.00 57571429
+ 0.21 0.79 0.00 64642857
+ 0.21 0.79 0.00 71714286
+ 0.21 0.79 0.00 78785714
+ 0.21 0.79 0.00 85857143
+ 0.21 0.79 0.00 92928571
+ 0.21 0.79 0.00 100000000
+ 0.21 0.79 0.07 1000000
+ 0.21 0.79 0.07 8071429
+ 0.21 0.79 0.07 15142857
+ 0.21 0.79 0.07 22214286
+ 0.21 0.79 0.07 29285714
+ 0.21 0.79 0.07 36357143
+ 0.21 0.79 0.07 43428571
+ 0.21 0.79 0.07 50500000
+ 0.21 0.79 0.07 57571429
+ 0.21 0.79 0.07 64642857
+ 0.21 0.79 0.07 71714286
+ 0.21 0.79 0.07 78785714
+ 0.21 0.79 0.07 85857143
+ 0.21 0.79 0.07 92928571
+ 0.21 0.79 0.07 100000000
+ 0.21 0.79 0.14 1000000
+ 0.21 0.79 0.14 8071429
+ 0.21 0.79 0.14 15142857
+ 0.21 0.79 0.14 22214286
+ 0.21 0.79 0.14 29285714
+ 0.21 0.79 0.14 36357143
+ 0.21 0.79 0.14 43428571
+ 0.21 0.79 0.14 50500000
+ 0.21 0.79 0.14 57571429
+ 0.21 0.79 0.14 64642857
+ 0.21 0.79 0.14 71714286
+ 0.21 0.79 0.14 78785714
+ 0.21 0.79 0.14 85857143
+ 0.21 0.79 0.14 92928571
+ 0.21 0.79 0.14 100000000
+ 0.21 0.79 0.21 1000000
+ 0.21 0.79 0.21 8071429
+ 0.21 0.79 0.21 15142857
+ 0.21 0.79 0.21 22214286
+ 0.21 0.79 0.21 29285714
+ 0.21 0.79 0.21 36357143
+ 0.21 0.79 0.21 43428571
+ 0.21 0.79 0.21 50500000
+ 0.21 0.79 0.21 57571429
+ 0.21 0.79 0.21 64642857
+ 0.21 0.79 0.21 71714286
+ 0.21 0.79 0.21 78785714
+ 0.21 0.79 0.21 85857143
+ 0.21 0.79 0.21 92928571
+ 0.21 0.79 0.21 100000000
+ 0.21 0.79 0.29 1000000
+ 0.21 0.79 0.29 8071429
+ 0.21 0.79 0.29 15142857
+ 0.21 0.79 0.29 22214286
+ 0.21 0.79 0.29 29285714
+ 0.21 0.79 0.29 36357143
+ 0.21 0.79 0.29 43428571
+ 0.21 0.79 0.29 50500000
+ 0.21 0.79 0.29 57571429
+ 0.21 0.79 0.29 64642857
+ 0.21 0.79 0.29 71714286
+ 0.21 0.79 0.29 78785714
+ 0.21 0.79 0.29 85857143
+ 0.21 0.79 0.29 92928571
+ 0.21 0.79 0.29 100000000
+ 0.21 0.79 0.36 1000000
+ 0.21 0.79 0.36 8071429
+ 0.21 0.79 0.36 15142857
+ 0.21 0.79 0.36 22214286
+ 0.21 0.79 0.36 29285714
+ 0.21 0.79 0.36 36357143
+ 0.21 0.79 0.36 43428571
+ 0.21 0.79 0.36 50500000
+ 0.21 0.79 0.36 57571429
+ 0.21 0.79 0.36 64642857
+ 0.21 0.79 0.36 71714286
+ 0.21 0.79 0.36 78785714
+ 0.21 0.79 0.36 85857143
+ 0.21 0.79 0.36 92928571
+ 0.21 0.79 0.36 100000000
+ 0.21 0.79 0.43 1000000
+ 0.21 0.79 0.43 8071429
+ 0.21 0.79 0.43 15142857
+ 0.21 0.79 0.43 22214286
+ 0.21 0.79 0.43 29285714
+ 0.21 0.79 0.43 36357143
+ 0.21 0.79 0.43 43428571
+ 0.21 0.79 0.43 50500000
+ 0.21 0.79 0.43 57571429
+ 0.21 0.79 0.43 64642857
+ 0.21 0.79 0.43 71714286
+ 0.21 0.79 0.43 78785714
+ 0.21 0.79 0.43 85857143
+ 0.21 0.79 0.43 92928571
+ 0.21 0.79 0.43 100000000
+ 0.21 0.79 0.50 1000000
+ 0.21 0.79 0.50 8071429
+ 0.21 0.79 0.50 15142857
+ 0.21 0.79 0.50 22214286
+ 0.21 0.79 0.50 29285714
+ 0.21 0.79 0.50 36357143
+ 0.21 0.79 0.50 43428571
+ 0.21 0.79 0.50 50500000
+ 0.21 0.79 0.50 57571429
+ 0.21 0.79 0.50 64642857
+ 0.21 0.79 0.50 71714286
+ 0.21 0.79 0.50 78785714
+ 0.21 0.79 0.50 85857143
+ 0.21 0.79 0.50 92928571
+ 0.21 0.79 0.50 100000000
+ 0.21 0.79 0.57 1000000
+ 0.21 0.79 0.57 8071429
+ 0.21 0.79 0.57 15142857
+ 0.21 0.79 0.57 22214286
+ 0.21 0.79 0.57 29285714
+ 0.21 0.79 0.57 36357143
+ 0.21 0.79 0.57 43428571
+ 0.21 0.79 0.57 50500000
+ 0.21 0.79 0.57 57571429
+ 0.21 0.79 0.57 64642857
+ 0.21 0.79 0.57 71714286
+ 0.21 0.79 0.57 78785714
+ 0.21 0.79 0.57 85857143
+ 0.21 0.79 0.57 92928571
+ 0.21 0.79 0.57 100000000
+ 0.21 0.79 0.64 1000000
+ 0.21 0.79 0.64 8071429
+ 0.21 0.79 0.64 15142857
+ 0.21 0.79 0.64 22214286
+ 0.21 0.79 0.64 29285714
+ 0.21 0.79 0.64 36357143
+ 0.21 0.79 0.64 43428571
+ 0.21 0.79 0.64 50500000
+ 0.21 0.79 0.64 57571429
+ 0.21 0.79 0.64 64642857
+ 0.21 0.79 0.64 71714286
+ 0.21 0.79 0.64 78785714
+ 0.21 0.79 0.64 85857143
+ 0.21 0.79 0.64 92928571
+ 0.21 0.79 0.64 100000000
+ 0.21 0.79 0.71 1000000
+ 0.21 0.79 0.71 8071429
+ 0.21 0.79 0.71 15142857
+ 0.21 0.79 0.71 22214286
+ 0.21 0.79 0.71 29285714
+ 0.21 0.79 0.71 36357143
+ 0.21 0.79 0.71 43428571
+ 0.21 0.79 0.71 50500000
+ 0.21 0.79 0.71 57571429
+ 0.21 0.79 0.71 64642857
+ 0.21 0.79 0.71 71714286
+ 0.21 0.79 0.71 78785714
+ 0.21 0.79 0.71 85857143
+ 0.21 0.79 0.71 92928571
+ 0.21 0.79 0.71 100000000
+ 0.21 0.79 0.79 1000000
+ 0.21 0.79 0.79 8071429
+ 0.21 0.79 0.79 15142857
+ 0.21 0.79 0.79 22214286
+ 0.21 0.79 0.79 29285714
+ 0.21 0.79 0.79 36357143
+ 0.21 0.79 0.79 43428571
+ 0.21 0.79 0.79 50500000
+ 0.21 0.79 0.79 57571429
+ 0.21 0.79 0.79 64642857
+ 0.21 0.79 0.79 71714286
+ 0.21 0.79 0.79 78785714
+ 0.21 0.79 0.79 85857143
+ 0.21 0.79 0.79 92928571
+ 0.21 0.79 0.79 100000000
+ 0.21 0.79 0.86 1000000
+ 0.21 0.79 0.86 8071429
+ 0.21 0.79 0.86 15142857
+ 0.21 0.79 0.86 22214286
+ 0.21 0.79 0.86 29285714
+ 0.21 0.79 0.86 36357143
+ 0.21 0.79 0.86 43428571
+ 0.21 0.79 0.86 50500000
+ 0.21 0.79 0.86 57571429
+ 0.21 0.79 0.86 64642857
+ 0.21 0.79 0.86 71714286
+ 0.21 0.79 0.86 78785714
+ 0.21 0.79 0.86 85857143
+ 0.21 0.79 0.86 92928571
+ 0.21 0.79 0.86 100000000
+ 0.21 0.79 0.93 1000000
+ 0.21 0.79 0.93 8071429
+ 0.21 0.79 0.93 15142857
+ 0.21 0.79 0.93 22214286
+ 0.21 0.79 0.93 29285714
+ 0.21 0.79 0.93 36357143
+ 0.21 0.79 0.93 43428571
+ 0.21 0.79 0.93 50500000
+ 0.21 0.79 0.93 57571429
+ 0.21 0.79 0.93 64642857
+ 0.21 0.79 0.93 71714286
+ 0.21 0.79 0.93 78785714
+ 0.21 0.79 0.93 85857143
+ 0.21 0.79 0.93 92928571
+ 0.21 0.79 0.93 100000000
+ 0.21 0.79 1.00 1000000
+ 0.21 0.79 1.00 8071429
+ 0.21 0.79 1.00 15142857
+ 0.21 0.79 1.00 22214286
+ 0.21 0.79 1.00 29285714
+ 0.21 0.79 1.00 36357143
+ 0.21 0.79 1.00 43428571
+ 0.21 0.79 1.00 50500000
+ 0.21 0.79 1.00 57571429
+ 0.21 0.79 1.00 64642857
+ 0.21 0.79 1.00 71714286
+ 0.21 0.79 1.00 78785714
+ 0.21 0.79 1.00 85857143
+ 0.21 0.79 1.00 92928571
+ 0.21 0.79 1.00 100000000
+ 0.21 0.86 0.00 1000000
+ 0.21 0.86 0.00 8071429
+ 0.21 0.86 0.00 15142857
+ 0.21 0.86 0.00 22214286
+ 0.21 0.86 0.00 29285714
+ 0.21 0.86 0.00 36357143
+ 0.21 0.86 0.00 43428571
+ 0.21 0.86 0.00 50500000
+ 0.21 0.86 0.00 57571429
+ 0.21 0.86 0.00 64642857
+ 0.21 0.86 0.00 71714286
+ 0.21 0.86 0.00 78785714
+ 0.21 0.86 0.00 85857143
+ 0.21 0.86 0.00 92928571
+ 0.21 0.86 0.00 100000000
+ 0.21 0.86 0.07 1000000
+ 0.21 0.86 0.07 8071429
+ 0.21 0.86 0.07 15142857
+ 0.21 0.86 0.07 22214286
+ 0.21 0.86 0.07 29285714
+ 0.21 0.86 0.07 36357143
+ 0.21 0.86 0.07 43428571
+ 0.21 0.86 0.07 50500000
+ 0.21 0.86 0.07 57571429
+ 0.21 0.86 0.07 64642857
+ 0.21 0.86 0.07 71714286
+ 0.21 0.86 0.07 78785714
+ 0.21 0.86 0.07 85857143
+ 0.21 0.86 0.07 92928571
+ 0.21 0.86 0.07 100000000
+ 0.21 0.86 0.14 1000000
+ 0.21 0.86 0.14 8071429
+ 0.21 0.86 0.14 15142857
+ 0.21 0.86 0.14 22214286
+ 0.21 0.86 0.14 29285714
+ 0.21 0.86 0.14 36357143
+ 0.21 0.86 0.14 43428571
+ 0.21 0.86 0.14 50500000
+ 0.21 0.86 0.14 57571429
+ 0.21 0.86 0.14 64642857
+ 0.21 0.86 0.14 71714286
+ 0.21 0.86 0.14 78785714
+ 0.21 0.86 0.14 85857143
+ 0.21 0.86 0.14 92928571
+ 0.21 0.86 0.14 100000000
+ 0.21 0.86 0.21 1000000
+ 0.21 0.86 0.21 8071429
+ 0.21 0.86 0.21 15142857
+ 0.21 0.86 0.21 22214286
+ 0.21 0.86 0.21 29285714
+ 0.21 0.86 0.21 36357143
+ 0.21 0.86 0.21 43428571
+ 0.21 0.86 0.21 50500000
+ 0.21 0.86 0.21 57571429
+ 0.21 0.86 0.21 64642857
+ 0.21 0.86 0.21 71714286
+ 0.21 0.86 0.21 78785714
+ 0.21 0.86 0.21 85857143
+ 0.21 0.86 0.21 92928571
+ 0.21 0.86 0.21 100000000
+ 0.21 0.86 0.29 1000000
+ 0.21 0.86 0.29 8071429
+ 0.21 0.86 0.29 15142857
+ 0.21 0.86 0.29 22214286
+ 0.21 0.86 0.29 29285714
+ 0.21 0.86 0.29 36357143
+ 0.21 0.86 0.29 43428571
+ 0.21 0.86 0.29 50500000
+ 0.21 0.86 0.29 57571429
+ 0.21 0.86 0.29 64642857
+ 0.21 0.86 0.29 71714286
+ 0.21 0.86 0.29 78785714
+ 0.21 0.86 0.29 85857143
+ 0.21 0.86 0.29 92928571
+ 0.21 0.86 0.29 100000000
+ 0.21 0.86 0.36 1000000
+ 0.21 0.86 0.36 8071429
+ 0.21 0.86 0.36 15142857
+ 0.21 0.86 0.36 22214286
+ 0.21 0.86 0.36 29285714
+ 0.21 0.86 0.36 36357143
+ 0.21 0.86 0.36 43428571
+ 0.21 0.86 0.36 50500000
+ 0.21 0.86 0.36 57571429
+ 0.21 0.86 0.36 64642857
+ 0.21 0.86 0.36 71714286
+ 0.21 0.86 0.36 78785714
+ 0.21 0.86 0.36 85857143
+ 0.21 0.86 0.36 92928571
+ 0.21 0.86 0.36 100000000
+ 0.21 0.86 0.43 1000000
+ 0.21 0.86 0.43 8071429
+ 0.21 0.86 0.43 15142857
+ 0.21 0.86 0.43 22214286
+ 0.21 0.86 0.43 29285714
+ 0.21 0.86 0.43 36357143
+ 0.21 0.86 0.43 43428571
+ 0.21 0.86 0.43 50500000
+ 0.21 0.86 0.43 57571429
+ 0.21 0.86 0.43 64642857
+ 0.21 0.86 0.43 71714286
+ 0.21 0.86 0.43 78785714
+ 0.21 0.86 0.43 85857143
+ 0.21 0.86 0.43 92928571
+ 0.21 0.86 0.43 100000000
+ 0.21 0.86 0.50 1000000
+ 0.21 0.86 0.50 8071429
+ 0.21 0.86 0.50 15142857
+ 0.21 0.86 0.50 22214286
+ 0.21 0.86 0.50 29285714
+ 0.21 0.86 0.50 36357143
+ 0.21 0.86 0.50 43428571
+ 0.21 0.86 0.50 50500000
+ 0.21 0.86 0.50 57571429
+ 0.21 0.86 0.50 64642857
+ 0.21 0.86 0.50 71714286
+ 0.21 0.86 0.50 78785714
+ 0.21 0.86 0.50 85857143
+ 0.21 0.86 0.50 92928571
+ 0.21 0.86 0.50 100000000
+ 0.21 0.86 0.57 1000000
+ 0.21 0.86 0.57 8071429
+ 0.21 0.86 0.57 15142857
+ 0.21 0.86 0.57 22214286
+ 0.21 0.86 0.57 29285714
+ 0.21 0.86 0.57 36357143
+ 0.21 0.86 0.57 43428571
+ 0.21 0.86 0.57 50500000
+ 0.21 0.86 0.57 57571429
+ 0.21 0.86 0.57 64642857
+ 0.21 0.86 0.57 71714286
+ 0.21 0.86 0.57 78785714
+ 0.21 0.86 0.57 85857143
+ 0.21 0.86 0.57 92928571
+ 0.21 0.86 0.57 100000000
+ 0.21 0.86 0.64 1000000
+ 0.21 0.86 0.64 8071429
+ 0.21 0.86 0.64 15142857
+ 0.21 0.86 0.64 22214286
+ 0.21 0.86 0.64 29285714
+ 0.21 0.86 0.64 36357143
+ 0.21 0.86 0.64 43428571
+ 0.21 0.86 0.64 50500000
+ 0.21 0.86 0.64 57571429
+ 0.21 0.86 0.64 64642857
+ 0.21 0.86 0.64 71714286
+ 0.21 0.86 0.64 78785714
+ 0.21 0.86 0.64 85857143
+ 0.21 0.86 0.64 92928571
+ 0.21 0.86 0.64 100000000
+ 0.21 0.86 0.71 1000000
+ 0.21 0.86 0.71 8071429
+ 0.21 0.86 0.71 15142857
+ 0.21 0.86 0.71 22214286
+ 0.21 0.86 0.71 29285714
+ 0.21 0.86 0.71 36357143
+ 0.21 0.86 0.71 43428571
+ 0.21 0.86 0.71 50500000
+ 0.21 0.86 0.71 57571429
+ 0.21 0.86 0.71 64642857
+ 0.21 0.86 0.71 71714286
+ 0.21 0.86 0.71 78785714
+ 0.21 0.86 0.71 85857143
+ 0.21 0.86 0.71 92928571
+ 0.21 0.86 0.71 100000000
+ 0.21 0.86 0.79 1000000
+ 0.21 0.86 0.79 8071429
+ 0.21 0.86 0.79 15142857
+ 0.21 0.86 0.79 22214286
+ 0.21 0.86 0.79 29285714
+ 0.21 0.86 0.79 36357143
+ 0.21 0.86 0.79 43428571
+ 0.21 0.86 0.79 50500000
+ 0.21 0.86 0.79 57571429
+ 0.21 0.86 0.79 64642857
+ 0.21 0.86 0.79 71714286
+ 0.21 0.86 0.79 78785714
+ 0.21 0.86 0.79 85857143
+ 0.21 0.86 0.79 92928571
+ 0.21 0.86 0.79 100000000
+ 0.21 0.86 0.86 1000000
+ 0.21 0.86 0.86 8071429
+ 0.21 0.86 0.86 15142857
+ 0.21 0.86 0.86 22214286
+ 0.21 0.86 0.86 29285714
+ 0.21 0.86 0.86 36357143
+ 0.21 0.86 0.86 43428571
+ 0.21 0.86 0.86 50500000
+ 0.21 0.86 0.86 57571429
+ 0.21 0.86 0.86 64642857
+ 0.21 0.86 0.86 71714286
+ 0.21 0.86 0.86 78785714
+ 0.21 0.86 0.86 85857143
+ 0.21 0.86 0.86 92928571
+ 0.21 0.86 0.86 100000000
+ 0.21 0.86 0.93 1000000
+ 0.21 0.86 0.93 8071429
+ 0.21 0.86 0.93 15142857
+ 0.21 0.86 0.93 22214286
+ 0.21 0.86 0.93 29285714
+ 0.21 0.86 0.93 36357143
+ 0.21 0.86 0.93 43428571
+ 0.21 0.86 0.93 50500000
+ 0.21 0.86 0.93 57571429
+ 0.21 0.86 0.93 64642857
+ 0.21 0.86 0.93 71714286
+ 0.21 0.86 0.93 78785714
+ 0.21 0.86 0.93 85857143
+ 0.21 0.86 0.93 92928571
+ 0.21 0.86 0.93 100000000
+ 0.21 0.86 1.00 1000000
+ 0.21 0.86 1.00 8071429
+ 0.21 0.86 1.00 15142857
+ 0.21 0.86 1.00 22214286
+ 0.21 0.86 1.00 29285714
+ 0.21 0.86 1.00 36357143
+ 0.21 0.86 1.00 43428571
+ 0.21 0.86 1.00 50500000
+ 0.21 0.86 1.00 57571429
+ 0.21 0.86 1.00 64642857
+ 0.21 0.86 1.00 71714286
+ 0.21 0.86 1.00 78785714
+ 0.21 0.86 1.00 85857143
+ 0.21 0.86 1.00 92928571
+ 0.21 0.86 1.00 100000000
+ 0.21 0.93 0.00 1000000
+ 0.21 0.93 0.00 8071429
+ 0.21 0.93 0.00 15142857
+ 0.21 0.93 0.00 22214286
+ 0.21 0.93 0.00 29285714
+ 0.21 0.93 0.00 36357143
+ 0.21 0.93 0.00 43428571
+ 0.21 0.93 0.00 50500000
+ 0.21 0.93 0.00 57571429
+ 0.21 0.93 0.00 64642857
+ 0.21 0.93 0.00 71714286
+ 0.21 0.93 0.00 78785714
+ 0.21 0.93 0.00 85857143
+ 0.21 0.93 0.00 92928571
+ 0.21 0.93 0.00 100000000
+ 0.21 0.93 0.07 1000000
+ 0.21 0.93 0.07 8071429
+ 0.21 0.93 0.07 15142857
+ 0.21 0.93 0.07 22214286
+ 0.21 0.93 0.07 29285714
+ 0.21 0.93 0.07 36357143
+ 0.21 0.93 0.07 43428571
+ 0.21 0.93 0.07 50500000
+ 0.21 0.93 0.07 57571429
+ 0.21 0.93 0.07 64642857
+ 0.21 0.93 0.07 71714286
+ 0.21 0.93 0.07 78785714
+ 0.21 0.93 0.07 85857143
+ 0.21 0.93 0.07 92928571
+ 0.21 0.93 0.07 100000000
+ 0.21 0.93 0.14 1000000
+ 0.21 0.93 0.14 8071429
+ 0.21 0.93 0.14 15142857
+ 0.21 0.93 0.14 22214286
+ 0.21 0.93 0.14 29285714
+ 0.21 0.93 0.14 36357143
+ 0.21 0.93 0.14 43428571
+ 0.21 0.93 0.14 50500000
+ 0.21 0.93 0.14 57571429
+ 0.21 0.93 0.14 64642857
+ 0.21 0.93 0.14 71714286
+ 0.21 0.93 0.14 78785714
+ 0.21 0.93 0.14 85857143
+ 0.21 0.93 0.14 92928571
+ 0.21 0.93 0.14 100000000
+ 0.21 0.93 0.21 1000000
+ 0.21 0.93 0.21 8071429
+ 0.21 0.93 0.21 15142857
+ 0.21 0.93 0.21 22214286
+ 0.21 0.93 0.21 29285714
+ 0.21 0.93 0.21 36357143
+ 0.21 0.93 0.21 43428571
+ 0.21 0.93 0.21 50500000
+ 0.21 0.93 0.21 57571429
+ 0.21 0.93 0.21 64642857
+ 0.21 0.93 0.21 71714286
+ 0.21 0.93 0.21 78785714
+ 0.21 0.93 0.21 85857143
+ 0.21 0.93 0.21 92928571
+ 0.21 0.93 0.21 100000000
+ 0.21 0.93 0.29 1000000
+ 0.21 0.93 0.29 8071429
+ 0.21 0.93 0.29 15142857
+ 0.21 0.93 0.29 22214286
+ 0.21 0.93 0.29 29285714
+ 0.21 0.93 0.29 36357143
+ 0.21 0.93 0.29 43428571
+ 0.21 0.93 0.29 50500000
+ 0.21 0.93 0.29 57571429
+ 0.21 0.93 0.29 64642857
+ 0.21 0.93 0.29 71714286
+ 0.21 0.93 0.29 78785714
+ 0.21 0.93 0.29 85857143
+ 0.21 0.93 0.29 92928571
+ 0.21 0.93 0.29 100000000
+ 0.21 0.93 0.36 1000000
+ 0.21 0.93 0.36 8071429
+ 0.21 0.93 0.36 15142857
+ 0.21 0.93 0.36 22214286
+ 0.21 0.93 0.36 29285714
+ 0.21 0.93 0.36 36357143
+ 0.21 0.93 0.36 43428571
+ 0.21 0.93 0.36 50500000
+ 0.21 0.93 0.36 57571429
+ 0.21 0.93 0.36 64642857
+ 0.21 0.93 0.36 71714286
+ 0.21 0.93 0.36 78785714
+ 0.21 0.93 0.36 85857143
+ 0.21 0.93 0.36 92928571
+ 0.21 0.93 0.36 100000000
+ 0.21 0.93 0.43 1000000
+ 0.21 0.93 0.43 8071429
+ 0.21 0.93 0.43 15142857
+ 0.21 0.93 0.43 22214286
+ 0.21 0.93 0.43 29285714
+ 0.21 0.93 0.43 36357143
+ 0.21 0.93 0.43 43428571
+ 0.21 0.93 0.43 50500000
+ 0.21 0.93 0.43 57571429
+ 0.21 0.93 0.43 64642857
+ 0.21 0.93 0.43 71714286
+ 0.21 0.93 0.43 78785714
+ 0.21 0.93 0.43 85857143
+ 0.21 0.93 0.43 92928571
+ 0.21 0.93 0.43 100000000
+ 0.21 0.93 0.50 1000000
+ 0.21 0.93 0.50 8071429
+ 0.21 0.93 0.50 15142857
+ 0.21 0.93 0.50 22214286
+ 0.21 0.93 0.50 29285714
+ 0.21 0.93 0.50 36357143
+ 0.21 0.93 0.50 43428571
+ 0.21 0.93 0.50 50500000
+ 0.21 0.93 0.50 57571429
+ 0.21 0.93 0.50 64642857
+ 0.21 0.93 0.50 71714286
+ 0.21 0.93 0.50 78785714
+ 0.21 0.93 0.50 85857143
+ 0.21 0.93 0.50 92928571
+ 0.21 0.93 0.50 100000000
+ 0.21 0.93 0.57 1000000
+ 0.21 0.93 0.57 8071429
+ 0.21 0.93 0.57 15142857
+ 0.21 0.93 0.57 22214286
+ 0.21 0.93 0.57 29285714
+ 0.21 0.93 0.57 36357143
+ 0.21 0.93 0.57 43428571
+ 0.21 0.93 0.57 50500000
+ 0.21 0.93 0.57 57571429
+ 0.21 0.93 0.57 64642857
+ 0.21 0.93 0.57 71714286
+ 0.21 0.93 0.57 78785714
+ 0.21 0.93 0.57 85857143
+ 0.21 0.93 0.57 92928571
+ 0.21 0.93 0.57 100000000
+ 0.21 0.93 0.64 1000000
+ 0.21 0.93 0.64 8071429
+ 0.21 0.93 0.64 15142857
+ 0.21 0.93 0.64 22214286
+ 0.21 0.93 0.64 29285714
+ 0.21 0.93 0.64 36357143
+ 0.21 0.93 0.64 43428571
+ 0.21 0.93 0.64 50500000
+ 0.21 0.93 0.64 57571429
+ 0.21 0.93 0.64 64642857
+ 0.21 0.93 0.64 71714286
+ 0.21 0.93 0.64 78785714
+ 0.21 0.93 0.64 85857143
+ 0.21 0.93 0.64 92928571
+ 0.21 0.93 0.64 100000000
+ 0.21 0.93 0.71 1000000
+ 0.21 0.93 0.71 8071429
+ 0.21 0.93 0.71 15142857
+ 0.21 0.93 0.71 22214286
+ 0.21 0.93 0.71 29285714
+ 0.21 0.93 0.71 36357143
+ 0.21 0.93 0.71 43428571
+ 0.21 0.93 0.71 50500000
+ 0.21 0.93 0.71 57571429
+ 0.21 0.93 0.71 64642857
+ 0.21 0.93 0.71 71714286
+ 0.21 0.93 0.71 78785714
+ 0.21 0.93 0.71 85857143
+ 0.21 0.93 0.71 92928571
+ 0.21 0.93 0.71 100000000
+ 0.21 0.93 0.79 1000000
+ 0.21 0.93 0.79 8071429
+ 0.21 0.93 0.79 15142857
+ 0.21 0.93 0.79 22214286
+ 0.21 0.93 0.79 29285714
+ 0.21 0.93 0.79 36357143
+ 0.21 0.93 0.79 43428571
+ 0.21 0.93 0.79 50500000
+ 0.21 0.93 0.79 57571429
+ 0.21 0.93 0.79 64642857
+ 0.21 0.93 0.79 71714286
+ 0.21 0.93 0.79 78785714
+ 0.21 0.93 0.79 85857143
+ 0.21 0.93 0.79 92928571
+ 0.21 0.93 0.79 100000000
+ 0.21 0.93 0.86 1000000
+ 0.21 0.93 0.86 8071429
+ 0.21 0.93 0.86 15142857
+ 0.21 0.93 0.86 22214286
+ 0.21 0.93 0.86 29285714
+ 0.21 0.93 0.86 36357143
+ 0.21 0.93 0.86 43428571
+ 0.21 0.93 0.86 50500000
+ 0.21 0.93 0.86 57571429
+ 0.21 0.93 0.86 64642857
+ 0.21 0.93 0.86 71714286
+ 0.21 0.93 0.86 78785714
+ 0.21 0.93 0.86 85857143
+ 0.21 0.93 0.86 92928571
+ 0.21 0.93 0.86 100000000
+ 0.21 0.93 0.93 1000000
+ 0.21 0.93 0.93 8071429
+ 0.21 0.93 0.93 15142857
+ 0.21 0.93 0.93 22214286
+ 0.21 0.93 0.93 29285714
+ 0.21 0.93 0.93 36357143
+ 0.21 0.93 0.93 43428571
+ 0.21 0.93 0.93 50500000
+ 0.21 0.93 0.93 57571429
+ 0.21 0.93 0.93 64642857
+ 0.21 0.93 0.93 71714286
+ 0.21 0.93 0.93 78785714
+ 0.21 0.93 0.93 85857143
+ 0.21 0.93 0.93 92928571
+ 0.21 0.93 0.93 100000000
+ 0.21 0.93 1.00 1000000
+ 0.21 0.93 1.00 8071429
+ 0.21 0.93 1.00 15142857
+ 0.21 0.93 1.00 22214286
+ 0.21 0.93 1.00 29285714
+ 0.21 0.93 1.00 36357143
+ 0.21 0.93 1.00 43428571
+ 0.21 0.93 1.00 50500000
+ 0.21 0.93 1.00 57571429
+ 0.21 0.93 1.00 64642857
+ 0.21 0.93 1.00 71714286
+ 0.21 0.93 1.00 78785714
+ 0.21 0.93 1.00 85857143
+ 0.21 0.93 1.00 92928571
+ 0.21 0.93 1.00 100000000
+ 0.21 1.00 0.00 1000000
+ 0.21 1.00 0.00 8071429
+ 0.21 1.00 0.00 15142857
+ 0.21 1.00 0.00 22214286
+ 0.21 1.00 0.00 29285714
+ 0.21 1.00 0.00 36357143
+ 0.21 1.00 0.00 43428571
+ 0.21 1.00 0.00 50500000
+ 0.21 1.00 0.00 57571429
+ 0.21 1.00 0.00 64642857
+ 0.21 1.00 0.00 71714286
+ 0.21 1.00 0.00 78785714
+ 0.21 1.00 0.00 85857143
+ 0.21 1.00 0.00 92928571
+ 0.21 1.00 0.00 100000000
+ 0.21 1.00 0.07 1000000
+ 0.21 1.00 0.07 8071429
+ 0.21 1.00 0.07 15142857
+ 0.21 1.00 0.07 22214286
+ 0.21 1.00 0.07 29285714
+ 0.21 1.00 0.07 36357143
+ 0.21 1.00 0.07 43428571
+ 0.21 1.00 0.07 50500000
+ 0.21 1.00 0.07 57571429
+ 0.21 1.00 0.07 64642857
+ 0.21 1.00 0.07 71714286
+ 0.21 1.00 0.07 78785714
+ 0.21 1.00 0.07 85857143
+ 0.21 1.00 0.07 92928571
+ 0.21 1.00 0.07 100000000
+ 0.21 1.00 0.14 1000000
+ 0.21 1.00 0.14 8071429
+ 0.21 1.00 0.14 15142857
+ 0.21 1.00 0.14 22214286
+ 0.21 1.00 0.14 29285714
+ 0.21 1.00 0.14 36357143
+ 0.21 1.00 0.14 43428571
+ 0.21 1.00 0.14 50500000
+ 0.21 1.00 0.14 57571429
+ 0.21 1.00 0.14 64642857
+ 0.21 1.00 0.14 71714286
+ 0.21 1.00 0.14 78785714
+ 0.21 1.00 0.14 85857143
+ 0.21 1.00 0.14 92928571
+ 0.21 1.00 0.14 100000000
+ 0.21 1.00 0.21 1000000
+ 0.21 1.00 0.21 8071429
+ 0.21 1.00 0.21 15142857
+ 0.21 1.00 0.21 22214286
+ 0.21 1.00 0.21 29285714
+ 0.21 1.00 0.21 36357143
+ 0.21 1.00 0.21 43428571
+ 0.21 1.00 0.21 50500000
+ 0.21 1.00 0.21 57571429
+ 0.21 1.00 0.21 64642857
+ 0.21 1.00 0.21 71714286
+ 0.21 1.00 0.21 78785714
+ 0.21 1.00 0.21 85857143
+ 0.21 1.00 0.21 92928571
+ 0.21 1.00 0.21 100000000
+ 0.21 1.00 0.29 1000000
+ 0.21 1.00 0.29 8071429
+ 0.21 1.00 0.29 15142857
+ 0.21 1.00 0.29 22214286
+ 0.21 1.00 0.29 29285714
+ 0.21 1.00 0.29 36357143
+ 0.21 1.00 0.29 43428571
+ 0.21 1.00 0.29 50500000
+ 0.21 1.00 0.29 57571429
+ 0.21 1.00 0.29 64642857
+ 0.21 1.00 0.29 71714286
+ 0.21 1.00 0.29 78785714
+ 0.21 1.00 0.29 85857143
+ 0.21 1.00 0.29 92928571
+ 0.21 1.00 0.29 100000000
+ 0.21 1.00 0.36 1000000
+ 0.21 1.00 0.36 8071429
+ 0.21 1.00 0.36 15142857
+ 0.21 1.00 0.36 22214286
+ 0.21 1.00 0.36 29285714
+ 0.21 1.00 0.36 36357143
+ 0.21 1.00 0.36 43428571
+ 0.21 1.00 0.36 50500000
+ 0.21 1.00 0.36 57571429
+ 0.21 1.00 0.36 64642857
+ 0.21 1.00 0.36 71714286
+ 0.21 1.00 0.36 78785714
+ 0.21 1.00 0.36 85857143
+ 0.21 1.00 0.36 92928571
+ 0.21 1.00 0.36 100000000
+ 0.21 1.00 0.43 1000000
+ 0.21 1.00 0.43 8071429
+ 0.21 1.00 0.43 15142857
+ 0.21 1.00 0.43 22214286
+ 0.21 1.00 0.43 29285714
+ 0.21 1.00 0.43 36357143
+ 0.21 1.00 0.43 43428571
+ 0.21 1.00 0.43 50500000
+ 0.21 1.00 0.43 57571429
+ 0.21 1.00 0.43 64642857
+ 0.21 1.00 0.43 71714286
+ 0.21 1.00 0.43 78785714
+ 0.21 1.00 0.43 85857143
+ 0.21 1.00 0.43 92928571
+ 0.21 1.00 0.43 100000000
+ 0.21 1.00 0.50 1000000
+ 0.21 1.00 0.50 8071429
+ 0.21 1.00 0.50 15142857
+ 0.21 1.00 0.50 22214286
+ 0.21 1.00 0.50 29285714
+ 0.21 1.00 0.50 36357143
+ 0.21 1.00 0.50 43428571
+ 0.21 1.00 0.50 50500000
+ 0.21 1.00 0.50 57571429
+ 0.21 1.00 0.50 64642857
+ 0.21 1.00 0.50 71714286
+ 0.21 1.00 0.50 78785714
+ 0.21 1.00 0.50 85857143
+ 0.21 1.00 0.50 92928571
+ 0.21 1.00 0.50 100000000
+ 0.21 1.00 0.57 1000000
+ 0.21 1.00 0.57 8071429
+ 0.21 1.00 0.57 15142857
+ 0.21 1.00 0.57 22214286
+ 0.21 1.00 0.57 29285714
+ 0.21 1.00 0.57 36357143
+ 0.21 1.00 0.57 43428571
+ 0.21 1.00 0.57 50500000
+ 0.21 1.00 0.57 57571429
+ 0.21 1.00 0.57 64642857
+ 0.21 1.00 0.57 71714286
+ 0.21 1.00 0.57 78785714
+ 0.21 1.00 0.57 85857143
+ 0.21 1.00 0.57 92928571
+ 0.21 1.00 0.57 100000000
+ 0.21 1.00 0.64 1000000
+ 0.21 1.00 0.64 8071429
+ 0.21 1.00 0.64 15142857
+ 0.21 1.00 0.64 22214286
+ 0.21 1.00 0.64 29285714
+ 0.21 1.00 0.64 36357143
+ 0.21 1.00 0.64 43428571
+ 0.21 1.00 0.64 50500000
+ 0.21 1.00 0.64 57571429
+ 0.21 1.00 0.64 64642857
+ 0.21 1.00 0.64 71714286
+ 0.21 1.00 0.64 78785714
+ 0.21 1.00 0.64 85857143
+ 0.21 1.00 0.64 92928571
+ 0.21 1.00 0.64 100000000
+ 0.21 1.00 0.71 1000000
+ 0.21 1.00 0.71 8071429
+ 0.21 1.00 0.71 15142857
+ 0.21 1.00 0.71 22214286
+ 0.21 1.00 0.71 29285714
+ 0.21 1.00 0.71 36357143
+ 0.21 1.00 0.71 43428571
+ 0.21 1.00 0.71 50500000
+ 0.21 1.00 0.71 57571429
+ 0.21 1.00 0.71 64642857
+ 0.21 1.00 0.71 71714286
+ 0.21 1.00 0.71 78785714
+ 0.21 1.00 0.71 85857143
+ 0.21 1.00 0.71 92928571
+ 0.21 1.00 0.71 100000000
+ 0.21 1.00 0.79 1000000
+ 0.21 1.00 0.79 8071429
+ 0.21 1.00 0.79 15142857
+ 0.21 1.00 0.79 22214286
+ 0.21 1.00 0.79 29285714
+ 0.21 1.00 0.79 36357143
+ 0.21 1.00 0.79 43428571
+ 0.21 1.00 0.79 50500000
+ 0.21 1.00 0.79 57571429
+ 0.21 1.00 0.79 64642857
+ 0.21 1.00 0.79 71714286
+ 0.21 1.00 0.79 78785714
+ 0.21 1.00 0.79 85857143
+ 0.21 1.00 0.79 92928571
+ 0.21 1.00 0.79 100000000
+ 0.21 1.00 0.86 1000000
+ 0.21 1.00 0.86 8071429
+ 0.21 1.00 0.86 15142857
+ 0.21 1.00 0.86 22214286
+ 0.21 1.00 0.86 29285714
+ 0.21 1.00 0.86 36357143
+ 0.21 1.00 0.86 43428571
+ 0.21 1.00 0.86 50500000
+ 0.21 1.00 0.86 57571429
+ 0.21 1.00 0.86 64642857
+ 0.21 1.00 0.86 71714286
+ 0.21 1.00 0.86 78785714
+ 0.21 1.00 0.86 85857143
+ 0.21 1.00 0.86 92928571
+ 0.21 1.00 0.86 100000000
+ 0.21 1.00 0.93 1000000
+ 0.21 1.00 0.93 8071429
+ 0.21 1.00 0.93 15142857
+ 0.21 1.00 0.93 22214286
+ 0.21 1.00 0.93 29285714
+ 0.21 1.00 0.93 36357143
+ 0.21 1.00 0.93 43428571
+ 0.21 1.00 0.93 50500000
+ 0.21 1.00 0.93 57571429
+ 0.21 1.00 0.93 64642857
+ 0.21 1.00 0.93 71714286
+ 0.21 1.00 0.93 78785714
+ 0.21 1.00 0.93 85857143
+ 0.21 1.00 0.93 92928571
+ 0.21 1.00 0.93 100000000
+ 0.21 1.00 1.00 1000000
+ 0.21 1.00 1.00 8071429
+ 0.21 1.00 1.00 15142857
+ 0.21 1.00 1.00 22214286
+ 0.21 1.00 1.00 29285714
+ 0.21 1.00 1.00 36357143
+ 0.21 1.00 1.00 43428571
+ 0.21 1.00 1.00 50500000
+ 0.21 1.00 1.00 57571429
+ 0.21 1.00 1.00 64642857
+ 0.21 1.00 1.00 71714286
+ 0.21 1.00 1.00 78785714
+ 0.21 1.00 1.00 85857143
+ 0.21 1.00 1.00 92928571
+ 0.21 1.00 1.00 100000000
+ 0.29 0.00 0.00 1000000
+ 0.29 0.00 0.00 8071429
+ 0.29 0.00 0.00 15142857
+ 0.29 0.00 0.00 22214286
+ 0.29 0.00 0.00 29285714
+ 0.29 0.00 0.00 36357143
+ 0.29 0.00 0.00 43428571
+ 0.29 0.00 0.00 50500000
+ 0.29 0.00 0.00 57571429
+ 0.29 0.00 0.00 64642857
+ 0.29 0.00 0.00 71714286
+ 0.29 0.00 0.00 78785714
+ 0.29 0.00 0.00 85857143
+ 0.29 0.00 0.00 92928571
+ 0.29 0.00 0.00 100000000
+ 0.29 0.00 0.07 1000000
+ 0.29 0.00 0.07 8071429
+ 0.29 0.00 0.07 15142857
+ 0.29 0.00 0.07 22214286
+ 0.29 0.00 0.07 29285714
+ 0.29 0.00 0.07 36357143
+ 0.29 0.00 0.07 43428571
+ 0.29 0.00 0.07 50500000
+ 0.29 0.00 0.07 57571429
+ 0.29 0.00 0.07 64642857
+ 0.29 0.00 0.07 71714286
+ 0.29 0.00 0.07 78785714
+ 0.29 0.00 0.07 85857143
+ 0.29 0.00 0.07 92928571
+ 0.29 0.00 0.07 100000000
+ 0.29 0.00 0.14 1000000
+ 0.29 0.00 0.14 8071429
+ 0.29 0.00 0.14 15142857
+ 0.29 0.00 0.14 22214286
+ 0.29 0.00 0.14 29285714
+ 0.29 0.00 0.14 36357143
+ 0.29 0.00 0.14 43428571
+ 0.29 0.00 0.14 50500000
+ 0.29 0.00 0.14 57571429
+ 0.29 0.00 0.14 64642857
+ 0.29 0.00 0.14 71714286
+ 0.29 0.00 0.14 78785714
+ 0.29 0.00 0.14 85857143
+ 0.29 0.00 0.14 92928571
+ 0.29 0.00 0.14 100000000
+ 0.29 0.00 0.21 1000000
+ 0.29 0.00 0.21 8071429
+ 0.29 0.00 0.21 15142857
+ 0.29 0.00 0.21 22214286
+ 0.29 0.00 0.21 29285714
+ 0.29 0.00 0.21 36357143
+ 0.29 0.00 0.21 43428571
+ 0.29 0.00 0.21 50500000
+ 0.29 0.00 0.21 57571429
+ 0.29 0.00 0.21 64642857
+ 0.29 0.00 0.21 71714286
+ 0.29 0.00 0.21 78785714
+ 0.29 0.00 0.21 85857143
+ 0.29 0.00 0.21 92928571
+ 0.29 0.00 0.21 100000000
+ 0.29 0.00 0.29 1000000
+ 0.29 0.00 0.29 8071429
+ 0.29 0.00 0.29 15142857
+ 0.29 0.00 0.29 22214286
+ 0.29 0.00 0.29 29285714
+ 0.29 0.00 0.29 36357143
+ 0.29 0.00 0.29 43428571
+ 0.29 0.00 0.29 50500000
+ 0.29 0.00 0.29 57571429
+ 0.29 0.00 0.29 64642857
+ 0.29 0.00 0.29 71714286
+ 0.29 0.00 0.29 78785714
+ 0.29 0.00 0.29 85857143
+ 0.29 0.00 0.29 92928571
+ 0.29 0.00 0.29 100000000
+ 0.29 0.00 0.36 1000000
+ 0.29 0.00 0.36 8071429
+ 0.29 0.00 0.36 15142857
+ 0.29 0.00 0.36 22214286
+ 0.29 0.00 0.36 29285714
+ 0.29 0.00 0.36 36357143
+ 0.29 0.00 0.36 43428571
+ 0.29 0.00 0.36 50500000
+ 0.29 0.00 0.36 57571429
+ 0.29 0.00 0.36 64642857
+ 0.29 0.00 0.36 71714286
+ 0.29 0.00 0.36 78785714
+ 0.29 0.00 0.36 85857143
+ 0.29 0.00 0.36 92928571
+ 0.29 0.00 0.36 100000000
+ 0.29 0.00 0.43 1000000
+ 0.29 0.00 0.43 8071429
+ 0.29 0.00 0.43 15142857
+ 0.29 0.00 0.43 22214286
+ 0.29 0.00 0.43 29285714
+ 0.29 0.00 0.43 36357143
+ 0.29 0.00 0.43 43428571
+ 0.29 0.00 0.43 50500000
+ 0.29 0.00 0.43 57571429
+ 0.29 0.00 0.43 64642857
+ 0.29 0.00 0.43 71714286
+ 0.29 0.00 0.43 78785714
+ 0.29 0.00 0.43 85857143
+ 0.29 0.00 0.43 92928571
+ 0.29 0.00 0.43 100000000
+ 0.29 0.00 0.50 1000000
+ 0.29 0.00 0.50 8071429
+ 0.29 0.00 0.50 15142857
+ 0.29 0.00 0.50 22214286
+ 0.29 0.00 0.50 29285714
+ 0.29 0.00 0.50 36357143
+ 0.29 0.00 0.50 43428571
+ 0.29 0.00 0.50 50500000
+ 0.29 0.00 0.50 57571429
+ 0.29 0.00 0.50 64642857
+ 0.29 0.00 0.50 71714286
+ 0.29 0.00 0.50 78785714
+ 0.29 0.00 0.50 85857143
+ 0.29 0.00 0.50 92928571
+ 0.29 0.00 0.50 100000000
+ 0.29 0.00 0.57 1000000
+ 0.29 0.00 0.57 8071429
+ 0.29 0.00 0.57 15142857
+ 0.29 0.00 0.57 22214286
+ 0.29 0.00 0.57 29285714
+ 0.29 0.00 0.57 36357143
+ 0.29 0.00 0.57 43428571
+ 0.29 0.00 0.57 50500000
+ 0.29 0.00 0.57 57571429
+ 0.29 0.00 0.57 64642857
+ 0.29 0.00 0.57 71714286
+ 0.29 0.00 0.57 78785714
+ 0.29 0.00 0.57 85857143
+ 0.29 0.00 0.57 92928571
+ 0.29 0.00 0.57 100000000
+ 0.29 0.00 0.64 1000000
+ 0.29 0.00 0.64 8071429
+ 0.29 0.00 0.64 15142857
+ 0.29 0.00 0.64 22214286
+ 0.29 0.00 0.64 29285714
+ 0.29 0.00 0.64 36357143
+ 0.29 0.00 0.64 43428571
+ 0.29 0.00 0.64 50500000
+ 0.29 0.00 0.64 57571429
+ 0.29 0.00 0.64 64642857
+ 0.29 0.00 0.64 71714286
+ 0.29 0.00 0.64 78785714
+ 0.29 0.00 0.64 85857143
+ 0.29 0.00 0.64 92928571
+ 0.29 0.00 0.64 100000000
+ 0.29 0.00 0.71 1000000
+ 0.29 0.00 0.71 8071429
+ 0.29 0.00 0.71 15142857
+ 0.29 0.00 0.71 22214286
+ 0.29 0.00 0.71 29285714
+ 0.29 0.00 0.71 36357143
+ 0.29 0.00 0.71 43428571
+ 0.29 0.00 0.71 50500000
+ 0.29 0.00 0.71 57571429
+ 0.29 0.00 0.71 64642857
+ 0.29 0.00 0.71 71714286
+ 0.29 0.00 0.71 78785714
+ 0.29 0.00 0.71 85857143
+ 0.29 0.00 0.71 92928571
+ 0.29 0.00 0.71 100000000
+ 0.29 0.00 0.79 1000000
+ 0.29 0.00 0.79 8071429
+ 0.29 0.00 0.79 15142857
+ 0.29 0.00 0.79 22214286
+ 0.29 0.00 0.79 29285714
+ 0.29 0.00 0.79 36357143
+ 0.29 0.00 0.79 43428571
+ 0.29 0.00 0.79 50500000
+ 0.29 0.00 0.79 57571429
+ 0.29 0.00 0.79 64642857
+ 0.29 0.00 0.79 71714286
+ 0.29 0.00 0.79 78785714
+ 0.29 0.00 0.79 85857143
+ 0.29 0.00 0.79 92928571
+ 0.29 0.00 0.79 100000000
+ 0.29 0.00 0.86 1000000
+ 0.29 0.00 0.86 8071429
+ 0.29 0.00 0.86 15142857
+ 0.29 0.00 0.86 22214286
+ 0.29 0.00 0.86 29285714
+ 0.29 0.00 0.86 36357143
+ 0.29 0.00 0.86 43428571
+ 0.29 0.00 0.86 50500000
+ 0.29 0.00 0.86 57571429
+ 0.29 0.00 0.86 64642857
+ 0.29 0.00 0.86 71714286
+ 0.29 0.00 0.86 78785714
+ 0.29 0.00 0.86 85857143
+ 0.29 0.00 0.86 92928571
+ 0.29 0.00 0.86 100000000
+ 0.29 0.00 0.93 1000000
+ 0.29 0.00 0.93 8071429
+ 0.29 0.00 0.93 15142857
+ 0.29 0.00 0.93 22214286
+ 0.29 0.00 0.93 29285714
+ 0.29 0.00 0.93 36357143
+ 0.29 0.00 0.93 43428571
+ 0.29 0.00 0.93 50500000
+ 0.29 0.00 0.93 57571429
+ 0.29 0.00 0.93 64642857
+ 0.29 0.00 0.93 71714286
+ 0.29 0.00 0.93 78785714
+ 0.29 0.00 0.93 85857143
+ 0.29 0.00 0.93 92928571
+ 0.29 0.00 0.93 100000000
+ 0.29 0.00 1.00 1000000
+ 0.29 0.00 1.00 8071429
+ 0.29 0.00 1.00 15142857
+ 0.29 0.00 1.00 22214286
+ 0.29 0.00 1.00 29285714
+ 0.29 0.00 1.00 36357143
+ 0.29 0.00 1.00 43428571
+ 0.29 0.00 1.00 50500000
+ 0.29 0.00 1.00 57571429
+ 0.29 0.00 1.00 64642857
+ 0.29 0.00 1.00 71714286
+ 0.29 0.00 1.00 78785714
+ 0.29 0.00 1.00 85857143
+ 0.29 0.00 1.00 92928571
+ 0.29 0.00 1.00 100000000
+ 0.29 0.07 0.00 1000000
+ 0.29 0.07 0.00 8071429
+ 0.29 0.07 0.00 15142857
+ 0.29 0.07 0.00 22214286
+ 0.29 0.07 0.00 29285714
+ 0.29 0.07 0.00 36357143
+ 0.29 0.07 0.00 43428571
+ 0.29 0.07 0.00 50500000
+ 0.29 0.07 0.00 57571429
+ 0.29 0.07 0.00 64642857
+ 0.29 0.07 0.00 71714286
+ 0.29 0.07 0.00 78785714
+ 0.29 0.07 0.00 85857143
+ 0.29 0.07 0.00 92928571
+ 0.29 0.07 0.00 100000000
+ 0.29 0.07 0.07 1000000
+ 0.29 0.07 0.07 8071429
+ 0.29 0.07 0.07 15142857
+ 0.29 0.07 0.07 22214286
+ 0.29 0.07 0.07 29285714
+ 0.29 0.07 0.07 36357143
+ 0.29 0.07 0.07 43428571
+ 0.29 0.07 0.07 50500000
+ 0.29 0.07 0.07 57571429
+ 0.29 0.07 0.07 64642857
+ 0.29 0.07 0.07 71714286
+ 0.29 0.07 0.07 78785714
+ 0.29 0.07 0.07 85857143
+ 0.29 0.07 0.07 92928571
+ 0.29 0.07 0.07 100000000
+ 0.29 0.07 0.14 1000000
+ 0.29 0.07 0.14 8071429
+ 0.29 0.07 0.14 15142857
+ 0.29 0.07 0.14 22214286
+ 0.29 0.07 0.14 29285714
+ 0.29 0.07 0.14 36357143
+ 0.29 0.07 0.14 43428571
+ 0.29 0.07 0.14 50500000
+ 0.29 0.07 0.14 57571429
+ 0.29 0.07 0.14 64642857
+ 0.29 0.07 0.14 71714286
+ 0.29 0.07 0.14 78785714
+ 0.29 0.07 0.14 85857143
+ 0.29 0.07 0.14 92928571
+ 0.29 0.07 0.14 100000000
+ 0.29 0.07 0.21 1000000
+ 0.29 0.07 0.21 8071429
+ 0.29 0.07 0.21 15142857
+ 0.29 0.07 0.21 22214286
+ 0.29 0.07 0.21 29285714
+ 0.29 0.07 0.21 36357143
+ 0.29 0.07 0.21 43428571
+ 0.29 0.07 0.21 50500000
+ 0.29 0.07 0.21 57571429
+ 0.29 0.07 0.21 64642857
+ 0.29 0.07 0.21 71714286
+ 0.29 0.07 0.21 78785714
+ 0.29 0.07 0.21 85857143
+ 0.29 0.07 0.21 92928571
+ 0.29 0.07 0.21 100000000
+ 0.29 0.07 0.29 1000000
+ 0.29 0.07 0.29 8071429
+ 0.29 0.07 0.29 15142857
+ 0.29 0.07 0.29 22214286
+ 0.29 0.07 0.29 29285714
+ 0.29 0.07 0.29 36357143
+ 0.29 0.07 0.29 43428571
+ 0.29 0.07 0.29 50500000
+ 0.29 0.07 0.29 57571429
+ 0.29 0.07 0.29 64642857
+ 0.29 0.07 0.29 71714286
+ 0.29 0.07 0.29 78785714
+ 0.29 0.07 0.29 85857143
+ 0.29 0.07 0.29 92928571
+ 0.29 0.07 0.29 100000000
+ 0.29 0.07 0.36 1000000
+ 0.29 0.07 0.36 8071429
+ 0.29 0.07 0.36 15142857
+ 0.29 0.07 0.36 22214286
+ 0.29 0.07 0.36 29285714
+ 0.29 0.07 0.36 36357143
+ 0.29 0.07 0.36 43428571
+ 0.29 0.07 0.36 50500000
+ 0.29 0.07 0.36 57571429
+ 0.29 0.07 0.36 64642857
+ 0.29 0.07 0.36 71714286
+ 0.29 0.07 0.36 78785714
+ 0.29 0.07 0.36 85857143
+ 0.29 0.07 0.36 92928571
+ 0.29 0.07 0.36 100000000
+ 0.29 0.07 0.43 1000000
+ 0.29 0.07 0.43 8071429
+ 0.29 0.07 0.43 15142857
+ 0.29 0.07 0.43 22214286
+ 0.29 0.07 0.43 29285714
+ 0.29 0.07 0.43 36357143
+ 0.29 0.07 0.43 43428571
+ 0.29 0.07 0.43 50500000
+ 0.29 0.07 0.43 57571429
+ 0.29 0.07 0.43 64642857
+ 0.29 0.07 0.43 71714286
+ 0.29 0.07 0.43 78785714
+ 0.29 0.07 0.43 85857143
+ 0.29 0.07 0.43 92928571
+ 0.29 0.07 0.43 100000000
+ 0.29 0.07 0.50 1000000
+ 0.29 0.07 0.50 8071429
+ 0.29 0.07 0.50 15142857
+ 0.29 0.07 0.50 22214286
+ 0.29 0.07 0.50 29285714
+ 0.29 0.07 0.50 36357143
+ 0.29 0.07 0.50 43428571
+ 0.29 0.07 0.50 50500000
+ 0.29 0.07 0.50 57571429
+ 0.29 0.07 0.50 64642857
+ 0.29 0.07 0.50 71714286
+ 0.29 0.07 0.50 78785714
+ 0.29 0.07 0.50 85857143
+ 0.29 0.07 0.50 92928571
+ 0.29 0.07 0.50 100000000
+ 0.29 0.07 0.57 1000000
+ 0.29 0.07 0.57 8071429
+ 0.29 0.07 0.57 15142857
+ 0.29 0.07 0.57 22214286
+ 0.29 0.07 0.57 29285714
+ 0.29 0.07 0.57 36357143
+ 0.29 0.07 0.57 43428571
+ 0.29 0.07 0.57 50500000
+ 0.29 0.07 0.57 57571429
+ 0.29 0.07 0.57 64642857
+ 0.29 0.07 0.57 71714286
+ 0.29 0.07 0.57 78785714
+ 0.29 0.07 0.57 85857143
+ 0.29 0.07 0.57 92928571
+ 0.29 0.07 0.57 100000000
+ 0.29 0.07 0.64 1000000
+ 0.29 0.07 0.64 8071429
+ 0.29 0.07 0.64 15142857
+ 0.29 0.07 0.64 22214286
+ 0.29 0.07 0.64 29285714
+ 0.29 0.07 0.64 36357143
+ 0.29 0.07 0.64 43428571
+ 0.29 0.07 0.64 50500000
+ 0.29 0.07 0.64 57571429
+ 0.29 0.07 0.64 64642857
+ 0.29 0.07 0.64 71714286
+ 0.29 0.07 0.64 78785714
+ 0.29 0.07 0.64 85857143
+ 0.29 0.07 0.64 92928571
+ 0.29 0.07 0.64 100000000
+ 0.29 0.07 0.71 1000000
+ 0.29 0.07 0.71 8071429
+ 0.29 0.07 0.71 15142857
+ 0.29 0.07 0.71 22214286
+ 0.29 0.07 0.71 29285714
+ 0.29 0.07 0.71 36357143
+ 0.29 0.07 0.71 43428571
+ 0.29 0.07 0.71 50500000
+ 0.29 0.07 0.71 57571429
+ 0.29 0.07 0.71 64642857
+ 0.29 0.07 0.71 71714286
+ 0.29 0.07 0.71 78785714
+ 0.29 0.07 0.71 85857143
+ 0.29 0.07 0.71 92928571
+ 0.29 0.07 0.71 100000000
+ 0.29 0.07 0.79 1000000
+ 0.29 0.07 0.79 8071429
+ 0.29 0.07 0.79 15142857
+ 0.29 0.07 0.79 22214286
+ 0.29 0.07 0.79 29285714
+ 0.29 0.07 0.79 36357143
+ 0.29 0.07 0.79 43428571
+ 0.29 0.07 0.79 50500000
+ 0.29 0.07 0.79 57571429
+ 0.29 0.07 0.79 64642857
+ 0.29 0.07 0.79 71714286
+ 0.29 0.07 0.79 78785714
+ 0.29 0.07 0.79 85857143
+ 0.29 0.07 0.79 92928571
+ 0.29 0.07 0.79 100000000
+ 0.29 0.07 0.86 1000000
+ 0.29 0.07 0.86 8071429
+ 0.29 0.07 0.86 15142857
+ 0.29 0.07 0.86 22214286
+ 0.29 0.07 0.86 29285714
+ 0.29 0.07 0.86 36357143
+ 0.29 0.07 0.86 43428571
+ 0.29 0.07 0.86 50500000
+ 0.29 0.07 0.86 57571429
+ 0.29 0.07 0.86 64642857
+ 0.29 0.07 0.86 71714286
+ 0.29 0.07 0.86 78785714
+ 0.29 0.07 0.86 85857143
+ 0.29 0.07 0.86 92928571
+ 0.29 0.07 0.86 100000000
+ 0.29 0.07 0.93 1000000
+ 0.29 0.07 0.93 8071429
+ 0.29 0.07 0.93 15142857
+ 0.29 0.07 0.93 22214286
+ 0.29 0.07 0.93 29285714
+ 0.29 0.07 0.93 36357143
+ 0.29 0.07 0.93 43428571
+ 0.29 0.07 0.93 50500000
+ 0.29 0.07 0.93 57571429
+ 0.29 0.07 0.93 64642857
+ 0.29 0.07 0.93 71714286
+ 0.29 0.07 0.93 78785714
+ 0.29 0.07 0.93 85857143
+ 0.29 0.07 0.93 92928571
+ 0.29 0.07 0.93 100000000
+ 0.29 0.07 1.00 1000000
+ 0.29 0.07 1.00 8071429
+ 0.29 0.07 1.00 15142857
+ 0.29 0.07 1.00 22214286
+ 0.29 0.07 1.00 29285714
+ 0.29 0.07 1.00 36357143
+ 0.29 0.07 1.00 43428571
+ 0.29 0.07 1.00 50500000
+ 0.29 0.07 1.00 57571429
+ 0.29 0.07 1.00 64642857
+ 0.29 0.07 1.00 71714286
+ 0.29 0.07 1.00 78785714
+ 0.29 0.07 1.00 85857143
+ 0.29 0.07 1.00 92928571
+ 0.29 0.07 1.00 100000000
+ 0.29 0.14 0.00 1000000
+ 0.29 0.14 0.00 8071429
+ 0.29 0.14 0.00 15142857
+ 0.29 0.14 0.00 22214286
+ 0.29 0.14 0.00 29285714
+ 0.29 0.14 0.00 36357143
+ 0.29 0.14 0.00 43428571
+ 0.29 0.14 0.00 50500000
+ 0.29 0.14 0.00 57571429
+ 0.29 0.14 0.00 64642857
+ 0.29 0.14 0.00 71714286
+ 0.29 0.14 0.00 78785714
+ 0.29 0.14 0.00 85857143
+ 0.29 0.14 0.00 92928571
+ 0.29 0.14 0.00 100000000
+ 0.29 0.14 0.07 1000000
+ 0.29 0.14 0.07 8071429
+ 0.29 0.14 0.07 15142857
+ 0.29 0.14 0.07 22214286
+ 0.29 0.14 0.07 29285714
+ 0.29 0.14 0.07 36357143
+ 0.29 0.14 0.07 43428571
+ 0.29 0.14 0.07 50500000
+ 0.29 0.14 0.07 57571429
+ 0.29 0.14 0.07 64642857
+ 0.29 0.14 0.07 71714286
+ 0.29 0.14 0.07 78785714
+ 0.29 0.14 0.07 85857143
+ 0.29 0.14 0.07 92928571
+ 0.29 0.14 0.07 100000000
+ 0.29 0.14 0.14 1000000
+ 0.29 0.14 0.14 8071429
+ 0.29 0.14 0.14 15142857
+ 0.29 0.14 0.14 22214286
+ 0.29 0.14 0.14 29285714
+ 0.29 0.14 0.14 36357143
+ 0.29 0.14 0.14 43428571
+ 0.29 0.14 0.14 50500000
+ 0.29 0.14 0.14 57571429
+ 0.29 0.14 0.14 64642857
+ 0.29 0.14 0.14 71714286
+ 0.29 0.14 0.14 78785714
+ 0.29 0.14 0.14 85857143
+ 0.29 0.14 0.14 92928571
+ 0.29 0.14 0.14 100000000
+ 0.29 0.14 0.21 1000000
+ 0.29 0.14 0.21 8071429
+ 0.29 0.14 0.21 15142857
+ 0.29 0.14 0.21 22214286
+ 0.29 0.14 0.21 29285714
+ 0.29 0.14 0.21 36357143
+ 0.29 0.14 0.21 43428571
+ 0.29 0.14 0.21 50500000
+ 0.29 0.14 0.21 57571429
+ 0.29 0.14 0.21 64642857
+ 0.29 0.14 0.21 71714286
+ 0.29 0.14 0.21 78785714
+ 0.29 0.14 0.21 85857143
+ 0.29 0.14 0.21 92928571
+ 0.29 0.14 0.21 100000000
+ 0.29 0.14 0.29 1000000
+ 0.29 0.14 0.29 8071429
+ 0.29 0.14 0.29 15142857
+ 0.29 0.14 0.29 22214286
+ 0.29 0.14 0.29 29285714
+ 0.29 0.14 0.29 36357143
+ 0.29 0.14 0.29 43428571
+ 0.29 0.14 0.29 50500000
+ 0.29 0.14 0.29 57571429
+ 0.29 0.14 0.29 64642857
+ 0.29 0.14 0.29 71714286
+ 0.29 0.14 0.29 78785714
+ 0.29 0.14 0.29 85857143
+ 0.29 0.14 0.29 92928571
+ 0.29 0.14 0.29 100000000
+ 0.29 0.14 0.36 1000000
+ 0.29 0.14 0.36 8071429
+ 0.29 0.14 0.36 15142857
+ 0.29 0.14 0.36 22214286
+ 0.29 0.14 0.36 29285714
+ 0.29 0.14 0.36 36357143
+ 0.29 0.14 0.36 43428571
+ 0.29 0.14 0.36 50500000
+ 0.29 0.14 0.36 57571429
+ 0.29 0.14 0.36 64642857
+ 0.29 0.14 0.36 71714286
+ 0.29 0.14 0.36 78785714
+ 0.29 0.14 0.36 85857143
+ 0.29 0.14 0.36 92928571
+ 0.29 0.14 0.36 100000000
+ 0.29 0.14 0.43 1000000
+ 0.29 0.14 0.43 8071429
+ 0.29 0.14 0.43 15142857
+ 0.29 0.14 0.43 22214286
+ 0.29 0.14 0.43 29285714
+ 0.29 0.14 0.43 36357143
+ 0.29 0.14 0.43 43428571
+ 0.29 0.14 0.43 50500000
+ 0.29 0.14 0.43 57571429
+ 0.29 0.14 0.43 64642857
+ 0.29 0.14 0.43 71714286
+ 0.29 0.14 0.43 78785714
+ 0.29 0.14 0.43 85857143
+ 0.29 0.14 0.43 92928571
+ 0.29 0.14 0.43 100000000
+ 0.29 0.14 0.50 1000000
+ 0.29 0.14 0.50 8071429
+ 0.29 0.14 0.50 15142857
+ 0.29 0.14 0.50 22214286
+ 0.29 0.14 0.50 29285714
+ 0.29 0.14 0.50 36357143
+ 0.29 0.14 0.50 43428571
+ 0.29 0.14 0.50 50500000
+ 0.29 0.14 0.50 57571429
+ 0.29 0.14 0.50 64642857
+ 0.29 0.14 0.50 71714286
+ 0.29 0.14 0.50 78785714
+ 0.29 0.14 0.50 85857143
+ 0.29 0.14 0.50 92928571
+ 0.29 0.14 0.50 100000000
+ 0.29 0.14 0.57 1000000
+ 0.29 0.14 0.57 8071429
+ 0.29 0.14 0.57 15142857
+ 0.29 0.14 0.57 22214286
+ 0.29 0.14 0.57 29285714
+ 0.29 0.14 0.57 36357143
+ 0.29 0.14 0.57 43428571
+ 0.29 0.14 0.57 50500000
+ 0.29 0.14 0.57 57571429
+ 0.29 0.14 0.57 64642857
+ 0.29 0.14 0.57 71714286
+ 0.29 0.14 0.57 78785714
+ 0.29 0.14 0.57 85857143
+ 0.29 0.14 0.57 92928571
+ 0.29 0.14 0.57 100000000
+ 0.29 0.14 0.64 1000000
+ 0.29 0.14 0.64 8071429
+ 0.29 0.14 0.64 15142857
+ 0.29 0.14 0.64 22214286
+ 0.29 0.14 0.64 29285714
+ 0.29 0.14 0.64 36357143
+ 0.29 0.14 0.64 43428571
+ 0.29 0.14 0.64 50500000
+ 0.29 0.14 0.64 57571429
+ 0.29 0.14 0.64 64642857
+ 0.29 0.14 0.64 71714286
+ 0.29 0.14 0.64 78785714
+ 0.29 0.14 0.64 85857143
+ 0.29 0.14 0.64 92928571
+ 0.29 0.14 0.64 100000000
+ 0.29 0.14 0.71 1000000
+ 0.29 0.14 0.71 8071429
+ 0.29 0.14 0.71 15142857
+ 0.29 0.14 0.71 22214286
+ 0.29 0.14 0.71 29285714
+ 0.29 0.14 0.71 36357143
+ 0.29 0.14 0.71 43428571
+ 0.29 0.14 0.71 50500000
+ 0.29 0.14 0.71 57571429
+ 0.29 0.14 0.71 64642857
+ 0.29 0.14 0.71 71714286
+ 0.29 0.14 0.71 78785714
+ 0.29 0.14 0.71 85857143
+ 0.29 0.14 0.71 92928571
+ 0.29 0.14 0.71 100000000
+ 0.29 0.14 0.79 1000000
+ 0.29 0.14 0.79 8071429
+ 0.29 0.14 0.79 15142857
+ 0.29 0.14 0.79 22214286
+ 0.29 0.14 0.79 29285714
+ 0.29 0.14 0.79 36357143
+ 0.29 0.14 0.79 43428571
+ 0.29 0.14 0.79 50500000
+ 0.29 0.14 0.79 57571429
+ 0.29 0.14 0.79 64642857
+ 0.29 0.14 0.79 71714286
+ 0.29 0.14 0.79 78785714
+ 0.29 0.14 0.79 85857143
+ 0.29 0.14 0.79 92928571
+ 0.29 0.14 0.79 100000000
+ 0.29 0.14 0.86 1000000
+ 0.29 0.14 0.86 8071429
+ 0.29 0.14 0.86 15142857
+ 0.29 0.14 0.86 22214286
+ 0.29 0.14 0.86 29285714
+ 0.29 0.14 0.86 36357143
+ 0.29 0.14 0.86 43428571
+ 0.29 0.14 0.86 50500000
+ 0.29 0.14 0.86 57571429
+ 0.29 0.14 0.86 64642857
+ 0.29 0.14 0.86 71714286
+ 0.29 0.14 0.86 78785714
+ 0.29 0.14 0.86 85857143
+ 0.29 0.14 0.86 92928571
+ 0.29 0.14 0.86 100000000
+ 0.29 0.14 0.93 1000000
+ 0.29 0.14 0.93 8071429
+ 0.29 0.14 0.93 15142857
+ 0.29 0.14 0.93 22214286
+ 0.29 0.14 0.93 29285714
+ 0.29 0.14 0.93 36357143
+ 0.29 0.14 0.93 43428571
+ 0.29 0.14 0.93 50500000
+ 0.29 0.14 0.93 57571429
+ 0.29 0.14 0.93 64642857
+ 0.29 0.14 0.93 71714286
+ 0.29 0.14 0.93 78785714
+ 0.29 0.14 0.93 85857143
+ 0.29 0.14 0.93 92928571
+ 0.29 0.14 0.93 100000000
+ 0.29 0.14 1.00 1000000
+ 0.29 0.14 1.00 8071429
+ 0.29 0.14 1.00 15142857
+ 0.29 0.14 1.00 22214286
+ 0.29 0.14 1.00 29285714
+ 0.29 0.14 1.00 36357143
+ 0.29 0.14 1.00 43428571
+ 0.29 0.14 1.00 50500000
+ 0.29 0.14 1.00 57571429
+ 0.29 0.14 1.00 64642857
+ 0.29 0.14 1.00 71714286
+ 0.29 0.14 1.00 78785714
+ 0.29 0.14 1.00 85857143
+ 0.29 0.14 1.00 92928571
+ 0.29 0.14 1.00 100000000
+ 0.29 0.21 0.00 1000000
+ 0.29 0.21 0.00 8071429
+ 0.29 0.21 0.00 15142857
+ 0.29 0.21 0.00 22214286
+ 0.29 0.21 0.00 29285714
+ 0.29 0.21 0.00 36357143
+ 0.29 0.21 0.00 43428571
+ 0.29 0.21 0.00 50500000
+ 0.29 0.21 0.00 57571429
+ 0.29 0.21 0.00 64642857
+ 0.29 0.21 0.00 71714286
+ 0.29 0.21 0.00 78785714
+ 0.29 0.21 0.00 85857143
+ 0.29 0.21 0.00 92928571
+ 0.29 0.21 0.00 100000000
+ 0.29 0.21 0.07 1000000
+ 0.29 0.21 0.07 8071429
+ 0.29 0.21 0.07 15142857
+ 0.29 0.21 0.07 22214286
+ 0.29 0.21 0.07 29285714
+ 0.29 0.21 0.07 36357143
+ 0.29 0.21 0.07 43428571
+ 0.29 0.21 0.07 50500000
+ 0.29 0.21 0.07 57571429
+ 0.29 0.21 0.07 64642857
+ 0.29 0.21 0.07 71714286
+ 0.29 0.21 0.07 78785714
+ 0.29 0.21 0.07 85857143
+ 0.29 0.21 0.07 92928571
+ 0.29 0.21 0.07 100000000
+ 0.29 0.21 0.14 1000000
+ 0.29 0.21 0.14 8071429
+ 0.29 0.21 0.14 15142857
+ 0.29 0.21 0.14 22214286
+ 0.29 0.21 0.14 29285714
+ 0.29 0.21 0.14 36357143
+ 0.29 0.21 0.14 43428571
+ 0.29 0.21 0.14 50500000
+ 0.29 0.21 0.14 57571429
+ 0.29 0.21 0.14 64642857
+ 0.29 0.21 0.14 71714286
+ 0.29 0.21 0.14 78785714
+ 0.29 0.21 0.14 85857143
+ 0.29 0.21 0.14 92928571
+ 0.29 0.21 0.14 100000000
+ 0.29 0.21 0.21 1000000
+ 0.29 0.21 0.21 8071429
+ 0.29 0.21 0.21 15142857
+ 0.29 0.21 0.21 22214286
+ 0.29 0.21 0.21 29285714
+ 0.29 0.21 0.21 36357143
+ 0.29 0.21 0.21 43428571
+ 0.29 0.21 0.21 50500000
+ 0.29 0.21 0.21 57571429
+ 0.29 0.21 0.21 64642857
+ 0.29 0.21 0.21 71714286
+ 0.29 0.21 0.21 78785714
+ 0.29 0.21 0.21 85857143
+ 0.29 0.21 0.21 92928571
+ 0.29 0.21 0.21 100000000
+ 0.29 0.21 0.29 1000000
+ 0.29 0.21 0.29 8071429
+ 0.29 0.21 0.29 15142857
+ 0.29 0.21 0.29 22214286
+ 0.29 0.21 0.29 29285714
+ 0.29 0.21 0.29 36357143
+ 0.29 0.21 0.29 43428571
+ 0.29 0.21 0.29 50500000
+ 0.29 0.21 0.29 57571429
+ 0.29 0.21 0.29 64642857
+ 0.29 0.21 0.29 71714286
+ 0.29 0.21 0.29 78785714
+ 0.29 0.21 0.29 85857143
+ 0.29 0.21 0.29 92928571
+ 0.29 0.21 0.29 100000000
+ 0.29 0.21 0.36 1000000
+ 0.29 0.21 0.36 8071429
+ 0.29 0.21 0.36 15142857
+ 0.29 0.21 0.36 22214286
+ 0.29 0.21 0.36 29285714
+ 0.29 0.21 0.36 36357143
+ 0.29 0.21 0.36 43428571
+ 0.29 0.21 0.36 50500000
+ 0.29 0.21 0.36 57571429
+ 0.29 0.21 0.36 64642857
+ 0.29 0.21 0.36 71714286
+ 0.29 0.21 0.36 78785714
+ 0.29 0.21 0.36 85857143
+ 0.29 0.21 0.36 92928571
+ 0.29 0.21 0.36 100000000
+ 0.29 0.21 0.43 1000000
+ 0.29 0.21 0.43 8071429
+ 0.29 0.21 0.43 15142857
+ 0.29 0.21 0.43 22214286
+ 0.29 0.21 0.43 29285714
+ 0.29 0.21 0.43 36357143
+ 0.29 0.21 0.43 43428571
+ 0.29 0.21 0.43 50500000
+ 0.29 0.21 0.43 57571429
+ 0.29 0.21 0.43 64642857
+ 0.29 0.21 0.43 71714286
+ 0.29 0.21 0.43 78785714
+ 0.29 0.21 0.43 85857143
+ 0.29 0.21 0.43 92928571
+ 0.29 0.21 0.43 100000000
+ 0.29 0.21 0.50 1000000
+ 0.29 0.21 0.50 8071429
+ 0.29 0.21 0.50 15142857
+ 0.29 0.21 0.50 22214286
+ 0.29 0.21 0.50 29285714
+ 0.29 0.21 0.50 36357143
+ 0.29 0.21 0.50 43428571
+ 0.29 0.21 0.50 50500000
+ 0.29 0.21 0.50 57571429
+ 0.29 0.21 0.50 64642857
+ 0.29 0.21 0.50 71714286
+ 0.29 0.21 0.50 78785714
+ 0.29 0.21 0.50 85857143
+ 0.29 0.21 0.50 92928571
+ 0.29 0.21 0.50 100000000
+ 0.29 0.21 0.57 1000000
+ 0.29 0.21 0.57 8071429
+ 0.29 0.21 0.57 15142857
+ 0.29 0.21 0.57 22214286
+ 0.29 0.21 0.57 29285714
+ 0.29 0.21 0.57 36357143
+ 0.29 0.21 0.57 43428571
+ 0.29 0.21 0.57 50500000
+ 0.29 0.21 0.57 57571429
+ 0.29 0.21 0.57 64642857
+ 0.29 0.21 0.57 71714286
+ 0.29 0.21 0.57 78785714
+ 0.29 0.21 0.57 85857143
+ 0.29 0.21 0.57 92928571
+ 0.29 0.21 0.57 100000000
+ 0.29 0.21 0.64 1000000
+ 0.29 0.21 0.64 8071429
+ 0.29 0.21 0.64 15142857
+ 0.29 0.21 0.64 22214286
+ 0.29 0.21 0.64 29285714
+ 0.29 0.21 0.64 36357143
+ 0.29 0.21 0.64 43428571
+ 0.29 0.21 0.64 50500000
+ 0.29 0.21 0.64 57571429
+ 0.29 0.21 0.64 64642857
+ 0.29 0.21 0.64 71714286
+ 0.29 0.21 0.64 78785714
+ 0.29 0.21 0.64 85857143
+ 0.29 0.21 0.64 92928571
+ 0.29 0.21 0.64 100000000
+ 0.29 0.21 0.71 1000000
+ 0.29 0.21 0.71 8071429
+ 0.29 0.21 0.71 15142857
+ 0.29 0.21 0.71 22214286
+ 0.29 0.21 0.71 29285714
+ 0.29 0.21 0.71 36357143
+ 0.29 0.21 0.71 43428571
+ 0.29 0.21 0.71 50500000
+ 0.29 0.21 0.71 57571429
+ 0.29 0.21 0.71 64642857
+ 0.29 0.21 0.71 71714286
+ 0.29 0.21 0.71 78785714
+ 0.29 0.21 0.71 85857143
+ 0.29 0.21 0.71 92928571
+ 0.29 0.21 0.71 100000000
+ 0.29 0.21 0.79 1000000
+ 0.29 0.21 0.79 8071429
+ 0.29 0.21 0.79 15142857
+ 0.29 0.21 0.79 22214286
+ 0.29 0.21 0.79 29285714
+ 0.29 0.21 0.79 36357143
+ 0.29 0.21 0.79 43428571
+ 0.29 0.21 0.79 50500000
+ 0.29 0.21 0.79 57571429
+ 0.29 0.21 0.79 64642857
+ 0.29 0.21 0.79 71714286
+ 0.29 0.21 0.79 78785714
+ 0.29 0.21 0.79 85857143
+ 0.29 0.21 0.79 92928571
+ 0.29 0.21 0.79 100000000
+ 0.29 0.21 0.86 1000000
+ 0.29 0.21 0.86 8071429
+ 0.29 0.21 0.86 15142857
+ 0.29 0.21 0.86 22214286
+ 0.29 0.21 0.86 29285714
+ 0.29 0.21 0.86 36357143
+ 0.29 0.21 0.86 43428571
+ 0.29 0.21 0.86 50500000
+ 0.29 0.21 0.86 57571429
+ 0.29 0.21 0.86 64642857
+ 0.29 0.21 0.86 71714286
+ 0.29 0.21 0.86 78785714
+ 0.29 0.21 0.86 85857143
+ 0.29 0.21 0.86 92928571
+ 0.29 0.21 0.86 100000000
+ 0.29 0.21 0.93 1000000
+ 0.29 0.21 0.93 8071429
+ 0.29 0.21 0.93 15142857
+ 0.29 0.21 0.93 22214286
+ 0.29 0.21 0.93 29285714
+ 0.29 0.21 0.93 36357143
+ 0.29 0.21 0.93 43428571
+ 0.29 0.21 0.93 50500000
+ 0.29 0.21 0.93 57571429
+ 0.29 0.21 0.93 64642857
+ 0.29 0.21 0.93 71714286
+ 0.29 0.21 0.93 78785714
+ 0.29 0.21 0.93 85857143
+ 0.29 0.21 0.93 92928571
+ 0.29 0.21 0.93 100000000
+ 0.29 0.21 1.00 1000000
+ 0.29 0.21 1.00 8071429
+ 0.29 0.21 1.00 15142857
+ 0.29 0.21 1.00 22214286
+ 0.29 0.21 1.00 29285714
+ 0.29 0.21 1.00 36357143
+ 0.29 0.21 1.00 43428571
+ 0.29 0.21 1.00 50500000
+ 0.29 0.21 1.00 57571429
+ 0.29 0.21 1.00 64642857
+ 0.29 0.21 1.00 71714286
+ 0.29 0.21 1.00 78785714
+ 0.29 0.21 1.00 85857143
+ 0.29 0.21 1.00 92928571
+ 0.29 0.21 1.00 100000000
+ 0.29 0.29 0.00 1000000
+ 0.29 0.29 0.00 8071429
+ 0.29 0.29 0.00 15142857
+ 0.29 0.29 0.00 22214286
+ 0.29 0.29 0.00 29285714
+ 0.29 0.29 0.00 36357143
+ 0.29 0.29 0.00 43428571
+ 0.29 0.29 0.00 50500000
+ 0.29 0.29 0.00 57571429
+ 0.29 0.29 0.00 64642857
+ 0.29 0.29 0.00 71714286
+ 0.29 0.29 0.00 78785714
+ 0.29 0.29 0.00 85857143
+ 0.29 0.29 0.00 92928571
+ 0.29 0.29 0.00 100000000
+ 0.29 0.29 0.07 1000000
+ 0.29 0.29 0.07 8071429
+ 0.29 0.29 0.07 15142857
+ 0.29 0.29 0.07 22214286
+ 0.29 0.29 0.07 29285714
+ 0.29 0.29 0.07 36357143
+ 0.29 0.29 0.07 43428571
+ 0.29 0.29 0.07 50500000
+ 0.29 0.29 0.07 57571429
+ 0.29 0.29 0.07 64642857
+ 0.29 0.29 0.07 71714286
+ 0.29 0.29 0.07 78785714
+ 0.29 0.29 0.07 85857143
+ 0.29 0.29 0.07 92928571
+ 0.29 0.29 0.07 100000000
+ 0.29 0.29 0.14 1000000
+ 0.29 0.29 0.14 8071429
+ 0.29 0.29 0.14 15142857
+ 0.29 0.29 0.14 22214286
+ 0.29 0.29 0.14 29285714
+ 0.29 0.29 0.14 36357143
+ 0.29 0.29 0.14 43428571
+ 0.29 0.29 0.14 50500000
+ 0.29 0.29 0.14 57571429
+ 0.29 0.29 0.14 64642857
+ 0.29 0.29 0.14 71714286
+ 0.29 0.29 0.14 78785714
+ 0.29 0.29 0.14 85857143
+ 0.29 0.29 0.14 92928571
+ 0.29 0.29 0.14 100000000
+ 0.29 0.29 0.21 1000000
+ 0.29 0.29 0.21 8071429
+ 0.29 0.29 0.21 15142857
+ 0.29 0.29 0.21 22214286
+ 0.29 0.29 0.21 29285714
+ 0.29 0.29 0.21 36357143
+ 0.29 0.29 0.21 43428571
+ 0.29 0.29 0.21 50500000
+ 0.29 0.29 0.21 57571429
+ 0.29 0.29 0.21 64642857
+ 0.29 0.29 0.21 71714286
+ 0.29 0.29 0.21 78785714
+ 0.29 0.29 0.21 85857143
+ 0.29 0.29 0.21 92928571
+ 0.29 0.29 0.21 100000000
+ 0.29 0.29 0.29 1000000
+ 0.29 0.29 0.29 8071429
+ 0.29 0.29 0.29 15142857
+ 0.29 0.29 0.29 22214286
+ 0.29 0.29 0.29 29285714
+ 0.29 0.29 0.29 36357143
+ 0.29 0.29 0.29 43428571
+ 0.29 0.29 0.29 50500000
+ 0.29 0.29 0.29 57571429
+ 0.29 0.29 0.29 64642857
+ 0.29 0.29 0.29 71714286
+ 0.29 0.29 0.29 78785714
+ 0.29 0.29 0.29 85857143
+ 0.29 0.29 0.29 92928571
+ 0.29 0.29 0.29 100000000
+ 0.29 0.29 0.36 1000000
+ 0.29 0.29 0.36 8071429
+ 0.29 0.29 0.36 15142857
+ 0.29 0.29 0.36 22214286
+ 0.29 0.29 0.36 29285714
+ 0.29 0.29 0.36 36357143
+ 0.29 0.29 0.36 43428571
+ 0.29 0.29 0.36 50500000
+ 0.29 0.29 0.36 57571429
+ 0.29 0.29 0.36 64642857
+ 0.29 0.29 0.36 71714286
+ 0.29 0.29 0.36 78785714
+ 0.29 0.29 0.36 85857143
+ 0.29 0.29 0.36 92928571
+ 0.29 0.29 0.36 100000000
+ 0.29 0.29 0.43 1000000
+ 0.29 0.29 0.43 8071429
+ 0.29 0.29 0.43 15142857
+ 0.29 0.29 0.43 22214286
+ 0.29 0.29 0.43 29285714
+ 0.29 0.29 0.43 36357143
+ 0.29 0.29 0.43 43428571
+ 0.29 0.29 0.43 50500000
+ 0.29 0.29 0.43 57571429
+ 0.29 0.29 0.43 64642857
+ 0.29 0.29 0.43 71714286
+ 0.29 0.29 0.43 78785714
+ 0.29 0.29 0.43 85857143
+ 0.29 0.29 0.43 92928571
+ 0.29 0.29 0.43 100000000
+ 0.29 0.29 0.50 1000000
+ 0.29 0.29 0.50 8071429
+ 0.29 0.29 0.50 15142857
+ 0.29 0.29 0.50 22214286
+ 0.29 0.29 0.50 29285714
+ 0.29 0.29 0.50 36357143
+ 0.29 0.29 0.50 43428571
+ 0.29 0.29 0.50 50500000
+ 0.29 0.29 0.50 57571429
+ 0.29 0.29 0.50 64642857
+ 0.29 0.29 0.50 71714286
+ 0.29 0.29 0.50 78785714
+ 0.29 0.29 0.50 85857143
+ 0.29 0.29 0.50 92928571
+ 0.29 0.29 0.50 100000000
+ 0.29 0.29 0.57 1000000
+ 0.29 0.29 0.57 8071429
+ 0.29 0.29 0.57 15142857
+ 0.29 0.29 0.57 22214286
+ 0.29 0.29 0.57 29285714
+ 0.29 0.29 0.57 36357143
+ 0.29 0.29 0.57 43428571
+ 0.29 0.29 0.57 50500000
+ 0.29 0.29 0.57 57571429
+ 0.29 0.29 0.57 64642857
+ 0.29 0.29 0.57 71714286
+ 0.29 0.29 0.57 78785714
+ 0.29 0.29 0.57 85857143
+ 0.29 0.29 0.57 92928571
+ 0.29 0.29 0.57 100000000
+ 0.29 0.29 0.64 1000000
+ 0.29 0.29 0.64 8071429
+ 0.29 0.29 0.64 15142857
+ 0.29 0.29 0.64 22214286
+ 0.29 0.29 0.64 29285714
+ 0.29 0.29 0.64 36357143
+ 0.29 0.29 0.64 43428571
+ 0.29 0.29 0.64 50500000
+ 0.29 0.29 0.64 57571429
+ 0.29 0.29 0.64 64642857
+ 0.29 0.29 0.64 71714286
+ 0.29 0.29 0.64 78785714
+ 0.29 0.29 0.64 85857143
+ 0.29 0.29 0.64 92928571
+ 0.29 0.29 0.64 100000000
+ 0.29 0.29 0.71 1000000
+ 0.29 0.29 0.71 8071429
+ 0.29 0.29 0.71 15142857
+ 0.29 0.29 0.71 22214286
+ 0.29 0.29 0.71 29285714
+ 0.29 0.29 0.71 36357143
+ 0.29 0.29 0.71 43428571
+ 0.29 0.29 0.71 50500000
+ 0.29 0.29 0.71 57571429
+ 0.29 0.29 0.71 64642857
+ 0.29 0.29 0.71 71714286
+ 0.29 0.29 0.71 78785714
+ 0.29 0.29 0.71 85857143
+ 0.29 0.29 0.71 92928571
+ 0.29 0.29 0.71 100000000
+ 0.29 0.29 0.79 1000000
+ 0.29 0.29 0.79 8071429
+ 0.29 0.29 0.79 15142857
+ 0.29 0.29 0.79 22214286
+ 0.29 0.29 0.79 29285714
+ 0.29 0.29 0.79 36357143
+ 0.29 0.29 0.79 43428571
+ 0.29 0.29 0.79 50500000
+ 0.29 0.29 0.79 57571429
+ 0.29 0.29 0.79 64642857
+ 0.29 0.29 0.79 71714286
+ 0.29 0.29 0.79 78785714
+ 0.29 0.29 0.79 85857143
+ 0.29 0.29 0.79 92928571
+ 0.29 0.29 0.79 100000000
+ 0.29 0.29 0.86 1000000
+ 0.29 0.29 0.86 8071429
+ 0.29 0.29 0.86 15142857
+ 0.29 0.29 0.86 22214286
+ 0.29 0.29 0.86 29285714
+ 0.29 0.29 0.86 36357143
+ 0.29 0.29 0.86 43428571
+ 0.29 0.29 0.86 50500000
+ 0.29 0.29 0.86 57571429
+ 0.29 0.29 0.86 64642857
+ 0.29 0.29 0.86 71714286
+ 0.29 0.29 0.86 78785714
+ 0.29 0.29 0.86 85857143
+ 0.29 0.29 0.86 92928571
+ 0.29 0.29 0.86 100000000
+ 0.29 0.29 0.93 1000000
+ 0.29 0.29 0.93 8071429
+ 0.29 0.29 0.93 15142857
+ 0.29 0.29 0.93 22214286
+ 0.29 0.29 0.93 29285714
+ 0.29 0.29 0.93 36357143
+ 0.29 0.29 0.93 43428571
+ 0.29 0.29 0.93 50500000
+ 0.29 0.29 0.93 57571429
+ 0.29 0.29 0.93 64642857
+ 0.29 0.29 0.93 71714286
+ 0.29 0.29 0.93 78785714
+ 0.29 0.29 0.93 85857143
+ 0.29 0.29 0.93 92928571
+ 0.29 0.29 0.93 100000000
+ 0.29 0.29 1.00 1000000
+ 0.29 0.29 1.00 8071429
+ 0.29 0.29 1.00 15142857
+ 0.29 0.29 1.00 22214286
+ 0.29 0.29 1.00 29285714
+ 0.29 0.29 1.00 36357143
+ 0.29 0.29 1.00 43428571
+ 0.29 0.29 1.00 50500000
+ 0.29 0.29 1.00 57571429
+ 0.29 0.29 1.00 64642857
+ 0.29 0.29 1.00 71714286
+ 0.29 0.29 1.00 78785714
+ 0.29 0.29 1.00 85857143
+ 0.29 0.29 1.00 92928571
+ 0.29 0.29 1.00 100000000
+ 0.29 0.36 0.00 1000000
+ 0.29 0.36 0.00 8071429
+ 0.29 0.36 0.00 15142857
+ 0.29 0.36 0.00 22214286
+ 0.29 0.36 0.00 29285714
+ 0.29 0.36 0.00 36357143
+ 0.29 0.36 0.00 43428571
+ 0.29 0.36 0.00 50500000
+ 0.29 0.36 0.00 57571429
+ 0.29 0.36 0.00 64642857
+ 0.29 0.36 0.00 71714286
+ 0.29 0.36 0.00 78785714
+ 0.29 0.36 0.00 85857143
+ 0.29 0.36 0.00 92928571
+ 0.29 0.36 0.00 100000000
+ 0.29 0.36 0.07 1000000
+ 0.29 0.36 0.07 8071429
+ 0.29 0.36 0.07 15142857
+ 0.29 0.36 0.07 22214286
+ 0.29 0.36 0.07 29285714
+ 0.29 0.36 0.07 36357143
+ 0.29 0.36 0.07 43428571
+ 0.29 0.36 0.07 50500000
+ 0.29 0.36 0.07 57571429
+ 0.29 0.36 0.07 64642857
+ 0.29 0.36 0.07 71714286
+ 0.29 0.36 0.07 78785714
+ 0.29 0.36 0.07 85857143
+ 0.29 0.36 0.07 92928571
+ 0.29 0.36 0.07 100000000
+ 0.29 0.36 0.14 1000000
+ 0.29 0.36 0.14 8071429
+ 0.29 0.36 0.14 15142857
+ 0.29 0.36 0.14 22214286
+ 0.29 0.36 0.14 29285714
+ 0.29 0.36 0.14 36357143
+ 0.29 0.36 0.14 43428571
+ 0.29 0.36 0.14 50500000
+ 0.29 0.36 0.14 57571429
+ 0.29 0.36 0.14 64642857
+ 0.29 0.36 0.14 71714286
+ 0.29 0.36 0.14 78785714
+ 0.29 0.36 0.14 85857143
+ 0.29 0.36 0.14 92928571
+ 0.29 0.36 0.14 100000000
+ 0.29 0.36 0.21 1000000
+ 0.29 0.36 0.21 8071429
+ 0.29 0.36 0.21 15142857
+ 0.29 0.36 0.21 22214286
+ 0.29 0.36 0.21 29285714
+ 0.29 0.36 0.21 36357143
+ 0.29 0.36 0.21 43428571
+ 0.29 0.36 0.21 50500000
+ 0.29 0.36 0.21 57571429
+ 0.29 0.36 0.21 64642857
+ 0.29 0.36 0.21 71714286
+ 0.29 0.36 0.21 78785714
+ 0.29 0.36 0.21 85857143
+ 0.29 0.36 0.21 92928571
+ 0.29 0.36 0.21 100000000
+ 0.29 0.36 0.29 1000000
+ 0.29 0.36 0.29 8071429
+ 0.29 0.36 0.29 15142857
+ 0.29 0.36 0.29 22214286
+ 0.29 0.36 0.29 29285714
+ 0.29 0.36 0.29 36357143
+ 0.29 0.36 0.29 43428571
+ 0.29 0.36 0.29 50500000
+ 0.29 0.36 0.29 57571429
+ 0.29 0.36 0.29 64642857
+ 0.29 0.36 0.29 71714286
+ 0.29 0.36 0.29 78785714
+ 0.29 0.36 0.29 85857143
+ 0.29 0.36 0.29 92928571
+ 0.29 0.36 0.29 100000000
+ 0.29 0.36 0.36 1000000
+ 0.29 0.36 0.36 8071429
+ 0.29 0.36 0.36 15142857
+ 0.29 0.36 0.36 22214286
+ 0.29 0.36 0.36 29285714
+ 0.29 0.36 0.36 36357143
+ 0.29 0.36 0.36 43428571
+ 0.29 0.36 0.36 50500000
+ 0.29 0.36 0.36 57571429
+ 0.29 0.36 0.36 64642857
+ 0.29 0.36 0.36 71714286
+ 0.29 0.36 0.36 78785714
+ 0.29 0.36 0.36 85857143
+ 0.29 0.36 0.36 92928571
+ 0.29 0.36 0.36 100000000
+ 0.29 0.36 0.43 1000000
+ 0.29 0.36 0.43 8071429
+ 0.29 0.36 0.43 15142857
+ 0.29 0.36 0.43 22214286
+ 0.29 0.36 0.43 29285714
+ 0.29 0.36 0.43 36357143
+ 0.29 0.36 0.43 43428571
+ 0.29 0.36 0.43 50500000
+ 0.29 0.36 0.43 57571429
+ 0.29 0.36 0.43 64642857
+ 0.29 0.36 0.43 71714286
+ 0.29 0.36 0.43 78785714
+ 0.29 0.36 0.43 85857143
+ 0.29 0.36 0.43 92928571
+ 0.29 0.36 0.43 100000000
+ 0.29 0.36 0.50 1000000
+ 0.29 0.36 0.50 8071429
+ 0.29 0.36 0.50 15142857
+ 0.29 0.36 0.50 22214286
+ 0.29 0.36 0.50 29285714
+ 0.29 0.36 0.50 36357143
+ 0.29 0.36 0.50 43428571
+ 0.29 0.36 0.50 50500000
+ 0.29 0.36 0.50 57571429
+ 0.29 0.36 0.50 64642857
+ 0.29 0.36 0.50 71714286
+ 0.29 0.36 0.50 78785714
+ 0.29 0.36 0.50 85857143
+ 0.29 0.36 0.50 92928571
+ 0.29 0.36 0.50 100000000
+ 0.29 0.36 0.57 1000000
+ 0.29 0.36 0.57 8071429
+ 0.29 0.36 0.57 15142857
+ 0.29 0.36 0.57 22214286
+ 0.29 0.36 0.57 29285714
+ 0.29 0.36 0.57 36357143
+ 0.29 0.36 0.57 43428571
+ 0.29 0.36 0.57 50500000
+ 0.29 0.36 0.57 57571429
+ 0.29 0.36 0.57 64642857
+ 0.29 0.36 0.57 71714286
+ 0.29 0.36 0.57 78785714
+ 0.29 0.36 0.57 85857143
+ 0.29 0.36 0.57 92928571
+ 0.29 0.36 0.57 100000000
+ 0.29 0.36 0.64 1000000
+ 0.29 0.36 0.64 8071429
+ 0.29 0.36 0.64 15142857
+ 0.29 0.36 0.64 22214286
+ 0.29 0.36 0.64 29285714
+ 0.29 0.36 0.64 36357143
+ 0.29 0.36 0.64 43428571
+ 0.29 0.36 0.64 50500000
+ 0.29 0.36 0.64 57571429
+ 0.29 0.36 0.64 64642857
+ 0.29 0.36 0.64 71714286
+ 0.29 0.36 0.64 78785714
+ 0.29 0.36 0.64 85857143
+ 0.29 0.36 0.64 92928571
+ 0.29 0.36 0.64 100000000
+ 0.29 0.36 0.71 1000000
+ 0.29 0.36 0.71 8071429
+ 0.29 0.36 0.71 15142857
+ 0.29 0.36 0.71 22214286
+ 0.29 0.36 0.71 29285714
+ 0.29 0.36 0.71 36357143
+ 0.29 0.36 0.71 43428571
+ 0.29 0.36 0.71 50500000
+ 0.29 0.36 0.71 57571429
+ 0.29 0.36 0.71 64642857
+ 0.29 0.36 0.71 71714286
+ 0.29 0.36 0.71 78785714
+ 0.29 0.36 0.71 85857143
+ 0.29 0.36 0.71 92928571
+ 0.29 0.36 0.71 100000000
+ 0.29 0.36 0.79 1000000
+ 0.29 0.36 0.79 8071429
+ 0.29 0.36 0.79 15142857
+ 0.29 0.36 0.79 22214286
+ 0.29 0.36 0.79 29285714
+ 0.29 0.36 0.79 36357143
+ 0.29 0.36 0.79 43428571
+ 0.29 0.36 0.79 50500000
+ 0.29 0.36 0.79 57571429
+ 0.29 0.36 0.79 64642857
+ 0.29 0.36 0.79 71714286
+ 0.29 0.36 0.79 78785714
+ 0.29 0.36 0.79 85857143
+ 0.29 0.36 0.79 92928571
+ 0.29 0.36 0.79 100000000
+ 0.29 0.36 0.86 1000000
+ 0.29 0.36 0.86 8071429
+ 0.29 0.36 0.86 15142857
+ 0.29 0.36 0.86 22214286
+ 0.29 0.36 0.86 29285714
+ 0.29 0.36 0.86 36357143
+ 0.29 0.36 0.86 43428571
+ 0.29 0.36 0.86 50500000
+ 0.29 0.36 0.86 57571429
+ 0.29 0.36 0.86 64642857
+ 0.29 0.36 0.86 71714286
+ 0.29 0.36 0.86 78785714
+ 0.29 0.36 0.86 85857143
+ 0.29 0.36 0.86 92928571
+ 0.29 0.36 0.86 100000000
+ 0.29 0.36 0.93 1000000
+ 0.29 0.36 0.93 8071429
+ 0.29 0.36 0.93 15142857
+ 0.29 0.36 0.93 22214286
+ 0.29 0.36 0.93 29285714
+ 0.29 0.36 0.93 36357143
+ 0.29 0.36 0.93 43428571
+ 0.29 0.36 0.93 50500000
+ 0.29 0.36 0.93 57571429
+ 0.29 0.36 0.93 64642857
+ 0.29 0.36 0.93 71714286
+ 0.29 0.36 0.93 78785714
+ 0.29 0.36 0.93 85857143
+ 0.29 0.36 0.93 92928571
+ 0.29 0.36 0.93 100000000
+ 0.29 0.36 1.00 1000000
+ 0.29 0.36 1.00 8071429
+ 0.29 0.36 1.00 15142857
+ 0.29 0.36 1.00 22214286
+ 0.29 0.36 1.00 29285714
+ 0.29 0.36 1.00 36357143
+ 0.29 0.36 1.00 43428571
+ 0.29 0.36 1.00 50500000
+ 0.29 0.36 1.00 57571429
+ 0.29 0.36 1.00 64642857
+ 0.29 0.36 1.00 71714286
+ 0.29 0.36 1.00 78785714
+ 0.29 0.36 1.00 85857143
+ 0.29 0.36 1.00 92928571
+ 0.29 0.36 1.00 100000000
+ 0.29 0.43 0.00 1000000
+ 0.29 0.43 0.00 8071429
+ 0.29 0.43 0.00 15142857
+ 0.29 0.43 0.00 22214286
+ 0.29 0.43 0.00 29285714
+ 0.29 0.43 0.00 36357143
+ 0.29 0.43 0.00 43428571
+ 0.29 0.43 0.00 50500000
+ 0.29 0.43 0.00 57571429
+ 0.29 0.43 0.00 64642857
+ 0.29 0.43 0.00 71714286
+ 0.29 0.43 0.00 78785714
+ 0.29 0.43 0.00 85857143
+ 0.29 0.43 0.00 92928571
+ 0.29 0.43 0.00 100000000
+ 0.29 0.43 0.07 1000000
+ 0.29 0.43 0.07 8071429
+ 0.29 0.43 0.07 15142857
+ 0.29 0.43 0.07 22214286
+ 0.29 0.43 0.07 29285714
+ 0.29 0.43 0.07 36357143
+ 0.29 0.43 0.07 43428571
+ 0.29 0.43 0.07 50500000
+ 0.29 0.43 0.07 57571429
+ 0.29 0.43 0.07 64642857
+ 0.29 0.43 0.07 71714286
+ 0.29 0.43 0.07 78785714
+ 0.29 0.43 0.07 85857143
+ 0.29 0.43 0.07 92928571
+ 0.29 0.43 0.07 100000000
+ 0.29 0.43 0.14 1000000
+ 0.29 0.43 0.14 8071429
+ 0.29 0.43 0.14 15142857
+ 0.29 0.43 0.14 22214286
+ 0.29 0.43 0.14 29285714
+ 0.29 0.43 0.14 36357143
+ 0.29 0.43 0.14 43428571
+ 0.29 0.43 0.14 50500000
+ 0.29 0.43 0.14 57571429
+ 0.29 0.43 0.14 64642857
+ 0.29 0.43 0.14 71714286
+ 0.29 0.43 0.14 78785714
+ 0.29 0.43 0.14 85857143
+ 0.29 0.43 0.14 92928571
+ 0.29 0.43 0.14 100000000
+ 0.29 0.43 0.21 1000000
+ 0.29 0.43 0.21 8071429
+ 0.29 0.43 0.21 15142857
+ 0.29 0.43 0.21 22214286
+ 0.29 0.43 0.21 29285714
+ 0.29 0.43 0.21 36357143
+ 0.29 0.43 0.21 43428571
+ 0.29 0.43 0.21 50500000
+ 0.29 0.43 0.21 57571429
+ 0.29 0.43 0.21 64642857
+ 0.29 0.43 0.21 71714286
+ 0.29 0.43 0.21 78785714
+ 0.29 0.43 0.21 85857143
+ 0.29 0.43 0.21 92928571
+ 0.29 0.43 0.21 100000000
+ 0.29 0.43 0.29 1000000
+ 0.29 0.43 0.29 8071429
+ 0.29 0.43 0.29 15142857
+ 0.29 0.43 0.29 22214286
+ 0.29 0.43 0.29 29285714
+ 0.29 0.43 0.29 36357143
+ 0.29 0.43 0.29 43428571
+ 0.29 0.43 0.29 50500000
+ 0.29 0.43 0.29 57571429
+ 0.29 0.43 0.29 64642857
+ 0.29 0.43 0.29 71714286
+ 0.29 0.43 0.29 78785714
+ 0.29 0.43 0.29 85857143
+ 0.29 0.43 0.29 92928571
+ 0.29 0.43 0.29 100000000
+ 0.29 0.43 0.36 1000000
+ 0.29 0.43 0.36 8071429
+ 0.29 0.43 0.36 15142857
+ 0.29 0.43 0.36 22214286
+ 0.29 0.43 0.36 29285714
+ 0.29 0.43 0.36 36357143
+ 0.29 0.43 0.36 43428571
+ 0.29 0.43 0.36 50500000
+ 0.29 0.43 0.36 57571429
+ 0.29 0.43 0.36 64642857
+ 0.29 0.43 0.36 71714286
+ 0.29 0.43 0.36 78785714
+ 0.29 0.43 0.36 85857143
+ 0.29 0.43 0.36 92928571
+ 0.29 0.43 0.36 100000000
+ 0.29 0.43 0.43 1000000
+ 0.29 0.43 0.43 8071429
+ 0.29 0.43 0.43 15142857
+ 0.29 0.43 0.43 22214286
+ 0.29 0.43 0.43 29285714
+ 0.29 0.43 0.43 36357143
+ 0.29 0.43 0.43 43428571
+ 0.29 0.43 0.43 50500000
+ 0.29 0.43 0.43 57571429
+ 0.29 0.43 0.43 64642857
+ 0.29 0.43 0.43 71714286
+ 0.29 0.43 0.43 78785714
+ 0.29 0.43 0.43 85857143
+ 0.29 0.43 0.43 92928571
+ 0.29 0.43 0.43 100000000
+ 0.29 0.43 0.50 1000000
+ 0.29 0.43 0.50 8071429
+ 0.29 0.43 0.50 15142857
+ 0.29 0.43 0.50 22214286
+ 0.29 0.43 0.50 29285714
+ 0.29 0.43 0.50 36357143
+ 0.29 0.43 0.50 43428571
+ 0.29 0.43 0.50 50500000
+ 0.29 0.43 0.50 57571429
+ 0.29 0.43 0.50 64642857
+ 0.29 0.43 0.50 71714286
+ 0.29 0.43 0.50 78785714
+ 0.29 0.43 0.50 85857143
+ 0.29 0.43 0.50 92928571
+ 0.29 0.43 0.50 100000000
+ 0.29 0.43 0.57 1000000
+ 0.29 0.43 0.57 8071429
+ 0.29 0.43 0.57 15142857
+ 0.29 0.43 0.57 22214286
+ 0.29 0.43 0.57 29285714
+ 0.29 0.43 0.57 36357143
+ 0.29 0.43 0.57 43428571
+ 0.29 0.43 0.57 50500000
+ 0.29 0.43 0.57 57571429
+ 0.29 0.43 0.57 64642857
+ 0.29 0.43 0.57 71714286
+ 0.29 0.43 0.57 78785714
+ 0.29 0.43 0.57 85857143
+ 0.29 0.43 0.57 92928571
+ 0.29 0.43 0.57 100000000
+ 0.29 0.43 0.64 1000000
+ 0.29 0.43 0.64 8071429
+ 0.29 0.43 0.64 15142857
+ 0.29 0.43 0.64 22214286
+ 0.29 0.43 0.64 29285714
+ 0.29 0.43 0.64 36357143
+ 0.29 0.43 0.64 43428571
+ 0.29 0.43 0.64 50500000
+ 0.29 0.43 0.64 57571429
+ 0.29 0.43 0.64 64642857
+ 0.29 0.43 0.64 71714286
+ 0.29 0.43 0.64 78785714
+ 0.29 0.43 0.64 85857143
+ 0.29 0.43 0.64 92928571
+ 0.29 0.43 0.64 100000000
+ 0.29 0.43 0.71 1000000
+ 0.29 0.43 0.71 8071429
+ 0.29 0.43 0.71 15142857
+ 0.29 0.43 0.71 22214286
+ 0.29 0.43 0.71 29285714
+ 0.29 0.43 0.71 36357143
+ 0.29 0.43 0.71 43428571
+ 0.29 0.43 0.71 50500000
+ 0.29 0.43 0.71 57571429
+ 0.29 0.43 0.71 64642857
+ 0.29 0.43 0.71 71714286
+ 0.29 0.43 0.71 78785714
+ 0.29 0.43 0.71 85857143
+ 0.29 0.43 0.71 92928571
+ 0.29 0.43 0.71 100000000
+ 0.29 0.43 0.79 1000000
+ 0.29 0.43 0.79 8071429
+ 0.29 0.43 0.79 15142857
+ 0.29 0.43 0.79 22214286
+ 0.29 0.43 0.79 29285714
+ 0.29 0.43 0.79 36357143
+ 0.29 0.43 0.79 43428571
+ 0.29 0.43 0.79 50500000
+ 0.29 0.43 0.79 57571429
+ 0.29 0.43 0.79 64642857
+ 0.29 0.43 0.79 71714286
+ 0.29 0.43 0.79 78785714
+ 0.29 0.43 0.79 85857143
+ 0.29 0.43 0.79 92928571
+ 0.29 0.43 0.79 100000000
+ 0.29 0.43 0.86 1000000
+ 0.29 0.43 0.86 8071429
+ 0.29 0.43 0.86 15142857
+ 0.29 0.43 0.86 22214286
+ 0.29 0.43 0.86 29285714
+ 0.29 0.43 0.86 36357143
+ 0.29 0.43 0.86 43428571
+ 0.29 0.43 0.86 50500000
+ 0.29 0.43 0.86 57571429
+ 0.29 0.43 0.86 64642857
+ 0.29 0.43 0.86 71714286
+ 0.29 0.43 0.86 78785714
+ 0.29 0.43 0.86 85857143
+ 0.29 0.43 0.86 92928571
+ 0.29 0.43 0.86 100000000
+ 0.29 0.43 0.93 1000000
+ 0.29 0.43 0.93 8071429
+ 0.29 0.43 0.93 15142857
+ 0.29 0.43 0.93 22214286
+ 0.29 0.43 0.93 29285714
+ 0.29 0.43 0.93 36357143
+ 0.29 0.43 0.93 43428571
+ 0.29 0.43 0.93 50500000
+ 0.29 0.43 0.93 57571429
+ 0.29 0.43 0.93 64642857
+ 0.29 0.43 0.93 71714286
+ 0.29 0.43 0.93 78785714
+ 0.29 0.43 0.93 85857143
+ 0.29 0.43 0.93 92928571
+ 0.29 0.43 0.93 100000000
+ 0.29 0.43 1.00 1000000
+ 0.29 0.43 1.00 8071429
+ 0.29 0.43 1.00 15142857
+ 0.29 0.43 1.00 22214286
+ 0.29 0.43 1.00 29285714
+ 0.29 0.43 1.00 36357143
+ 0.29 0.43 1.00 43428571
+ 0.29 0.43 1.00 50500000
+ 0.29 0.43 1.00 57571429
+ 0.29 0.43 1.00 64642857
+ 0.29 0.43 1.00 71714286
+ 0.29 0.43 1.00 78785714
+ 0.29 0.43 1.00 85857143
+ 0.29 0.43 1.00 92928571
+ 0.29 0.43 1.00 100000000
+ 0.29 0.50 0.00 1000000
+ 0.29 0.50 0.00 8071429
+ 0.29 0.50 0.00 15142857
+ 0.29 0.50 0.00 22214286
+ 0.29 0.50 0.00 29285714
+ 0.29 0.50 0.00 36357143
+ 0.29 0.50 0.00 43428571
+ 0.29 0.50 0.00 50500000
+ 0.29 0.50 0.00 57571429
+ 0.29 0.50 0.00 64642857
+ 0.29 0.50 0.00 71714286
+ 0.29 0.50 0.00 78785714
+ 0.29 0.50 0.00 85857143
+ 0.29 0.50 0.00 92928571
+ 0.29 0.50 0.00 100000000
+ 0.29 0.50 0.07 1000000
+ 0.29 0.50 0.07 8071429
+ 0.29 0.50 0.07 15142857
+ 0.29 0.50 0.07 22214286
+ 0.29 0.50 0.07 29285714
+ 0.29 0.50 0.07 36357143
+ 0.29 0.50 0.07 43428571
+ 0.29 0.50 0.07 50500000
+ 0.29 0.50 0.07 57571429
+ 0.29 0.50 0.07 64642857
+ 0.29 0.50 0.07 71714286
+ 0.29 0.50 0.07 78785714
+ 0.29 0.50 0.07 85857143
+ 0.29 0.50 0.07 92928571
+ 0.29 0.50 0.07 100000000
+ 0.29 0.50 0.14 1000000
+ 0.29 0.50 0.14 8071429
+ 0.29 0.50 0.14 15142857
+ 0.29 0.50 0.14 22214286
+ 0.29 0.50 0.14 29285714
+ 0.29 0.50 0.14 36357143
+ 0.29 0.50 0.14 43428571
+ 0.29 0.50 0.14 50500000
+ 0.29 0.50 0.14 57571429
+ 0.29 0.50 0.14 64642857
+ 0.29 0.50 0.14 71714286
+ 0.29 0.50 0.14 78785714
+ 0.29 0.50 0.14 85857143
+ 0.29 0.50 0.14 92928571
+ 0.29 0.50 0.14 100000000
+ 0.29 0.50 0.21 1000000
+ 0.29 0.50 0.21 8071429
+ 0.29 0.50 0.21 15142857
+ 0.29 0.50 0.21 22214286
+ 0.29 0.50 0.21 29285714
+ 0.29 0.50 0.21 36357143
+ 0.29 0.50 0.21 43428571
+ 0.29 0.50 0.21 50500000
+ 0.29 0.50 0.21 57571429
+ 0.29 0.50 0.21 64642857
+ 0.29 0.50 0.21 71714286
+ 0.29 0.50 0.21 78785714
+ 0.29 0.50 0.21 85857143
+ 0.29 0.50 0.21 92928571
+ 0.29 0.50 0.21 100000000
+ 0.29 0.50 0.29 1000000
+ 0.29 0.50 0.29 8071429
+ 0.29 0.50 0.29 15142857
+ 0.29 0.50 0.29 22214286
+ 0.29 0.50 0.29 29285714
+ 0.29 0.50 0.29 36357143
+ 0.29 0.50 0.29 43428571
+ 0.29 0.50 0.29 50500000
+ 0.29 0.50 0.29 57571429
+ 0.29 0.50 0.29 64642857
+ 0.29 0.50 0.29 71714286
+ 0.29 0.50 0.29 78785714
+ 0.29 0.50 0.29 85857143
+ 0.29 0.50 0.29 92928571
+ 0.29 0.50 0.29 100000000
+ 0.29 0.50 0.36 1000000
+ 0.29 0.50 0.36 8071429
+ 0.29 0.50 0.36 15142857
+ 0.29 0.50 0.36 22214286
+ 0.29 0.50 0.36 29285714
+ 0.29 0.50 0.36 36357143
+ 0.29 0.50 0.36 43428571
+ 0.29 0.50 0.36 50500000
+ 0.29 0.50 0.36 57571429
+ 0.29 0.50 0.36 64642857
+ 0.29 0.50 0.36 71714286
+ 0.29 0.50 0.36 78785714
+ 0.29 0.50 0.36 85857143
+ 0.29 0.50 0.36 92928571
+ 0.29 0.50 0.36 100000000
+ 0.29 0.50 0.43 1000000
+ 0.29 0.50 0.43 8071429
+ 0.29 0.50 0.43 15142857
+ 0.29 0.50 0.43 22214286
+ 0.29 0.50 0.43 29285714
+ 0.29 0.50 0.43 36357143
+ 0.29 0.50 0.43 43428571
+ 0.29 0.50 0.43 50500000
+ 0.29 0.50 0.43 57571429
+ 0.29 0.50 0.43 64642857
+ 0.29 0.50 0.43 71714286
+ 0.29 0.50 0.43 78785714
+ 0.29 0.50 0.43 85857143
+ 0.29 0.50 0.43 92928571
+ 0.29 0.50 0.43 100000000
+ 0.29 0.50 0.50 1000000
+ 0.29 0.50 0.50 8071429
+ 0.29 0.50 0.50 15142857
+ 0.29 0.50 0.50 22214286
+ 0.29 0.50 0.50 29285714
+ 0.29 0.50 0.50 36357143
+ 0.29 0.50 0.50 43428571
+ 0.29 0.50 0.50 50500000
+ 0.29 0.50 0.50 57571429
+ 0.29 0.50 0.50 64642857
+ 0.29 0.50 0.50 71714286
+ 0.29 0.50 0.50 78785714
+ 0.29 0.50 0.50 85857143
+ 0.29 0.50 0.50 92928571
+ 0.29 0.50 0.50 100000000
+ 0.29 0.50 0.57 1000000
+ 0.29 0.50 0.57 8071429
+ 0.29 0.50 0.57 15142857
+ 0.29 0.50 0.57 22214286
+ 0.29 0.50 0.57 29285714
+ 0.29 0.50 0.57 36357143
+ 0.29 0.50 0.57 43428571
+ 0.29 0.50 0.57 50500000
+ 0.29 0.50 0.57 57571429
+ 0.29 0.50 0.57 64642857
+ 0.29 0.50 0.57 71714286
+ 0.29 0.50 0.57 78785714
+ 0.29 0.50 0.57 85857143
+ 0.29 0.50 0.57 92928571
+ 0.29 0.50 0.57 100000000
+ 0.29 0.50 0.64 1000000
+ 0.29 0.50 0.64 8071429
+ 0.29 0.50 0.64 15142857
+ 0.29 0.50 0.64 22214286
+ 0.29 0.50 0.64 29285714
+ 0.29 0.50 0.64 36357143
+ 0.29 0.50 0.64 43428571
+ 0.29 0.50 0.64 50500000
+ 0.29 0.50 0.64 57571429
+ 0.29 0.50 0.64 64642857
+ 0.29 0.50 0.64 71714286
+ 0.29 0.50 0.64 78785714
+ 0.29 0.50 0.64 85857143
+ 0.29 0.50 0.64 92928571
+ 0.29 0.50 0.64 100000000
+ 0.29 0.50 0.71 1000000
+ 0.29 0.50 0.71 8071429
+ 0.29 0.50 0.71 15142857
+ 0.29 0.50 0.71 22214286
+ 0.29 0.50 0.71 29285714
+ 0.29 0.50 0.71 36357143
+ 0.29 0.50 0.71 43428571
+ 0.29 0.50 0.71 50500000
+ 0.29 0.50 0.71 57571429
+ 0.29 0.50 0.71 64642857
+ 0.29 0.50 0.71 71714286
+ 0.29 0.50 0.71 78785714
+ 0.29 0.50 0.71 85857143
+ 0.29 0.50 0.71 92928571
+ 0.29 0.50 0.71 100000000
+ 0.29 0.50 0.79 1000000
+ 0.29 0.50 0.79 8071429
+ 0.29 0.50 0.79 15142857
+ 0.29 0.50 0.79 22214286
+ 0.29 0.50 0.79 29285714
+ 0.29 0.50 0.79 36357143
+ 0.29 0.50 0.79 43428571
+ 0.29 0.50 0.79 50500000
+ 0.29 0.50 0.79 57571429
+ 0.29 0.50 0.79 64642857
+ 0.29 0.50 0.79 71714286
+ 0.29 0.50 0.79 78785714
+ 0.29 0.50 0.79 85857143
+ 0.29 0.50 0.79 92928571
+ 0.29 0.50 0.79 100000000
+ 0.29 0.50 0.86 1000000
+ 0.29 0.50 0.86 8071429
+ 0.29 0.50 0.86 15142857
+ 0.29 0.50 0.86 22214286
+ 0.29 0.50 0.86 29285714
+ 0.29 0.50 0.86 36357143
+ 0.29 0.50 0.86 43428571
+ 0.29 0.50 0.86 50500000
+ 0.29 0.50 0.86 57571429
+ 0.29 0.50 0.86 64642857
+ 0.29 0.50 0.86 71714286
+ 0.29 0.50 0.86 78785714
+ 0.29 0.50 0.86 85857143
+ 0.29 0.50 0.86 92928571
+ 0.29 0.50 0.86 100000000
+ 0.29 0.50 0.93 1000000
+ 0.29 0.50 0.93 8071429
+ 0.29 0.50 0.93 15142857
+ 0.29 0.50 0.93 22214286
+ 0.29 0.50 0.93 29285714
+ 0.29 0.50 0.93 36357143
+ 0.29 0.50 0.93 43428571
+ 0.29 0.50 0.93 50500000
+ 0.29 0.50 0.93 57571429
+ 0.29 0.50 0.93 64642857
+ 0.29 0.50 0.93 71714286
+ 0.29 0.50 0.93 78785714
+ 0.29 0.50 0.93 85857143
+ 0.29 0.50 0.93 92928571
+ 0.29 0.50 0.93 100000000
+ 0.29 0.50 1.00 1000000
+ 0.29 0.50 1.00 8071429
+ 0.29 0.50 1.00 15142857
+ 0.29 0.50 1.00 22214286
+ 0.29 0.50 1.00 29285714
+ 0.29 0.50 1.00 36357143
+ 0.29 0.50 1.00 43428571
+ 0.29 0.50 1.00 50500000
+ 0.29 0.50 1.00 57571429
+ 0.29 0.50 1.00 64642857
+ 0.29 0.50 1.00 71714286
+ 0.29 0.50 1.00 78785714
+ 0.29 0.50 1.00 85857143
+ 0.29 0.50 1.00 92928571
+ 0.29 0.50 1.00 100000000
+ 0.29 0.57 0.00 1000000
+ 0.29 0.57 0.00 8071429
+ 0.29 0.57 0.00 15142857
+ 0.29 0.57 0.00 22214286
+ 0.29 0.57 0.00 29285714
+ 0.29 0.57 0.00 36357143
+ 0.29 0.57 0.00 43428571
+ 0.29 0.57 0.00 50500000
+ 0.29 0.57 0.00 57571429
+ 0.29 0.57 0.00 64642857
+ 0.29 0.57 0.00 71714286
+ 0.29 0.57 0.00 78785714
+ 0.29 0.57 0.00 85857143
+ 0.29 0.57 0.00 92928571
+ 0.29 0.57 0.00 100000000
+ 0.29 0.57 0.07 1000000
+ 0.29 0.57 0.07 8071429
+ 0.29 0.57 0.07 15142857
+ 0.29 0.57 0.07 22214286
+ 0.29 0.57 0.07 29285714
+ 0.29 0.57 0.07 36357143
+ 0.29 0.57 0.07 43428571
+ 0.29 0.57 0.07 50500000
+ 0.29 0.57 0.07 57571429
+ 0.29 0.57 0.07 64642857
+ 0.29 0.57 0.07 71714286
+ 0.29 0.57 0.07 78785714
+ 0.29 0.57 0.07 85857143
+ 0.29 0.57 0.07 92928571
+ 0.29 0.57 0.07 100000000
+ 0.29 0.57 0.14 1000000
+ 0.29 0.57 0.14 8071429
+ 0.29 0.57 0.14 15142857
+ 0.29 0.57 0.14 22214286
+ 0.29 0.57 0.14 29285714
+ 0.29 0.57 0.14 36357143
+ 0.29 0.57 0.14 43428571
+ 0.29 0.57 0.14 50500000
+ 0.29 0.57 0.14 57571429
+ 0.29 0.57 0.14 64642857
+ 0.29 0.57 0.14 71714286
+ 0.29 0.57 0.14 78785714
+ 0.29 0.57 0.14 85857143
+ 0.29 0.57 0.14 92928571
+ 0.29 0.57 0.14 100000000
+ 0.29 0.57 0.21 1000000
+ 0.29 0.57 0.21 8071429
+ 0.29 0.57 0.21 15142857
+ 0.29 0.57 0.21 22214286
+ 0.29 0.57 0.21 29285714
+ 0.29 0.57 0.21 36357143
+ 0.29 0.57 0.21 43428571
+ 0.29 0.57 0.21 50500000
+ 0.29 0.57 0.21 57571429
+ 0.29 0.57 0.21 64642857
+ 0.29 0.57 0.21 71714286
+ 0.29 0.57 0.21 78785714
+ 0.29 0.57 0.21 85857143
+ 0.29 0.57 0.21 92928571
+ 0.29 0.57 0.21 100000000
+ 0.29 0.57 0.29 1000000
+ 0.29 0.57 0.29 8071429
+ 0.29 0.57 0.29 15142857
+ 0.29 0.57 0.29 22214286
+ 0.29 0.57 0.29 29285714
+ 0.29 0.57 0.29 36357143
+ 0.29 0.57 0.29 43428571
+ 0.29 0.57 0.29 50500000
+ 0.29 0.57 0.29 57571429
+ 0.29 0.57 0.29 64642857
+ 0.29 0.57 0.29 71714286
+ 0.29 0.57 0.29 78785714
+ 0.29 0.57 0.29 85857143
+ 0.29 0.57 0.29 92928571
+ 0.29 0.57 0.29 100000000
+ 0.29 0.57 0.36 1000000
+ 0.29 0.57 0.36 8071429
+ 0.29 0.57 0.36 15142857
+ 0.29 0.57 0.36 22214286
+ 0.29 0.57 0.36 29285714
+ 0.29 0.57 0.36 36357143
+ 0.29 0.57 0.36 43428571
+ 0.29 0.57 0.36 50500000
+ 0.29 0.57 0.36 57571429
+ 0.29 0.57 0.36 64642857
+ 0.29 0.57 0.36 71714286
+ 0.29 0.57 0.36 78785714
+ 0.29 0.57 0.36 85857143
+ 0.29 0.57 0.36 92928571
+ 0.29 0.57 0.36 100000000
+ 0.29 0.57 0.43 1000000
+ 0.29 0.57 0.43 8071429
+ 0.29 0.57 0.43 15142857
+ 0.29 0.57 0.43 22214286
+ 0.29 0.57 0.43 29285714
+ 0.29 0.57 0.43 36357143
+ 0.29 0.57 0.43 43428571
+ 0.29 0.57 0.43 50500000
+ 0.29 0.57 0.43 57571429
+ 0.29 0.57 0.43 64642857
+ 0.29 0.57 0.43 71714286
+ 0.29 0.57 0.43 78785714
+ 0.29 0.57 0.43 85857143
+ 0.29 0.57 0.43 92928571
+ 0.29 0.57 0.43 100000000
+ 0.29 0.57 0.50 1000000
+ 0.29 0.57 0.50 8071429
+ 0.29 0.57 0.50 15142857
+ 0.29 0.57 0.50 22214286
+ 0.29 0.57 0.50 29285714
+ 0.29 0.57 0.50 36357143
+ 0.29 0.57 0.50 43428571
+ 0.29 0.57 0.50 50500000
+ 0.29 0.57 0.50 57571429
+ 0.29 0.57 0.50 64642857
+ 0.29 0.57 0.50 71714286
+ 0.29 0.57 0.50 78785714
+ 0.29 0.57 0.50 85857143
+ 0.29 0.57 0.50 92928571
+ 0.29 0.57 0.50 100000000
+ 0.29 0.57 0.57 1000000
+ 0.29 0.57 0.57 8071429
+ 0.29 0.57 0.57 15142857
+ 0.29 0.57 0.57 22214286
+ 0.29 0.57 0.57 29285714
+ 0.29 0.57 0.57 36357143
+ 0.29 0.57 0.57 43428571
+ 0.29 0.57 0.57 50500000
+ 0.29 0.57 0.57 57571429
+ 0.29 0.57 0.57 64642857
+ 0.29 0.57 0.57 71714286
+ 0.29 0.57 0.57 78785714
+ 0.29 0.57 0.57 85857143
+ 0.29 0.57 0.57 92928571
+ 0.29 0.57 0.57 100000000
+ 0.29 0.57 0.64 1000000
+ 0.29 0.57 0.64 8071429
+ 0.29 0.57 0.64 15142857
+ 0.29 0.57 0.64 22214286
+ 0.29 0.57 0.64 29285714
+ 0.29 0.57 0.64 36357143
+ 0.29 0.57 0.64 43428571
+ 0.29 0.57 0.64 50500000
+ 0.29 0.57 0.64 57571429
+ 0.29 0.57 0.64 64642857
+ 0.29 0.57 0.64 71714286
+ 0.29 0.57 0.64 78785714
+ 0.29 0.57 0.64 85857143
+ 0.29 0.57 0.64 92928571
+ 0.29 0.57 0.64 100000000
+ 0.29 0.57 0.71 1000000
+ 0.29 0.57 0.71 8071429
+ 0.29 0.57 0.71 15142857
+ 0.29 0.57 0.71 22214286
+ 0.29 0.57 0.71 29285714
+ 0.29 0.57 0.71 36357143
+ 0.29 0.57 0.71 43428571
+ 0.29 0.57 0.71 50500000
+ 0.29 0.57 0.71 57571429
+ 0.29 0.57 0.71 64642857
+ 0.29 0.57 0.71 71714286
+ 0.29 0.57 0.71 78785714
+ 0.29 0.57 0.71 85857143
+ 0.29 0.57 0.71 92928571
+ 0.29 0.57 0.71 100000000
+ 0.29 0.57 0.79 1000000
+ 0.29 0.57 0.79 8071429
+ 0.29 0.57 0.79 15142857
+ 0.29 0.57 0.79 22214286
+ 0.29 0.57 0.79 29285714
+ 0.29 0.57 0.79 36357143
+ 0.29 0.57 0.79 43428571
+ 0.29 0.57 0.79 50500000
+ 0.29 0.57 0.79 57571429
+ 0.29 0.57 0.79 64642857
+ 0.29 0.57 0.79 71714286
+ 0.29 0.57 0.79 78785714
+ 0.29 0.57 0.79 85857143
+ 0.29 0.57 0.79 92928571
+ 0.29 0.57 0.79 100000000
+ 0.29 0.57 0.86 1000000
+ 0.29 0.57 0.86 8071429
+ 0.29 0.57 0.86 15142857
+ 0.29 0.57 0.86 22214286
+ 0.29 0.57 0.86 29285714
+ 0.29 0.57 0.86 36357143
+ 0.29 0.57 0.86 43428571
+ 0.29 0.57 0.86 50500000
+ 0.29 0.57 0.86 57571429
+ 0.29 0.57 0.86 64642857
+ 0.29 0.57 0.86 71714286
+ 0.29 0.57 0.86 78785714
+ 0.29 0.57 0.86 85857143
+ 0.29 0.57 0.86 92928571
+ 0.29 0.57 0.86 100000000
+ 0.29 0.57 0.93 1000000
+ 0.29 0.57 0.93 8071429
+ 0.29 0.57 0.93 15142857
+ 0.29 0.57 0.93 22214286
+ 0.29 0.57 0.93 29285714
+ 0.29 0.57 0.93 36357143
+ 0.29 0.57 0.93 43428571
+ 0.29 0.57 0.93 50500000
+ 0.29 0.57 0.93 57571429
+ 0.29 0.57 0.93 64642857
+ 0.29 0.57 0.93 71714286
+ 0.29 0.57 0.93 78785714
+ 0.29 0.57 0.93 85857143
+ 0.29 0.57 0.93 92928571
+ 0.29 0.57 0.93 100000000
+ 0.29 0.57 1.00 1000000
+ 0.29 0.57 1.00 8071429
+ 0.29 0.57 1.00 15142857
+ 0.29 0.57 1.00 22214286
+ 0.29 0.57 1.00 29285714
+ 0.29 0.57 1.00 36357143
+ 0.29 0.57 1.00 43428571
+ 0.29 0.57 1.00 50500000
+ 0.29 0.57 1.00 57571429
+ 0.29 0.57 1.00 64642857
+ 0.29 0.57 1.00 71714286
+ 0.29 0.57 1.00 78785714
+ 0.29 0.57 1.00 85857143
+ 0.29 0.57 1.00 92928571
+ 0.29 0.57 1.00 100000000
+ 0.29 0.64 0.00 1000000
+ 0.29 0.64 0.00 8071429
+ 0.29 0.64 0.00 15142857
+ 0.29 0.64 0.00 22214286
+ 0.29 0.64 0.00 29285714
+ 0.29 0.64 0.00 36357143
+ 0.29 0.64 0.00 43428571
+ 0.29 0.64 0.00 50500000
+ 0.29 0.64 0.00 57571429
+ 0.29 0.64 0.00 64642857
+ 0.29 0.64 0.00 71714286
+ 0.29 0.64 0.00 78785714
+ 0.29 0.64 0.00 85857143
+ 0.29 0.64 0.00 92928571
+ 0.29 0.64 0.00 100000000
+ 0.29 0.64 0.07 1000000
+ 0.29 0.64 0.07 8071429
+ 0.29 0.64 0.07 15142857
+ 0.29 0.64 0.07 22214286
+ 0.29 0.64 0.07 29285714
+ 0.29 0.64 0.07 36357143
+ 0.29 0.64 0.07 43428571
+ 0.29 0.64 0.07 50500000
+ 0.29 0.64 0.07 57571429
+ 0.29 0.64 0.07 64642857
+ 0.29 0.64 0.07 71714286
+ 0.29 0.64 0.07 78785714
+ 0.29 0.64 0.07 85857143
+ 0.29 0.64 0.07 92928571
+ 0.29 0.64 0.07 100000000
+ 0.29 0.64 0.14 1000000
+ 0.29 0.64 0.14 8071429
+ 0.29 0.64 0.14 15142857
+ 0.29 0.64 0.14 22214286
+ 0.29 0.64 0.14 29285714
+ 0.29 0.64 0.14 36357143
+ 0.29 0.64 0.14 43428571
+ 0.29 0.64 0.14 50500000
+ 0.29 0.64 0.14 57571429
+ 0.29 0.64 0.14 64642857
+ 0.29 0.64 0.14 71714286
+ 0.29 0.64 0.14 78785714
+ 0.29 0.64 0.14 85857143
+ 0.29 0.64 0.14 92928571
+ 0.29 0.64 0.14 100000000
+ 0.29 0.64 0.21 1000000
+ 0.29 0.64 0.21 8071429
+ 0.29 0.64 0.21 15142857
+ 0.29 0.64 0.21 22214286
+ 0.29 0.64 0.21 29285714
+ 0.29 0.64 0.21 36357143
+ 0.29 0.64 0.21 43428571
+ 0.29 0.64 0.21 50500000
+ 0.29 0.64 0.21 57571429
+ 0.29 0.64 0.21 64642857
+ 0.29 0.64 0.21 71714286
+ 0.29 0.64 0.21 78785714
+ 0.29 0.64 0.21 85857143
+ 0.29 0.64 0.21 92928571
+ 0.29 0.64 0.21 100000000
+ 0.29 0.64 0.29 1000000
+ 0.29 0.64 0.29 8071429
+ 0.29 0.64 0.29 15142857
+ 0.29 0.64 0.29 22214286
+ 0.29 0.64 0.29 29285714
+ 0.29 0.64 0.29 36357143
+ 0.29 0.64 0.29 43428571
+ 0.29 0.64 0.29 50500000
+ 0.29 0.64 0.29 57571429
+ 0.29 0.64 0.29 64642857
+ 0.29 0.64 0.29 71714286
+ 0.29 0.64 0.29 78785714
+ 0.29 0.64 0.29 85857143
+ 0.29 0.64 0.29 92928571
+ 0.29 0.64 0.29 100000000
+ 0.29 0.64 0.36 1000000
+ 0.29 0.64 0.36 8071429
+ 0.29 0.64 0.36 15142857
+ 0.29 0.64 0.36 22214286
+ 0.29 0.64 0.36 29285714
+ 0.29 0.64 0.36 36357143
+ 0.29 0.64 0.36 43428571
+ 0.29 0.64 0.36 50500000
+ 0.29 0.64 0.36 57571429
+ 0.29 0.64 0.36 64642857
+ 0.29 0.64 0.36 71714286
+ 0.29 0.64 0.36 78785714
+ 0.29 0.64 0.36 85857143
+ 0.29 0.64 0.36 92928571
+ 0.29 0.64 0.36 100000000
+ 0.29 0.64 0.43 1000000
+ 0.29 0.64 0.43 8071429
+ 0.29 0.64 0.43 15142857
+ 0.29 0.64 0.43 22214286
+ 0.29 0.64 0.43 29285714
+ 0.29 0.64 0.43 36357143
+ 0.29 0.64 0.43 43428571
+ 0.29 0.64 0.43 50500000
+ 0.29 0.64 0.43 57571429
+ 0.29 0.64 0.43 64642857
+ 0.29 0.64 0.43 71714286
+ 0.29 0.64 0.43 78785714
+ 0.29 0.64 0.43 85857143
+ 0.29 0.64 0.43 92928571
+ 0.29 0.64 0.43 100000000
+ 0.29 0.64 0.50 1000000
+ 0.29 0.64 0.50 8071429
+ 0.29 0.64 0.50 15142857
+ 0.29 0.64 0.50 22214286
+ 0.29 0.64 0.50 29285714
+ 0.29 0.64 0.50 36357143
+ 0.29 0.64 0.50 43428571
+ 0.29 0.64 0.50 50500000
+ 0.29 0.64 0.50 57571429
+ 0.29 0.64 0.50 64642857
+ 0.29 0.64 0.50 71714286
+ 0.29 0.64 0.50 78785714
+ 0.29 0.64 0.50 85857143
+ 0.29 0.64 0.50 92928571
+ 0.29 0.64 0.50 100000000
+ 0.29 0.64 0.57 1000000
+ 0.29 0.64 0.57 8071429
+ 0.29 0.64 0.57 15142857
+ 0.29 0.64 0.57 22214286
+ 0.29 0.64 0.57 29285714
+ 0.29 0.64 0.57 36357143
+ 0.29 0.64 0.57 43428571
+ 0.29 0.64 0.57 50500000
+ 0.29 0.64 0.57 57571429
+ 0.29 0.64 0.57 64642857
+ 0.29 0.64 0.57 71714286
+ 0.29 0.64 0.57 78785714
+ 0.29 0.64 0.57 85857143
+ 0.29 0.64 0.57 92928571
+ 0.29 0.64 0.57 100000000
+ 0.29 0.64 0.64 1000000
+ 0.29 0.64 0.64 8071429
+ 0.29 0.64 0.64 15142857
+ 0.29 0.64 0.64 22214286
+ 0.29 0.64 0.64 29285714
+ 0.29 0.64 0.64 36357143
+ 0.29 0.64 0.64 43428571
+ 0.29 0.64 0.64 50500000
+ 0.29 0.64 0.64 57571429
+ 0.29 0.64 0.64 64642857
+ 0.29 0.64 0.64 71714286
+ 0.29 0.64 0.64 78785714
+ 0.29 0.64 0.64 85857143
+ 0.29 0.64 0.64 92928571
+ 0.29 0.64 0.64 100000000
+ 0.29 0.64 0.71 1000000
+ 0.29 0.64 0.71 8071429
+ 0.29 0.64 0.71 15142857
+ 0.29 0.64 0.71 22214286
+ 0.29 0.64 0.71 29285714
+ 0.29 0.64 0.71 36357143
+ 0.29 0.64 0.71 43428571
+ 0.29 0.64 0.71 50500000
+ 0.29 0.64 0.71 57571429
+ 0.29 0.64 0.71 64642857
+ 0.29 0.64 0.71 71714286
+ 0.29 0.64 0.71 78785714
+ 0.29 0.64 0.71 85857143
+ 0.29 0.64 0.71 92928571
+ 0.29 0.64 0.71 100000000
+ 0.29 0.64 0.79 1000000
+ 0.29 0.64 0.79 8071429
+ 0.29 0.64 0.79 15142857
+ 0.29 0.64 0.79 22214286
+ 0.29 0.64 0.79 29285714
+ 0.29 0.64 0.79 36357143
+ 0.29 0.64 0.79 43428571
+ 0.29 0.64 0.79 50500000
+ 0.29 0.64 0.79 57571429
+ 0.29 0.64 0.79 64642857
+ 0.29 0.64 0.79 71714286
+ 0.29 0.64 0.79 78785714
+ 0.29 0.64 0.79 85857143
+ 0.29 0.64 0.79 92928571
+ 0.29 0.64 0.79 100000000
+ 0.29 0.64 0.86 1000000
+ 0.29 0.64 0.86 8071429
+ 0.29 0.64 0.86 15142857
+ 0.29 0.64 0.86 22214286
+ 0.29 0.64 0.86 29285714
+ 0.29 0.64 0.86 36357143
+ 0.29 0.64 0.86 43428571
+ 0.29 0.64 0.86 50500000
+ 0.29 0.64 0.86 57571429
+ 0.29 0.64 0.86 64642857
+ 0.29 0.64 0.86 71714286
+ 0.29 0.64 0.86 78785714
+ 0.29 0.64 0.86 85857143
+ 0.29 0.64 0.86 92928571
+ 0.29 0.64 0.86 100000000
+ 0.29 0.64 0.93 1000000
+ 0.29 0.64 0.93 8071429
+ 0.29 0.64 0.93 15142857
+ 0.29 0.64 0.93 22214286
+ 0.29 0.64 0.93 29285714
+ 0.29 0.64 0.93 36357143
+ 0.29 0.64 0.93 43428571
+ 0.29 0.64 0.93 50500000
+ 0.29 0.64 0.93 57571429
+ 0.29 0.64 0.93 64642857
+ 0.29 0.64 0.93 71714286
+ 0.29 0.64 0.93 78785714
+ 0.29 0.64 0.93 85857143
+ 0.29 0.64 0.93 92928571
+ 0.29 0.64 0.93 100000000
+ 0.29 0.64 1.00 1000000
+ 0.29 0.64 1.00 8071429
+ 0.29 0.64 1.00 15142857
+ 0.29 0.64 1.00 22214286
+ 0.29 0.64 1.00 29285714
+ 0.29 0.64 1.00 36357143
+ 0.29 0.64 1.00 43428571
+ 0.29 0.64 1.00 50500000
+ 0.29 0.64 1.00 57571429
+ 0.29 0.64 1.00 64642857
+ 0.29 0.64 1.00 71714286
+ 0.29 0.64 1.00 78785714
+ 0.29 0.64 1.00 85857143
+ 0.29 0.64 1.00 92928571
+ 0.29 0.64 1.00 100000000
+ 0.29 0.71 0.00 1000000
+ 0.29 0.71 0.00 8071429
+ 0.29 0.71 0.00 15142857
+ 0.29 0.71 0.00 22214286
+ 0.29 0.71 0.00 29285714
+ 0.29 0.71 0.00 36357143
+ 0.29 0.71 0.00 43428571
+ 0.29 0.71 0.00 50500000
+ 0.29 0.71 0.00 57571429
+ 0.29 0.71 0.00 64642857
+ 0.29 0.71 0.00 71714286
+ 0.29 0.71 0.00 78785714
+ 0.29 0.71 0.00 85857143
+ 0.29 0.71 0.00 92928571
+ 0.29 0.71 0.00 100000000
+ 0.29 0.71 0.07 1000000
+ 0.29 0.71 0.07 8071429
+ 0.29 0.71 0.07 15142857
+ 0.29 0.71 0.07 22214286
+ 0.29 0.71 0.07 29285714
+ 0.29 0.71 0.07 36357143
+ 0.29 0.71 0.07 43428571
+ 0.29 0.71 0.07 50500000
+ 0.29 0.71 0.07 57571429
+ 0.29 0.71 0.07 64642857
+ 0.29 0.71 0.07 71714286
+ 0.29 0.71 0.07 78785714
+ 0.29 0.71 0.07 85857143
+ 0.29 0.71 0.07 92928571
+ 0.29 0.71 0.07 100000000
+ 0.29 0.71 0.14 1000000
+ 0.29 0.71 0.14 8071429
+ 0.29 0.71 0.14 15142857
+ 0.29 0.71 0.14 22214286
+ 0.29 0.71 0.14 29285714
+ 0.29 0.71 0.14 36357143
+ 0.29 0.71 0.14 43428571
+ 0.29 0.71 0.14 50500000
+ 0.29 0.71 0.14 57571429
+ 0.29 0.71 0.14 64642857
+ 0.29 0.71 0.14 71714286
+ 0.29 0.71 0.14 78785714
+ 0.29 0.71 0.14 85857143
+ 0.29 0.71 0.14 92928571
+ 0.29 0.71 0.14 100000000
+ 0.29 0.71 0.21 1000000
+ 0.29 0.71 0.21 8071429
+ 0.29 0.71 0.21 15142857
+ 0.29 0.71 0.21 22214286
+ 0.29 0.71 0.21 29285714
+ 0.29 0.71 0.21 36357143
+ 0.29 0.71 0.21 43428571
+ 0.29 0.71 0.21 50500000
+ 0.29 0.71 0.21 57571429
+ 0.29 0.71 0.21 64642857
+ 0.29 0.71 0.21 71714286
+ 0.29 0.71 0.21 78785714
+ 0.29 0.71 0.21 85857143
+ 0.29 0.71 0.21 92928571
+ 0.29 0.71 0.21 100000000
+ 0.29 0.71 0.29 1000000
+ 0.29 0.71 0.29 8071429
+ 0.29 0.71 0.29 15142857
+ 0.29 0.71 0.29 22214286
+ 0.29 0.71 0.29 29285714
+ 0.29 0.71 0.29 36357143
+ 0.29 0.71 0.29 43428571
+ 0.29 0.71 0.29 50500000
+ 0.29 0.71 0.29 57571429
+ 0.29 0.71 0.29 64642857
+ 0.29 0.71 0.29 71714286
+ 0.29 0.71 0.29 78785714
+ 0.29 0.71 0.29 85857143
+ 0.29 0.71 0.29 92928571
+ 0.29 0.71 0.29 100000000
+ 0.29 0.71 0.36 1000000
+ 0.29 0.71 0.36 8071429
+ 0.29 0.71 0.36 15142857
+ 0.29 0.71 0.36 22214286
+ 0.29 0.71 0.36 29285714
+ 0.29 0.71 0.36 36357143
+ 0.29 0.71 0.36 43428571
+ 0.29 0.71 0.36 50500000
+ 0.29 0.71 0.36 57571429
+ 0.29 0.71 0.36 64642857
+ 0.29 0.71 0.36 71714286
+ 0.29 0.71 0.36 78785714
+ 0.29 0.71 0.36 85857143
+ 0.29 0.71 0.36 92928571
+ 0.29 0.71 0.36 100000000
+ 0.29 0.71 0.43 1000000
+ 0.29 0.71 0.43 8071429
+ 0.29 0.71 0.43 15142857
+ 0.29 0.71 0.43 22214286
+ 0.29 0.71 0.43 29285714
+ 0.29 0.71 0.43 36357143
+ 0.29 0.71 0.43 43428571
+ 0.29 0.71 0.43 50500000
+ 0.29 0.71 0.43 57571429
+ 0.29 0.71 0.43 64642857
+ 0.29 0.71 0.43 71714286
+ 0.29 0.71 0.43 78785714
+ 0.29 0.71 0.43 85857143
+ 0.29 0.71 0.43 92928571
+ 0.29 0.71 0.43 100000000
+ 0.29 0.71 0.50 1000000
+ 0.29 0.71 0.50 8071429
+ 0.29 0.71 0.50 15142857
+ 0.29 0.71 0.50 22214286
+ 0.29 0.71 0.50 29285714
+ 0.29 0.71 0.50 36357143
+ 0.29 0.71 0.50 43428571
+ 0.29 0.71 0.50 50500000
+ 0.29 0.71 0.50 57571429
+ 0.29 0.71 0.50 64642857
+ 0.29 0.71 0.50 71714286
+ 0.29 0.71 0.50 78785714
+ 0.29 0.71 0.50 85857143
+ 0.29 0.71 0.50 92928571
+ 0.29 0.71 0.50 100000000
+ 0.29 0.71 0.57 1000000
+ 0.29 0.71 0.57 8071429
+ 0.29 0.71 0.57 15142857
+ 0.29 0.71 0.57 22214286
+ 0.29 0.71 0.57 29285714
+ 0.29 0.71 0.57 36357143
+ 0.29 0.71 0.57 43428571
+ 0.29 0.71 0.57 50500000
+ 0.29 0.71 0.57 57571429
+ 0.29 0.71 0.57 64642857
+ 0.29 0.71 0.57 71714286
+ 0.29 0.71 0.57 78785714
+ 0.29 0.71 0.57 85857143
+ 0.29 0.71 0.57 92928571
+ 0.29 0.71 0.57 100000000
+ 0.29 0.71 0.64 1000000
+ 0.29 0.71 0.64 8071429
+ 0.29 0.71 0.64 15142857
+ 0.29 0.71 0.64 22214286
+ 0.29 0.71 0.64 29285714
+ 0.29 0.71 0.64 36357143
+ 0.29 0.71 0.64 43428571
+ 0.29 0.71 0.64 50500000
+ 0.29 0.71 0.64 57571429
+ 0.29 0.71 0.64 64642857
+ 0.29 0.71 0.64 71714286
+ 0.29 0.71 0.64 78785714
+ 0.29 0.71 0.64 85857143
+ 0.29 0.71 0.64 92928571
+ 0.29 0.71 0.64 100000000
+ 0.29 0.71 0.71 1000000
+ 0.29 0.71 0.71 8071429
+ 0.29 0.71 0.71 15142857
+ 0.29 0.71 0.71 22214286
+ 0.29 0.71 0.71 29285714
+ 0.29 0.71 0.71 36357143
+ 0.29 0.71 0.71 43428571
+ 0.29 0.71 0.71 50500000
+ 0.29 0.71 0.71 57571429
+ 0.29 0.71 0.71 64642857
+ 0.29 0.71 0.71 71714286
+ 0.29 0.71 0.71 78785714
+ 0.29 0.71 0.71 85857143
+ 0.29 0.71 0.71 92928571
+ 0.29 0.71 0.71 100000000
+ 0.29 0.71 0.79 1000000
+ 0.29 0.71 0.79 8071429
+ 0.29 0.71 0.79 15142857
+ 0.29 0.71 0.79 22214286
+ 0.29 0.71 0.79 29285714
+ 0.29 0.71 0.79 36357143
+ 0.29 0.71 0.79 43428571
+ 0.29 0.71 0.79 50500000
+ 0.29 0.71 0.79 57571429
+ 0.29 0.71 0.79 64642857
+ 0.29 0.71 0.79 71714286
+ 0.29 0.71 0.79 78785714
+ 0.29 0.71 0.79 85857143
+ 0.29 0.71 0.79 92928571
+ 0.29 0.71 0.79 100000000
+ 0.29 0.71 0.86 1000000
+ 0.29 0.71 0.86 8071429
+ 0.29 0.71 0.86 15142857
+ 0.29 0.71 0.86 22214286
+ 0.29 0.71 0.86 29285714
+ 0.29 0.71 0.86 36357143
+ 0.29 0.71 0.86 43428571
+ 0.29 0.71 0.86 50500000
+ 0.29 0.71 0.86 57571429
+ 0.29 0.71 0.86 64642857
+ 0.29 0.71 0.86 71714286
+ 0.29 0.71 0.86 78785714
+ 0.29 0.71 0.86 85857143
+ 0.29 0.71 0.86 92928571
+ 0.29 0.71 0.86 100000000
+ 0.29 0.71 0.93 1000000
+ 0.29 0.71 0.93 8071429
+ 0.29 0.71 0.93 15142857
+ 0.29 0.71 0.93 22214286
+ 0.29 0.71 0.93 29285714
+ 0.29 0.71 0.93 36357143
+ 0.29 0.71 0.93 43428571
+ 0.29 0.71 0.93 50500000
+ 0.29 0.71 0.93 57571429
+ 0.29 0.71 0.93 64642857
+ 0.29 0.71 0.93 71714286
+ 0.29 0.71 0.93 78785714
+ 0.29 0.71 0.93 85857143
+ 0.29 0.71 0.93 92928571
+ 0.29 0.71 0.93 100000000
+ 0.29 0.71 1.00 1000000
+ 0.29 0.71 1.00 8071429
+ 0.29 0.71 1.00 15142857
+ 0.29 0.71 1.00 22214286
+ 0.29 0.71 1.00 29285714
+ 0.29 0.71 1.00 36357143
+ 0.29 0.71 1.00 43428571
+ 0.29 0.71 1.00 50500000
+ 0.29 0.71 1.00 57571429
+ 0.29 0.71 1.00 64642857
+ 0.29 0.71 1.00 71714286
+ 0.29 0.71 1.00 78785714
+ 0.29 0.71 1.00 85857143
+ 0.29 0.71 1.00 92928571
+ 0.29 0.71 1.00 100000000
+ 0.29 0.79 0.00 1000000
+ 0.29 0.79 0.00 8071429
+ 0.29 0.79 0.00 15142857
+ 0.29 0.79 0.00 22214286
+ 0.29 0.79 0.00 29285714
+ 0.29 0.79 0.00 36357143
+ 0.29 0.79 0.00 43428571
+ 0.29 0.79 0.00 50500000
+ 0.29 0.79 0.00 57571429
+ 0.29 0.79 0.00 64642857
+ 0.29 0.79 0.00 71714286
+ 0.29 0.79 0.00 78785714
+ 0.29 0.79 0.00 85857143
+ 0.29 0.79 0.00 92928571
+ 0.29 0.79 0.00 100000000
+ 0.29 0.79 0.07 1000000
+ 0.29 0.79 0.07 8071429
+ 0.29 0.79 0.07 15142857
+ 0.29 0.79 0.07 22214286
+ 0.29 0.79 0.07 29285714
+ 0.29 0.79 0.07 36357143
+ 0.29 0.79 0.07 43428571
+ 0.29 0.79 0.07 50500000
+ 0.29 0.79 0.07 57571429
+ 0.29 0.79 0.07 64642857
+ 0.29 0.79 0.07 71714286
+ 0.29 0.79 0.07 78785714
+ 0.29 0.79 0.07 85857143
+ 0.29 0.79 0.07 92928571
+ 0.29 0.79 0.07 100000000
+ 0.29 0.79 0.14 1000000
+ 0.29 0.79 0.14 8071429
+ 0.29 0.79 0.14 15142857
+ 0.29 0.79 0.14 22214286
+ 0.29 0.79 0.14 29285714
+ 0.29 0.79 0.14 36357143
+ 0.29 0.79 0.14 43428571
+ 0.29 0.79 0.14 50500000
+ 0.29 0.79 0.14 57571429
+ 0.29 0.79 0.14 64642857
+ 0.29 0.79 0.14 71714286
+ 0.29 0.79 0.14 78785714
+ 0.29 0.79 0.14 85857143
+ 0.29 0.79 0.14 92928571
+ 0.29 0.79 0.14 100000000
+ 0.29 0.79 0.21 1000000
+ 0.29 0.79 0.21 8071429
+ 0.29 0.79 0.21 15142857
+ 0.29 0.79 0.21 22214286
+ 0.29 0.79 0.21 29285714
+ 0.29 0.79 0.21 36357143
+ 0.29 0.79 0.21 43428571
+ 0.29 0.79 0.21 50500000
+ 0.29 0.79 0.21 57571429
+ 0.29 0.79 0.21 64642857
+ 0.29 0.79 0.21 71714286
+ 0.29 0.79 0.21 78785714
+ 0.29 0.79 0.21 85857143
+ 0.29 0.79 0.21 92928571
+ 0.29 0.79 0.21 100000000
+ 0.29 0.79 0.29 1000000
+ 0.29 0.79 0.29 8071429
+ 0.29 0.79 0.29 15142857
+ 0.29 0.79 0.29 22214286
+ 0.29 0.79 0.29 29285714
+ 0.29 0.79 0.29 36357143
+ 0.29 0.79 0.29 43428571
+ 0.29 0.79 0.29 50500000
+ 0.29 0.79 0.29 57571429
+ 0.29 0.79 0.29 64642857
+ 0.29 0.79 0.29 71714286
+ 0.29 0.79 0.29 78785714
+ 0.29 0.79 0.29 85857143
+ 0.29 0.79 0.29 92928571
+ 0.29 0.79 0.29 100000000
+ 0.29 0.79 0.36 1000000
+ 0.29 0.79 0.36 8071429
+ 0.29 0.79 0.36 15142857
+ 0.29 0.79 0.36 22214286
+ 0.29 0.79 0.36 29285714
+ 0.29 0.79 0.36 36357143
+ 0.29 0.79 0.36 43428571
+ 0.29 0.79 0.36 50500000
+ 0.29 0.79 0.36 57571429
+ 0.29 0.79 0.36 64642857
+ 0.29 0.79 0.36 71714286
+ 0.29 0.79 0.36 78785714
+ 0.29 0.79 0.36 85857143
+ 0.29 0.79 0.36 92928571
+ 0.29 0.79 0.36 100000000
+ 0.29 0.79 0.43 1000000
+ 0.29 0.79 0.43 8071429
+ 0.29 0.79 0.43 15142857
+ 0.29 0.79 0.43 22214286
+ 0.29 0.79 0.43 29285714
+ 0.29 0.79 0.43 36357143
+ 0.29 0.79 0.43 43428571
+ 0.29 0.79 0.43 50500000
+ 0.29 0.79 0.43 57571429
+ 0.29 0.79 0.43 64642857
+ 0.29 0.79 0.43 71714286
+ 0.29 0.79 0.43 78785714
+ 0.29 0.79 0.43 85857143
+ 0.29 0.79 0.43 92928571
+ 0.29 0.79 0.43 100000000
+ 0.29 0.79 0.50 1000000
+ 0.29 0.79 0.50 8071429
+ 0.29 0.79 0.50 15142857
+ 0.29 0.79 0.50 22214286
+ 0.29 0.79 0.50 29285714
+ 0.29 0.79 0.50 36357143
+ 0.29 0.79 0.50 43428571
+ 0.29 0.79 0.50 50500000
+ 0.29 0.79 0.50 57571429
+ 0.29 0.79 0.50 64642857
+ 0.29 0.79 0.50 71714286
+ 0.29 0.79 0.50 78785714
+ 0.29 0.79 0.50 85857143
+ 0.29 0.79 0.50 92928571
+ 0.29 0.79 0.50 100000000
+ 0.29 0.79 0.57 1000000
+ 0.29 0.79 0.57 8071429
+ 0.29 0.79 0.57 15142857
+ 0.29 0.79 0.57 22214286
+ 0.29 0.79 0.57 29285714
+ 0.29 0.79 0.57 36357143
+ 0.29 0.79 0.57 43428571
+ 0.29 0.79 0.57 50500000
+ 0.29 0.79 0.57 57571429
+ 0.29 0.79 0.57 64642857
+ 0.29 0.79 0.57 71714286
+ 0.29 0.79 0.57 78785714
+ 0.29 0.79 0.57 85857143
+ 0.29 0.79 0.57 92928571
+ 0.29 0.79 0.57 100000000
+ 0.29 0.79 0.64 1000000
+ 0.29 0.79 0.64 8071429
+ 0.29 0.79 0.64 15142857
+ 0.29 0.79 0.64 22214286
+ 0.29 0.79 0.64 29285714
+ 0.29 0.79 0.64 36357143
+ 0.29 0.79 0.64 43428571
+ 0.29 0.79 0.64 50500000
+ 0.29 0.79 0.64 57571429
+ 0.29 0.79 0.64 64642857
+ 0.29 0.79 0.64 71714286
+ 0.29 0.79 0.64 78785714
+ 0.29 0.79 0.64 85857143
+ 0.29 0.79 0.64 92928571
+ 0.29 0.79 0.64 100000000
+ 0.29 0.79 0.71 1000000
+ 0.29 0.79 0.71 8071429
+ 0.29 0.79 0.71 15142857
+ 0.29 0.79 0.71 22214286
+ 0.29 0.79 0.71 29285714
+ 0.29 0.79 0.71 36357143
+ 0.29 0.79 0.71 43428571
+ 0.29 0.79 0.71 50500000
+ 0.29 0.79 0.71 57571429
+ 0.29 0.79 0.71 64642857
+ 0.29 0.79 0.71 71714286
+ 0.29 0.79 0.71 78785714
+ 0.29 0.79 0.71 85857143
+ 0.29 0.79 0.71 92928571
+ 0.29 0.79 0.71 100000000
+ 0.29 0.79 0.79 1000000
+ 0.29 0.79 0.79 8071429
+ 0.29 0.79 0.79 15142857
+ 0.29 0.79 0.79 22214286
+ 0.29 0.79 0.79 29285714
+ 0.29 0.79 0.79 36357143
+ 0.29 0.79 0.79 43428571
+ 0.29 0.79 0.79 50500000
+ 0.29 0.79 0.79 57571429
+ 0.29 0.79 0.79 64642857
+ 0.29 0.79 0.79 71714286
+ 0.29 0.79 0.79 78785714
+ 0.29 0.79 0.79 85857143
+ 0.29 0.79 0.79 92928571
+ 0.29 0.79 0.79 100000000
+ 0.29 0.79 0.86 1000000
+ 0.29 0.79 0.86 8071429
+ 0.29 0.79 0.86 15142857
+ 0.29 0.79 0.86 22214286
+ 0.29 0.79 0.86 29285714
+ 0.29 0.79 0.86 36357143
+ 0.29 0.79 0.86 43428571
+ 0.29 0.79 0.86 50500000
+ 0.29 0.79 0.86 57571429
+ 0.29 0.79 0.86 64642857
+ 0.29 0.79 0.86 71714286
+ 0.29 0.79 0.86 78785714
+ 0.29 0.79 0.86 85857143
+ 0.29 0.79 0.86 92928571
+ 0.29 0.79 0.86 100000000
+ 0.29 0.79 0.93 1000000
+ 0.29 0.79 0.93 8071429
+ 0.29 0.79 0.93 15142857
+ 0.29 0.79 0.93 22214286
+ 0.29 0.79 0.93 29285714
+ 0.29 0.79 0.93 36357143
+ 0.29 0.79 0.93 43428571
+ 0.29 0.79 0.93 50500000
+ 0.29 0.79 0.93 57571429
+ 0.29 0.79 0.93 64642857
+ 0.29 0.79 0.93 71714286
+ 0.29 0.79 0.93 78785714
+ 0.29 0.79 0.93 85857143
+ 0.29 0.79 0.93 92928571
+ 0.29 0.79 0.93 100000000
+ 0.29 0.79 1.00 1000000
+ 0.29 0.79 1.00 8071429
+ 0.29 0.79 1.00 15142857
+ 0.29 0.79 1.00 22214286
+ 0.29 0.79 1.00 29285714
+ 0.29 0.79 1.00 36357143
+ 0.29 0.79 1.00 43428571
+ 0.29 0.79 1.00 50500000
+ 0.29 0.79 1.00 57571429
+ 0.29 0.79 1.00 64642857
+ 0.29 0.79 1.00 71714286
+ 0.29 0.79 1.00 78785714
+ 0.29 0.79 1.00 85857143
+ 0.29 0.79 1.00 92928571
+ 0.29 0.79 1.00 100000000
+ 0.29 0.86 0.00 1000000
+ 0.29 0.86 0.00 8071429
+ 0.29 0.86 0.00 15142857
+ 0.29 0.86 0.00 22214286
+ 0.29 0.86 0.00 29285714
+ 0.29 0.86 0.00 36357143
+ 0.29 0.86 0.00 43428571
+ 0.29 0.86 0.00 50500000
+ 0.29 0.86 0.00 57571429
+ 0.29 0.86 0.00 64642857
+ 0.29 0.86 0.00 71714286
+ 0.29 0.86 0.00 78785714
+ 0.29 0.86 0.00 85857143
+ 0.29 0.86 0.00 92928571
+ 0.29 0.86 0.00 100000000
+ 0.29 0.86 0.07 1000000
+ 0.29 0.86 0.07 8071429
+ 0.29 0.86 0.07 15142857
+ 0.29 0.86 0.07 22214286
+ 0.29 0.86 0.07 29285714
+ 0.29 0.86 0.07 36357143
+ 0.29 0.86 0.07 43428571
+ 0.29 0.86 0.07 50500000
+ 0.29 0.86 0.07 57571429
+ 0.29 0.86 0.07 64642857
+ 0.29 0.86 0.07 71714286
+ 0.29 0.86 0.07 78785714
+ 0.29 0.86 0.07 85857143
+ 0.29 0.86 0.07 92928571
+ 0.29 0.86 0.07 100000000
+ 0.29 0.86 0.14 1000000
+ 0.29 0.86 0.14 8071429
+ 0.29 0.86 0.14 15142857
+ 0.29 0.86 0.14 22214286
+ 0.29 0.86 0.14 29285714
+ 0.29 0.86 0.14 36357143
+ 0.29 0.86 0.14 43428571
+ 0.29 0.86 0.14 50500000
+ 0.29 0.86 0.14 57571429
+ 0.29 0.86 0.14 64642857
+ 0.29 0.86 0.14 71714286
+ 0.29 0.86 0.14 78785714
+ 0.29 0.86 0.14 85857143
+ 0.29 0.86 0.14 92928571
+ 0.29 0.86 0.14 100000000
+ 0.29 0.86 0.21 1000000
+ 0.29 0.86 0.21 8071429
+ 0.29 0.86 0.21 15142857
+ 0.29 0.86 0.21 22214286
+ 0.29 0.86 0.21 29285714
+ 0.29 0.86 0.21 36357143
+ 0.29 0.86 0.21 43428571
+ 0.29 0.86 0.21 50500000
+ 0.29 0.86 0.21 57571429
+ 0.29 0.86 0.21 64642857
+ 0.29 0.86 0.21 71714286
+ 0.29 0.86 0.21 78785714
+ 0.29 0.86 0.21 85857143
+ 0.29 0.86 0.21 92928571
+ 0.29 0.86 0.21 100000000
+ 0.29 0.86 0.29 1000000
+ 0.29 0.86 0.29 8071429
+ 0.29 0.86 0.29 15142857
+ 0.29 0.86 0.29 22214286
+ 0.29 0.86 0.29 29285714
+ 0.29 0.86 0.29 36357143
+ 0.29 0.86 0.29 43428571
+ 0.29 0.86 0.29 50500000
+ 0.29 0.86 0.29 57571429
+ 0.29 0.86 0.29 64642857
+ 0.29 0.86 0.29 71714286
+ 0.29 0.86 0.29 78785714
+ 0.29 0.86 0.29 85857143
+ 0.29 0.86 0.29 92928571
+ 0.29 0.86 0.29 100000000
+ 0.29 0.86 0.36 1000000
+ 0.29 0.86 0.36 8071429
+ 0.29 0.86 0.36 15142857
+ 0.29 0.86 0.36 22214286
+ 0.29 0.86 0.36 29285714
+ 0.29 0.86 0.36 36357143
+ 0.29 0.86 0.36 43428571
+ 0.29 0.86 0.36 50500000
+ 0.29 0.86 0.36 57571429
+ 0.29 0.86 0.36 64642857
+ 0.29 0.86 0.36 71714286
+ 0.29 0.86 0.36 78785714
+ 0.29 0.86 0.36 85857143
+ 0.29 0.86 0.36 92928571
+ 0.29 0.86 0.36 100000000
+ 0.29 0.86 0.43 1000000
+ 0.29 0.86 0.43 8071429
+ 0.29 0.86 0.43 15142857
+ 0.29 0.86 0.43 22214286
+ 0.29 0.86 0.43 29285714
+ 0.29 0.86 0.43 36357143
+ 0.29 0.86 0.43 43428571
+ 0.29 0.86 0.43 50500000
+ 0.29 0.86 0.43 57571429
+ 0.29 0.86 0.43 64642857
+ 0.29 0.86 0.43 71714286
+ 0.29 0.86 0.43 78785714
+ 0.29 0.86 0.43 85857143
+ 0.29 0.86 0.43 92928571
+ 0.29 0.86 0.43 100000000
+ 0.29 0.86 0.50 1000000
+ 0.29 0.86 0.50 8071429
+ 0.29 0.86 0.50 15142857
+ 0.29 0.86 0.50 22214286
+ 0.29 0.86 0.50 29285714
+ 0.29 0.86 0.50 36357143
+ 0.29 0.86 0.50 43428571
+ 0.29 0.86 0.50 50500000
+ 0.29 0.86 0.50 57571429
+ 0.29 0.86 0.50 64642857
+ 0.29 0.86 0.50 71714286
+ 0.29 0.86 0.50 78785714
+ 0.29 0.86 0.50 85857143
+ 0.29 0.86 0.50 92928571
+ 0.29 0.86 0.50 100000000
+ 0.29 0.86 0.57 1000000
+ 0.29 0.86 0.57 8071429
+ 0.29 0.86 0.57 15142857
+ 0.29 0.86 0.57 22214286
+ 0.29 0.86 0.57 29285714
+ 0.29 0.86 0.57 36357143
+ 0.29 0.86 0.57 43428571
+ 0.29 0.86 0.57 50500000
+ 0.29 0.86 0.57 57571429
+ 0.29 0.86 0.57 64642857
+ 0.29 0.86 0.57 71714286
+ 0.29 0.86 0.57 78785714
+ 0.29 0.86 0.57 85857143
+ 0.29 0.86 0.57 92928571
+ 0.29 0.86 0.57 100000000
+ 0.29 0.86 0.64 1000000
+ 0.29 0.86 0.64 8071429
+ 0.29 0.86 0.64 15142857
+ 0.29 0.86 0.64 22214286
+ 0.29 0.86 0.64 29285714
+ 0.29 0.86 0.64 36357143
+ 0.29 0.86 0.64 43428571
+ 0.29 0.86 0.64 50500000
+ 0.29 0.86 0.64 57571429
+ 0.29 0.86 0.64 64642857
+ 0.29 0.86 0.64 71714286
+ 0.29 0.86 0.64 78785714
+ 0.29 0.86 0.64 85857143
+ 0.29 0.86 0.64 92928571
+ 0.29 0.86 0.64 100000000
+ 0.29 0.86 0.71 1000000
+ 0.29 0.86 0.71 8071429
+ 0.29 0.86 0.71 15142857
+ 0.29 0.86 0.71 22214286
+ 0.29 0.86 0.71 29285714
+ 0.29 0.86 0.71 36357143
+ 0.29 0.86 0.71 43428571
+ 0.29 0.86 0.71 50500000
+ 0.29 0.86 0.71 57571429
+ 0.29 0.86 0.71 64642857
+ 0.29 0.86 0.71 71714286
+ 0.29 0.86 0.71 78785714
+ 0.29 0.86 0.71 85857143
+ 0.29 0.86 0.71 92928571
+ 0.29 0.86 0.71 100000000
+ 0.29 0.86 0.79 1000000
+ 0.29 0.86 0.79 8071429
+ 0.29 0.86 0.79 15142857
+ 0.29 0.86 0.79 22214286
+ 0.29 0.86 0.79 29285714
+ 0.29 0.86 0.79 36357143
+ 0.29 0.86 0.79 43428571
+ 0.29 0.86 0.79 50500000
+ 0.29 0.86 0.79 57571429
+ 0.29 0.86 0.79 64642857
+ 0.29 0.86 0.79 71714286
+ 0.29 0.86 0.79 78785714
+ 0.29 0.86 0.79 85857143
+ 0.29 0.86 0.79 92928571
+ 0.29 0.86 0.79 100000000
+ 0.29 0.86 0.86 1000000
+ 0.29 0.86 0.86 8071429
+ 0.29 0.86 0.86 15142857
+ 0.29 0.86 0.86 22214286
+ 0.29 0.86 0.86 29285714
+ 0.29 0.86 0.86 36357143
+ 0.29 0.86 0.86 43428571
+ 0.29 0.86 0.86 50500000
+ 0.29 0.86 0.86 57571429
+ 0.29 0.86 0.86 64642857
+ 0.29 0.86 0.86 71714286
+ 0.29 0.86 0.86 78785714
+ 0.29 0.86 0.86 85857143
+ 0.29 0.86 0.86 92928571
+ 0.29 0.86 0.86 100000000
+ 0.29 0.86 0.93 1000000
+ 0.29 0.86 0.93 8071429
+ 0.29 0.86 0.93 15142857
+ 0.29 0.86 0.93 22214286
+ 0.29 0.86 0.93 29285714
+ 0.29 0.86 0.93 36357143
+ 0.29 0.86 0.93 43428571
+ 0.29 0.86 0.93 50500000
+ 0.29 0.86 0.93 57571429
+ 0.29 0.86 0.93 64642857
+ 0.29 0.86 0.93 71714286
+ 0.29 0.86 0.93 78785714
+ 0.29 0.86 0.93 85857143
+ 0.29 0.86 0.93 92928571
+ 0.29 0.86 0.93 100000000
+ 0.29 0.86 1.00 1000000
+ 0.29 0.86 1.00 8071429
+ 0.29 0.86 1.00 15142857
+ 0.29 0.86 1.00 22214286
+ 0.29 0.86 1.00 29285714
+ 0.29 0.86 1.00 36357143
+ 0.29 0.86 1.00 43428571
+ 0.29 0.86 1.00 50500000
+ 0.29 0.86 1.00 57571429
+ 0.29 0.86 1.00 64642857
+ 0.29 0.86 1.00 71714286
+ 0.29 0.86 1.00 78785714
+ 0.29 0.86 1.00 85857143
+ 0.29 0.86 1.00 92928571
+ 0.29 0.86 1.00 100000000
+ 0.29 0.93 0.00 1000000
+ 0.29 0.93 0.00 8071429
+ 0.29 0.93 0.00 15142857
+ 0.29 0.93 0.00 22214286
+ 0.29 0.93 0.00 29285714
+ 0.29 0.93 0.00 36357143
+ 0.29 0.93 0.00 43428571
+ 0.29 0.93 0.00 50500000
+ 0.29 0.93 0.00 57571429
+ 0.29 0.93 0.00 64642857
+ 0.29 0.93 0.00 71714286
+ 0.29 0.93 0.00 78785714
+ 0.29 0.93 0.00 85857143
+ 0.29 0.93 0.00 92928571
+ 0.29 0.93 0.00 100000000
+ 0.29 0.93 0.07 1000000
+ 0.29 0.93 0.07 8071429
+ 0.29 0.93 0.07 15142857
+ 0.29 0.93 0.07 22214286
+ 0.29 0.93 0.07 29285714
+ 0.29 0.93 0.07 36357143
+ 0.29 0.93 0.07 43428571
+ 0.29 0.93 0.07 50500000
+ 0.29 0.93 0.07 57571429
+ 0.29 0.93 0.07 64642857
+ 0.29 0.93 0.07 71714286
+ 0.29 0.93 0.07 78785714
+ 0.29 0.93 0.07 85857143
+ 0.29 0.93 0.07 92928571
+ 0.29 0.93 0.07 100000000
+ 0.29 0.93 0.14 1000000
+ 0.29 0.93 0.14 8071429
+ 0.29 0.93 0.14 15142857
+ 0.29 0.93 0.14 22214286
+ 0.29 0.93 0.14 29285714
+ 0.29 0.93 0.14 36357143
+ 0.29 0.93 0.14 43428571
+ 0.29 0.93 0.14 50500000
+ 0.29 0.93 0.14 57571429
+ 0.29 0.93 0.14 64642857
+ 0.29 0.93 0.14 71714286
+ 0.29 0.93 0.14 78785714
+ 0.29 0.93 0.14 85857143
+ 0.29 0.93 0.14 92928571
+ 0.29 0.93 0.14 100000000
+ 0.29 0.93 0.21 1000000
+ 0.29 0.93 0.21 8071429
+ 0.29 0.93 0.21 15142857
+ 0.29 0.93 0.21 22214286
+ 0.29 0.93 0.21 29285714
+ 0.29 0.93 0.21 36357143
+ 0.29 0.93 0.21 43428571
+ 0.29 0.93 0.21 50500000
+ 0.29 0.93 0.21 57571429
+ 0.29 0.93 0.21 64642857
+ 0.29 0.93 0.21 71714286
+ 0.29 0.93 0.21 78785714
+ 0.29 0.93 0.21 85857143
+ 0.29 0.93 0.21 92928571
+ 0.29 0.93 0.21 100000000
+ 0.29 0.93 0.29 1000000
+ 0.29 0.93 0.29 8071429
+ 0.29 0.93 0.29 15142857
+ 0.29 0.93 0.29 22214286
+ 0.29 0.93 0.29 29285714
+ 0.29 0.93 0.29 36357143
+ 0.29 0.93 0.29 43428571
+ 0.29 0.93 0.29 50500000
+ 0.29 0.93 0.29 57571429
+ 0.29 0.93 0.29 64642857
+ 0.29 0.93 0.29 71714286
+ 0.29 0.93 0.29 78785714
+ 0.29 0.93 0.29 85857143
+ 0.29 0.93 0.29 92928571
+ 0.29 0.93 0.29 100000000
+ 0.29 0.93 0.36 1000000
+ 0.29 0.93 0.36 8071429
+ 0.29 0.93 0.36 15142857
+ 0.29 0.93 0.36 22214286
+ 0.29 0.93 0.36 29285714
+ 0.29 0.93 0.36 36357143
+ 0.29 0.93 0.36 43428571
+ 0.29 0.93 0.36 50500000
+ 0.29 0.93 0.36 57571429
+ 0.29 0.93 0.36 64642857
+ 0.29 0.93 0.36 71714286
+ 0.29 0.93 0.36 78785714
+ 0.29 0.93 0.36 85857143
+ 0.29 0.93 0.36 92928571
+ 0.29 0.93 0.36 100000000
+ 0.29 0.93 0.43 1000000
+ 0.29 0.93 0.43 8071429
+ 0.29 0.93 0.43 15142857
+ 0.29 0.93 0.43 22214286
+ 0.29 0.93 0.43 29285714
+ 0.29 0.93 0.43 36357143
+ 0.29 0.93 0.43 43428571
+ 0.29 0.93 0.43 50500000
+ 0.29 0.93 0.43 57571429
+ 0.29 0.93 0.43 64642857
+ 0.29 0.93 0.43 71714286
+ 0.29 0.93 0.43 78785714
+ 0.29 0.93 0.43 85857143
+ 0.29 0.93 0.43 92928571
+ 0.29 0.93 0.43 100000000
+ 0.29 0.93 0.50 1000000
+ 0.29 0.93 0.50 8071429
+ 0.29 0.93 0.50 15142857
+ 0.29 0.93 0.50 22214286
+ 0.29 0.93 0.50 29285714
+ 0.29 0.93 0.50 36357143
+ 0.29 0.93 0.50 43428571
+ 0.29 0.93 0.50 50500000
+ 0.29 0.93 0.50 57571429
+ 0.29 0.93 0.50 64642857
+ 0.29 0.93 0.50 71714286
+ 0.29 0.93 0.50 78785714
+ 0.29 0.93 0.50 85857143
+ 0.29 0.93 0.50 92928571
+ 0.29 0.93 0.50 100000000
+ 0.29 0.93 0.57 1000000
+ 0.29 0.93 0.57 8071429
+ 0.29 0.93 0.57 15142857
+ 0.29 0.93 0.57 22214286
+ 0.29 0.93 0.57 29285714
+ 0.29 0.93 0.57 36357143
+ 0.29 0.93 0.57 43428571
+ 0.29 0.93 0.57 50500000
+ 0.29 0.93 0.57 57571429
+ 0.29 0.93 0.57 64642857
+ 0.29 0.93 0.57 71714286
+ 0.29 0.93 0.57 78785714
+ 0.29 0.93 0.57 85857143
+ 0.29 0.93 0.57 92928571
+ 0.29 0.93 0.57 100000000
+ 0.29 0.93 0.64 1000000
+ 0.29 0.93 0.64 8071429
+ 0.29 0.93 0.64 15142857
+ 0.29 0.93 0.64 22214286
+ 0.29 0.93 0.64 29285714
+ 0.29 0.93 0.64 36357143
+ 0.29 0.93 0.64 43428571
+ 0.29 0.93 0.64 50500000
+ 0.29 0.93 0.64 57571429
+ 0.29 0.93 0.64 64642857
+ 0.29 0.93 0.64 71714286
+ 0.29 0.93 0.64 78785714
+ 0.29 0.93 0.64 85857143
+ 0.29 0.93 0.64 92928571
+ 0.29 0.93 0.64 100000000
+ 0.29 0.93 0.71 1000000
+ 0.29 0.93 0.71 8071429
+ 0.29 0.93 0.71 15142857
+ 0.29 0.93 0.71 22214286
+ 0.29 0.93 0.71 29285714
+ 0.29 0.93 0.71 36357143
+ 0.29 0.93 0.71 43428571
+ 0.29 0.93 0.71 50500000
+ 0.29 0.93 0.71 57571429
+ 0.29 0.93 0.71 64642857
+ 0.29 0.93 0.71 71714286
+ 0.29 0.93 0.71 78785714
+ 0.29 0.93 0.71 85857143
+ 0.29 0.93 0.71 92928571
+ 0.29 0.93 0.71 100000000
+ 0.29 0.93 0.79 1000000
+ 0.29 0.93 0.79 8071429
+ 0.29 0.93 0.79 15142857
+ 0.29 0.93 0.79 22214286
+ 0.29 0.93 0.79 29285714
+ 0.29 0.93 0.79 36357143
+ 0.29 0.93 0.79 43428571
+ 0.29 0.93 0.79 50500000
+ 0.29 0.93 0.79 57571429
+ 0.29 0.93 0.79 64642857
+ 0.29 0.93 0.79 71714286
+ 0.29 0.93 0.79 78785714
+ 0.29 0.93 0.79 85857143
+ 0.29 0.93 0.79 92928571
+ 0.29 0.93 0.79 100000000
+ 0.29 0.93 0.86 1000000
+ 0.29 0.93 0.86 8071429
+ 0.29 0.93 0.86 15142857
+ 0.29 0.93 0.86 22214286
+ 0.29 0.93 0.86 29285714
+ 0.29 0.93 0.86 36357143
+ 0.29 0.93 0.86 43428571
+ 0.29 0.93 0.86 50500000
+ 0.29 0.93 0.86 57571429
+ 0.29 0.93 0.86 64642857
+ 0.29 0.93 0.86 71714286
+ 0.29 0.93 0.86 78785714
+ 0.29 0.93 0.86 85857143
+ 0.29 0.93 0.86 92928571
+ 0.29 0.93 0.86 100000000
+ 0.29 0.93 0.93 1000000
+ 0.29 0.93 0.93 8071429
+ 0.29 0.93 0.93 15142857
+ 0.29 0.93 0.93 22214286
+ 0.29 0.93 0.93 29285714
+ 0.29 0.93 0.93 36357143
+ 0.29 0.93 0.93 43428571
+ 0.29 0.93 0.93 50500000
+ 0.29 0.93 0.93 57571429
+ 0.29 0.93 0.93 64642857
+ 0.29 0.93 0.93 71714286
+ 0.29 0.93 0.93 78785714
+ 0.29 0.93 0.93 85857143
+ 0.29 0.93 0.93 92928571
+ 0.29 0.93 0.93 100000000
+ 0.29 0.93 1.00 1000000
+ 0.29 0.93 1.00 8071429
+ 0.29 0.93 1.00 15142857
+ 0.29 0.93 1.00 22214286
+ 0.29 0.93 1.00 29285714
+ 0.29 0.93 1.00 36357143
+ 0.29 0.93 1.00 43428571
+ 0.29 0.93 1.00 50500000
+ 0.29 0.93 1.00 57571429
+ 0.29 0.93 1.00 64642857
+ 0.29 0.93 1.00 71714286
+ 0.29 0.93 1.00 78785714
+ 0.29 0.93 1.00 85857143
+ 0.29 0.93 1.00 92928571
+ 0.29 0.93 1.00 100000000
+ 0.29 1.00 0.00 1000000
+ 0.29 1.00 0.00 8071429
+ 0.29 1.00 0.00 15142857
+ 0.29 1.00 0.00 22214286
+ 0.29 1.00 0.00 29285714
+ 0.29 1.00 0.00 36357143
+ 0.29 1.00 0.00 43428571
+ 0.29 1.00 0.00 50500000
+ 0.29 1.00 0.00 57571429
+ 0.29 1.00 0.00 64642857
+ 0.29 1.00 0.00 71714286
+ 0.29 1.00 0.00 78785714
+ 0.29 1.00 0.00 85857143
+ 0.29 1.00 0.00 92928571
+ 0.29 1.00 0.00 100000000
+ 0.29 1.00 0.07 1000000
+ 0.29 1.00 0.07 8071429
+ 0.29 1.00 0.07 15142857
+ 0.29 1.00 0.07 22214286
+ 0.29 1.00 0.07 29285714
+ 0.29 1.00 0.07 36357143
+ 0.29 1.00 0.07 43428571
+ 0.29 1.00 0.07 50500000
+ 0.29 1.00 0.07 57571429
+ 0.29 1.00 0.07 64642857
+ 0.29 1.00 0.07 71714286
+ 0.29 1.00 0.07 78785714
+ 0.29 1.00 0.07 85857143
+ 0.29 1.00 0.07 92928571
+ 0.29 1.00 0.07 100000000
+ 0.29 1.00 0.14 1000000
+ 0.29 1.00 0.14 8071429
+ 0.29 1.00 0.14 15142857
+ 0.29 1.00 0.14 22214286
+ 0.29 1.00 0.14 29285714
+ 0.29 1.00 0.14 36357143
+ 0.29 1.00 0.14 43428571
+ 0.29 1.00 0.14 50500000
+ 0.29 1.00 0.14 57571429
+ 0.29 1.00 0.14 64642857
+ 0.29 1.00 0.14 71714286
+ 0.29 1.00 0.14 78785714
+ 0.29 1.00 0.14 85857143
+ 0.29 1.00 0.14 92928571
+ 0.29 1.00 0.14 100000000
+ 0.29 1.00 0.21 1000000
+ 0.29 1.00 0.21 8071429
+ 0.29 1.00 0.21 15142857
+ 0.29 1.00 0.21 22214286
+ 0.29 1.00 0.21 29285714
+ 0.29 1.00 0.21 36357143
+ 0.29 1.00 0.21 43428571
+ 0.29 1.00 0.21 50500000
+ 0.29 1.00 0.21 57571429
+ 0.29 1.00 0.21 64642857
+ 0.29 1.00 0.21 71714286
+ 0.29 1.00 0.21 78785714
+ 0.29 1.00 0.21 85857143
+ 0.29 1.00 0.21 92928571
+ 0.29 1.00 0.21 100000000
+ 0.29 1.00 0.29 1000000
+ 0.29 1.00 0.29 8071429
+ 0.29 1.00 0.29 15142857
+ 0.29 1.00 0.29 22214286
+ 0.29 1.00 0.29 29285714
+ 0.29 1.00 0.29 36357143
+ 0.29 1.00 0.29 43428571
+ 0.29 1.00 0.29 50500000
+ 0.29 1.00 0.29 57571429
+ 0.29 1.00 0.29 64642857
+ 0.29 1.00 0.29 71714286
+ 0.29 1.00 0.29 78785714
+ 0.29 1.00 0.29 85857143
+ 0.29 1.00 0.29 92928571
+ 0.29 1.00 0.29 100000000
+ 0.29 1.00 0.36 1000000
+ 0.29 1.00 0.36 8071429
+ 0.29 1.00 0.36 15142857
+ 0.29 1.00 0.36 22214286
+ 0.29 1.00 0.36 29285714
+ 0.29 1.00 0.36 36357143
+ 0.29 1.00 0.36 43428571
+ 0.29 1.00 0.36 50500000
+ 0.29 1.00 0.36 57571429
+ 0.29 1.00 0.36 64642857
+ 0.29 1.00 0.36 71714286
+ 0.29 1.00 0.36 78785714
+ 0.29 1.00 0.36 85857143
+ 0.29 1.00 0.36 92928571
+ 0.29 1.00 0.36 100000000
+ 0.29 1.00 0.43 1000000
+ 0.29 1.00 0.43 8071429
+ 0.29 1.00 0.43 15142857
+ 0.29 1.00 0.43 22214286
+ 0.29 1.00 0.43 29285714
+ 0.29 1.00 0.43 36357143
+ 0.29 1.00 0.43 43428571
+ 0.29 1.00 0.43 50500000
+ 0.29 1.00 0.43 57571429
+ 0.29 1.00 0.43 64642857
+ 0.29 1.00 0.43 71714286
+ 0.29 1.00 0.43 78785714
+ 0.29 1.00 0.43 85857143
+ 0.29 1.00 0.43 92928571
+ 0.29 1.00 0.43 100000000
+ 0.29 1.00 0.50 1000000
+ 0.29 1.00 0.50 8071429
+ 0.29 1.00 0.50 15142857
+ 0.29 1.00 0.50 22214286
+ 0.29 1.00 0.50 29285714
+ 0.29 1.00 0.50 36357143
+ 0.29 1.00 0.50 43428571
+ 0.29 1.00 0.50 50500000
+ 0.29 1.00 0.50 57571429
+ 0.29 1.00 0.50 64642857
+ 0.29 1.00 0.50 71714286
+ 0.29 1.00 0.50 78785714
+ 0.29 1.00 0.50 85857143
+ 0.29 1.00 0.50 92928571
+ 0.29 1.00 0.50 100000000
+ 0.29 1.00 0.57 1000000
+ 0.29 1.00 0.57 8071429
+ 0.29 1.00 0.57 15142857
+ 0.29 1.00 0.57 22214286
+ 0.29 1.00 0.57 29285714
+ 0.29 1.00 0.57 36357143
+ 0.29 1.00 0.57 43428571
+ 0.29 1.00 0.57 50500000
+ 0.29 1.00 0.57 57571429
+ 0.29 1.00 0.57 64642857
+ 0.29 1.00 0.57 71714286
+ 0.29 1.00 0.57 78785714
+ 0.29 1.00 0.57 85857143
+ 0.29 1.00 0.57 92928571
+ 0.29 1.00 0.57 100000000
+ 0.29 1.00 0.64 1000000
+ 0.29 1.00 0.64 8071429
+ 0.29 1.00 0.64 15142857
+ 0.29 1.00 0.64 22214286
+ 0.29 1.00 0.64 29285714
+ 0.29 1.00 0.64 36357143
+ 0.29 1.00 0.64 43428571
+ 0.29 1.00 0.64 50500000
+ 0.29 1.00 0.64 57571429
+ 0.29 1.00 0.64 64642857
+ 0.29 1.00 0.64 71714286
+ 0.29 1.00 0.64 78785714
+ 0.29 1.00 0.64 85857143
+ 0.29 1.00 0.64 92928571
+ 0.29 1.00 0.64 100000000
+ 0.29 1.00 0.71 1000000
+ 0.29 1.00 0.71 8071429
+ 0.29 1.00 0.71 15142857
+ 0.29 1.00 0.71 22214286
+ 0.29 1.00 0.71 29285714
+ 0.29 1.00 0.71 36357143
+ 0.29 1.00 0.71 43428571
+ 0.29 1.00 0.71 50500000
+ 0.29 1.00 0.71 57571429
+ 0.29 1.00 0.71 64642857
+ 0.29 1.00 0.71 71714286
+ 0.29 1.00 0.71 78785714
+ 0.29 1.00 0.71 85857143
+ 0.29 1.00 0.71 92928571
+ 0.29 1.00 0.71 100000000
+ 0.29 1.00 0.79 1000000
+ 0.29 1.00 0.79 8071429
+ 0.29 1.00 0.79 15142857
+ 0.29 1.00 0.79 22214286
+ 0.29 1.00 0.79 29285714
+ 0.29 1.00 0.79 36357143
+ 0.29 1.00 0.79 43428571
+ 0.29 1.00 0.79 50500000
+ 0.29 1.00 0.79 57571429
+ 0.29 1.00 0.79 64642857
+ 0.29 1.00 0.79 71714286
+ 0.29 1.00 0.79 78785714
+ 0.29 1.00 0.79 85857143
+ 0.29 1.00 0.79 92928571
+ 0.29 1.00 0.79 100000000
+ 0.29 1.00 0.86 1000000
+ 0.29 1.00 0.86 8071429
+ 0.29 1.00 0.86 15142857
+ 0.29 1.00 0.86 22214286
+ 0.29 1.00 0.86 29285714
+ 0.29 1.00 0.86 36357143
+ 0.29 1.00 0.86 43428571
+ 0.29 1.00 0.86 50500000
+ 0.29 1.00 0.86 57571429
+ 0.29 1.00 0.86 64642857
+ 0.29 1.00 0.86 71714286
+ 0.29 1.00 0.86 78785714
+ 0.29 1.00 0.86 85857143
+ 0.29 1.00 0.86 92928571
+ 0.29 1.00 0.86 100000000
+ 0.29 1.00 0.93 1000000
+ 0.29 1.00 0.93 8071429
+ 0.29 1.00 0.93 15142857
+ 0.29 1.00 0.93 22214286
+ 0.29 1.00 0.93 29285714
+ 0.29 1.00 0.93 36357143
+ 0.29 1.00 0.93 43428571
+ 0.29 1.00 0.93 50500000
+ 0.29 1.00 0.93 57571429
+ 0.29 1.00 0.93 64642857
+ 0.29 1.00 0.93 71714286
+ 0.29 1.00 0.93 78785714
+ 0.29 1.00 0.93 85857143
+ 0.29 1.00 0.93 92928571
+ 0.29 1.00 0.93 100000000
+ 0.29 1.00 1.00 1000000
+ 0.29 1.00 1.00 8071429
+ 0.29 1.00 1.00 15142857
+ 0.29 1.00 1.00 22214286
+ 0.29 1.00 1.00 29285714
+ 0.29 1.00 1.00 36357143
+ 0.29 1.00 1.00 43428571
+ 0.29 1.00 1.00 50500000
+ 0.29 1.00 1.00 57571429
+ 0.29 1.00 1.00 64642857
+ 0.29 1.00 1.00 71714286
+ 0.29 1.00 1.00 78785714
+ 0.29 1.00 1.00 85857143
+ 0.29 1.00 1.00 92928571
+ 0.29 1.00 1.00 100000000
+ 0.36 0.00 0.00 1000000
+ 0.36 0.00 0.00 8071429
+ 0.36 0.00 0.00 15142857
+ 0.36 0.00 0.00 22214286
+ 0.36 0.00 0.00 29285714
+ 0.36 0.00 0.00 36357143
+ 0.36 0.00 0.00 43428571
+ 0.36 0.00 0.00 50500000
+ 0.36 0.00 0.00 57571429
+ 0.36 0.00 0.00 64642857
+ 0.36 0.00 0.00 71714286
+ 0.36 0.00 0.00 78785714
+ 0.36 0.00 0.00 85857143
+ 0.36 0.00 0.00 92928571
+ 0.36 0.00 0.00 100000000
+ 0.36 0.00 0.07 1000000
+ 0.36 0.00 0.07 8071429
+ 0.36 0.00 0.07 15142857
+ 0.36 0.00 0.07 22214286
+ 0.36 0.00 0.07 29285714
+ 0.36 0.00 0.07 36357143
+ 0.36 0.00 0.07 43428571
+ 0.36 0.00 0.07 50500000
+ 0.36 0.00 0.07 57571429
+ 0.36 0.00 0.07 64642857
+ 0.36 0.00 0.07 71714286
+ 0.36 0.00 0.07 78785714
+ 0.36 0.00 0.07 85857143
+ 0.36 0.00 0.07 92928571
+ 0.36 0.00 0.07 100000000
+ 0.36 0.00 0.14 1000000
+ 0.36 0.00 0.14 8071429
+ 0.36 0.00 0.14 15142857
+ 0.36 0.00 0.14 22214286
+ 0.36 0.00 0.14 29285714
+ 0.36 0.00 0.14 36357143
+ 0.36 0.00 0.14 43428571
+ 0.36 0.00 0.14 50500000
+ 0.36 0.00 0.14 57571429
+ 0.36 0.00 0.14 64642857
+ 0.36 0.00 0.14 71714286
+ 0.36 0.00 0.14 78785714
+ 0.36 0.00 0.14 85857143
+ 0.36 0.00 0.14 92928571
+ 0.36 0.00 0.14 100000000
+ 0.36 0.00 0.21 1000000
+ 0.36 0.00 0.21 8071429
+ 0.36 0.00 0.21 15142857
+ 0.36 0.00 0.21 22214286
+ 0.36 0.00 0.21 29285714
+ 0.36 0.00 0.21 36357143
+ 0.36 0.00 0.21 43428571
+ 0.36 0.00 0.21 50500000
+ 0.36 0.00 0.21 57571429
+ 0.36 0.00 0.21 64642857
+ 0.36 0.00 0.21 71714286
+ 0.36 0.00 0.21 78785714
+ 0.36 0.00 0.21 85857143
+ 0.36 0.00 0.21 92928571
+ 0.36 0.00 0.21 100000000
+ 0.36 0.00 0.29 1000000
+ 0.36 0.00 0.29 8071429
+ 0.36 0.00 0.29 15142857
+ 0.36 0.00 0.29 22214286
+ 0.36 0.00 0.29 29285714
+ 0.36 0.00 0.29 36357143
+ 0.36 0.00 0.29 43428571
+ 0.36 0.00 0.29 50500000
+ 0.36 0.00 0.29 57571429
+ 0.36 0.00 0.29 64642857
+ 0.36 0.00 0.29 71714286
+ 0.36 0.00 0.29 78785714
+ 0.36 0.00 0.29 85857143
+ 0.36 0.00 0.29 92928571
+ 0.36 0.00 0.29 100000000
+ 0.36 0.00 0.36 1000000
+ 0.36 0.00 0.36 8071429
+ 0.36 0.00 0.36 15142857
+ 0.36 0.00 0.36 22214286
+ 0.36 0.00 0.36 29285714
+ 0.36 0.00 0.36 36357143
+ 0.36 0.00 0.36 43428571
+ 0.36 0.00 0.36 50500000
+ 0.36 0.00 0.36 57571429
+ 0.36 0.00 0.36 64642857
+ 0.36 0.00 0.36 71714286
+ 0.36 0.00 0.36 78785714
+ 0.36 0.00 0.36 85857143
+ 0.36 0.00 0.36 92928571
+ 0.36 0.00 0.36 100000000
+ 0.36 0.00 0.43 1000000
+ 0.36 0.00 0.43 8071429
+ 0.36 0.00 0.43 15142857
+ 0.36 0.00 0.43 22214286
+ 0.36 0.00 0.43 29285714
+ 0.36 0.00 0.43 36357143
+ 0.36 0.00 0.43 43428571
+ 0.36 0.00 0.43 50500000
+ 0.36 0.00 0.43 57571429
+ 0.36 0.00 0.43 64642857
+ 0.36 0.00 0.43 71714286
+ 0.36 0.00 0.43 78785714
+ 0.36 0.00 0.43 85857143
+ 0.36 0.00 0.43 92928571
+ 0.36 0.00 0.43 100000000
+ 0.36 0.00 0.50 1000000
+ 0.36 0.00 0.50 8071429
+ 0.36 0.00 0.50 15142857
+ 0.36 0.00 0.50 22214286
+ 0.36 0.00 0.50 29285714
+ 0.36 0.00 0.50 36357143
+ 0.36 0.00 0.50 43428571
+ 0.36 0.00 0.50 50500000
+ 0.36 0.00 0.50 57571429
+ 0.36 0.00 0.50 64642857
+ 0.36 0.00 0.50 71714286
+ 0.36 0.00 0.50 78785714
+ 0.36 0.00 0.50 85857143
+ 0.36 0.00 0.50 92928571
+ 0.36 0.00 0.50 100000000
+ 0.36 0.00 0.57 1000000
+ 0.36 0.00 0.57 8071429
+ 0.36 0.00 0.57 15142857
+ 0.36 0.00 0.57 22214286
+ 0.36 0.00 0.57 29285714
+ 0.36 0.00 0.57 36357143
+ 0.36 0.00 0.57 43428571
+ 0.36 0.00 0.57 50500000
+ 0.36 0.00 0.57 57571429
+ 0.36 0.00 0.57 64642857
+ 0.36 0.00 0.57 71714286
+ 0.36 0.00 0.57 78785714
+ 0.36 0.00 0.57 85857143
+ 0.36 0.00 0.57 92928571
+ 0.36 0.00 0.57 100000000
+ 0.36 0.00 0.64 1000000
+ 0.36 0.00 0.64 8071429
+ 0.36 0.00 0.64 15142857
+ 0.36 0.00 0.64 22214286
+ 0.36 0.00 0.64 29285714
+ 0.36 0.00 0.64 36357143
+ 0.36 0.00 0.64 43428571
+ 0.36 0.00 0.64 50500000
+ 0.36 0.00 0.64 57571429
+ 0.36 0.00 0.64 64642857
+ 0.36 0.00 0.64 71714286
+ 0.36 0.00 0.64 78785714
+ 0.36 0.00 0.64 85857143
+ 0.36 0.00 0.64 92928571
+ 0.36 0.00 0.64 100000000
+ 0.36 0.00 0.71 1000000
+ 0.36 0.00 0.71 8071429
+ 0.36 0.00 0.71 15142857
+ 0.36 0.00 0.71 22214286
+ 0.36 0.00 0.71 29285714
+ 0.36 0.00 0.71 36357143
+ 0.36 0.00 0.71 43428571
+ 0.36 0.00 0.71 50500000
+ 0.36 0.00 0.71 57571429
+ 0.36 0.00 0.71 64642857
+ 0.36 0.00 0.71 71714286
+ 0.36 0.00 0.71 78785714
+ 0.36 0.00 0.71 85857143
+ 0.36 0.00 0.71 92928571
+ 0.36 0.00 0.71 100000000
+ 0.36 0.00 0.79 1000000
+ 0.36 0.00 0.79 8071429
+ 0.36 0.00 0.79 15142857
+ 0.36 0.00 0.79 22214286
+ 0.36 0.00 0.79 29285714
+ 0.36 0.00 0.79 36357143
+ 0.36 0.00 0.79 43428571
+ 0.36 0.00 0.79 50500000
+ 0.36 0.00 0.79 57571429
+ 0.36 0.00 0.79 64642857
+ 0.36 0.00 0.79 71714286
+ 0.36 0.00 0.79 78785714
+ 0.36 0.00 0.79 85857143
+ 0.36 0.00 0.79 92928571
+ 0.36 0.00 0.79 100000000
+ 0.36 0.00 0.86 1000000
+ 0.36 0.00 0.86 8071429
+ 0.36 0.00 0.86 15142857
+ 0.36 0.00 0.86 22214286
+ 0.36 0.00 0.86 29285714
+ 0.36 0.00 0.86 36357143
+ 0.36 0.00 0.86 43428571
+ 0.36 0.00 0.86 50500000
+ 0.36 0.00 0.86 57571429
+ 0.36 0.00 0.86 64642857
+ 0.36 0.00 0.86 71714286
+ 0.36 0.00 0.86 78785714
+ 0.36 0.00 0.86 85857143
+ 0.36 0.00 0.86 92928571
+ 0.36 0.00 0.86 100000000
+ 0.36 0.00 0.93 1000000
+ 0.36 0.00 0.93 8071429
+ 0.36 0.00 0.93 15142857
+ 0.36 0.00 0.93 22214286
+ 0.36 0.00 0.93 29285714
+ 0.36 0.00 0.93 36357143
+ 0.36 0.00 0.93 43428571
+ 0.36 0.00 0.93 50500000
+ 0.36 0.00 0.93 57571429
+ 0.36 0.00 0.93 64642857
+ 0.36 0.00 0.93 71714286
+ 0.36 0.00 0.93 78785714
+ 0.36 0.00 0.93 85857143
+ 0.36 0.00 0.93 92928571
+ 0.36 0.00 0.93 100000000
+ 0.36 0.00 1.00 1000000
+ 0.36 0.00 1.00 8071429
+ 0.36 0.00 1.00 15142857
+ 0.36 0.00 1.00 22214286
+ 0.36 0.00 1.00 29285714
+ 0.36 0.00 1.00 36357143
+ 0.36 0.00 1.00 43428571
+ 0.36 0.00 1.00 50500000
+ 0.36 0.00 1.00 57571429
+ 0.36 0.00 1.00 64642857
+ 0.36 0.00 1.00 71714286
+ 0.36 0.00 1.00 78785714
+ 0.36 0.00 1.00 85857143
+ 0.36 0.00 1.00 92928571
+ 0.36 0.00 1.00 100000000
+ 0.36 0.07 0.00 1000000
+ 0.36 0.07 0.00 8071429
+ 0.36 0.07 0.00 15142857
+ 0.36 0.07 0.00 22214286
+ 0.36 0.07 0.00 29285714
+ 0.36 0.07 0.00 36357143
+ 0.36 0.07 0.00 43428571
+ 0.36 0.07 0.00 50500000
+ 0.36 0.07 0.00 57571429
+ 0.36 0.07 0.00 64642857
+ 0.36 0.07 0.00 71714286
+ 0.36 0.07 0.00 78785714
+ 0.36 0.07 0.00 85857143
+ 0.36 0.07 0.00 92928571
+ 0.36 0.07 0.00 100000000
+ 0.36 0.07 0.07 1000000
+ 0.36 0.07 0.07 8071429
+ 0.36 0.07 0.07 15142857
+ 0.36 0.07 0.07 22214286
+ 0.36 0.07 0.07 29285714
+ 0.36 0.07 0.07 36357143
+ 0.36 0.07 0.07 43428571
+ 0.36 0.07 0.07 50500000
+ 0.36 0.07 0.07 57571429
+ 0.36 0.07 0.07 64642857
+ 0.36 0.07 0.07 71714286
+ 0.36 0.07 0.07 78785714
+ 0.36 0.07 0.07 85857143
+ 0.36 0.07 0.07 92928571
+ 0.36 0.07 0.07 100000000
+ 0.36 0.07 0.14 1000000
+ 0.36 0.07 0.14 8071429
+ 0.36 0.07 0.14 15142857
+ 0.36 0.07 0.14 22214286
+ 0.36 0.07 0.14 29285714
+ 0.36 0.07 0.14 36357143
+ 0.36 0.07 0.14 43428571
+ 0.36 0.07 0.14 50500000
+ 0.36 0.07 0.14 57571429
+ 0.36 0.07 0.14 64642857
+ 0.36 0.07 0.14 71714286
+ 0.36 0.07 0.14 78785714
+ 0.36 0.07 0.14 85857143
+ 0.36 0.07 0.14 92928571
+ 0.36 0.07 0.14 100000000
+ 0.36 0.07 0.21 1000000
+ 0.36 0.07 0.21 8071429
+ 0.36 0.07 0.21 15142857
+ 0.36 0.07 0.21 22214286
+ 0.36 0.07 0.21 29285714
+ 0.36 0.07 0.21 36357143
+ 0.36 0.07 0.21 43428571
+ 0.36 0.07 0.21 50500000
+ 0.36 0.07 0.21 57571429
+ 0.36 0.07 0.21 64642857
+ 0.36 0.07 0.21 71714286
+ 0.36 0.07 0.21 78785714
+ 0.36 0.07 0.21 85857143
+ 0.36 0.07 0.21 92928571
+ 0.36 0.07 0.21 100000000
+ 0.36 0.07 0.29 1000000
+ 0.36 0.07 0.29 8071429
+ 0.36 0.07 0.29 15142857
+ 0.36 0.07 0.29 22214286
+ 0.36 0.07 0.29 29285714
+ 0.36 0.07 0.29 36357143
+ 0.36 0.07 0.29 43428571
+ 0.36 0.07 0.29 50500000
+ 0.36 0.07 0.29 57571429
+ 0.36 0.07 0.29 64642857
+ 0.36 0.07 0.29 71714286
+ 0.36 0.07 0.29 78785714
+ 0.36 0.07 0.29 85857143
+ 0.36 0.07 0.29 92928571
+ 0.36 0.07 0.29 100000000
+ 0.36 0.07 0.36 1000000
+ 0.36 0.07 0.36 8071429
+ 0.36 0.07 0.36 15142857
+ 0.36 0.07 0.36 22214286
+ 0.36 0.07 0.36 29285714
+ 0.36 0.07 0.36 36357143
+ 0.36 0.07 0.36 43428571
+ 0.36 0.07 0.36 50500000
+ 0.36 0.07 0.36 57571429
+ 0.36 0.07 0.36 64642857
+ 0.36 0.07 0.36 71714286
+ 0.36 0.07 0.36 78785714
+ 0.36 0.07 0.36 85857143
+ 0.36 0.07 0.36 92928571
+ 0.36 0.07 0.36 100000000
+ 0.36 0.07 0.43 1000000
+ 0.36 0.07 0.43 8071429
+ 0.36 0.07 0.43 15142857
+ 0.36 0.07 0.43 22214286
+ 0.36 0.07 0.43 29285714
+ 0.36 0.07 0.43 36357143
+ 0.36 0.07 0.43 43428571
+ 0.36 0.07 0.43 50500000
+ 0.36 0.07 0.43 57571429
+ 0.36 0.07 0.43 64642857
+ 0.36 0.07 0.43 71714286
+ 0.36 0.07 0.43 78785714
+ 0.36 0.07 0.43 85857143
+ 0.36 0.07 0.43 92928571
+ 0.36 0.07 0.43 100000000
+ 0.36 0.07 0.50 1000000
+ 0.36 0.07 0.50 8071429
+ 0.36 0.07 0.50 15142857
+ 0.36 0.07 0.50 22214286
+ 0.36 0.07 0.50 29285714
+ 0.36 0.07 0.50 36357143
+ 0.36 0.07 0.50 43428571
+ 0.36 0.07 0.50 50500000
+ 0.36 0.07 0.50 57571429
+ 0.36 0.07 0.50 64642857
+ 0.36 0.07 0.50 71714286
+ 0.36 0.07 0.50 78785714
+ 0.36 0.07 0.50 85857143
+ 0.36 0.07 0.50 92928571
+ 0.36 0.07 0.50 100000000
+ 0.36 0.07 0.57 1000000
+ 0.36 0.07 0.57 8071429
+ 0.36 0.07 0.57 15142857
+ 0.36 0.07 0.57 22214286
+ 0.36 0.07 0.57 29285714
+ 0.36 0.07 0.57 36357143
+ 0.36 0.07 0.57 43428571
+ 0.36 0.07 0.57 50500000
+ 0.36 0.07 0.57 57571429
+ 0.36 0.07 0.57 64642857
+ 0.36 0.07 0.57 71714286
+ 0.36 0.07 0.57 78785714
+ 0.36 0.07 0.57 85857143
+ 0.36 0.07 0.57 92928571
+ 0.36 0.07 0.57 100000000
+ 0.36 0.07 0.64 1000000
+ 0.36 0.07 0.64 8071429
+ 0.36 0.07 0.64 15142857
+ 0.36 0.07 0.64 22214286
+ 0.36 0.07 0.64 29285714
+ 0.36 0.07 0.64 36357143
+ 0.36 0.07 0.64 43428571
+ 0.36 0.07 0.64 50500000
+ 0.36 0.07 0.64 57571429
+ 0.36 0.07 0.64 64642857
+ 0.36 0.07 0.64 71714286
+ 0.36 0.07 0.64 78785714
+ 0.36 0.07 0.64 85857143
+ 0.36 0.07 0.64 92928571
+ 0.36 0.07 0.64 100000000
+ 0.36 0.07 0.71 1000000
+ 0.36 0.07 0.71 8071429
+ 0.36 0.07 0.71 15142857
+ 0.36 0.07 0.71 22214286
+ 0.36 0.07 0.71 29285714
+ 0.36 0.07 0.71 36357143
+ 0.36 0.07 0.71 43428571
+ 0.36 0.07 0.71 50500000
+ 0.36 0.07 0.71 57571429
+ 0.36 0.07 0.71 64642857
+ 0.36 0.07 0.71 71714286
+ 0.36 0.07 0.71 78785714
+ 0.36 0.07 0.71 85857143
+ 0.36 0.07 0.71 92928571
+ 0.36 0.07 0.71 100000000
+ 0.36 0.07 0.79 1000000
+ 0.36 0.07 0.79 8071429
+ 0.36 0.07 0.79 15142857
+ 0.36 0.07 0.79 22214286
+ 0.36 0.07 0.79 29285714
+ 0.36 0.07 0.79 36357143
+ 0.36 0.07 0.79 43428571
+ 0.36 0.07 0.79 50500000
+ 0.36 0.07 0.79 57571429
+ 0.36 0.07 0.79 64642857
+ 0.36 0.07 0.79 71714286
+ 0.36 0.07 0.79 78785714
+ 0.36 0.07 0.79 85857143
+ 0.36 0.07 0.79 92928571
+ 0.36 0.07 0.79 100000000
+ 0.36 0.07 0.86 1000000
+ 0.36 0.07 0.86 8071429
+ 0.36 0.07 0.86 15142857
+ 0.36 0.07 0.86 22214286
+ 0.36 0.07 0.86 29285714
+ 0.36 0.07 0.86 36357143
+ 0.36 0.07 0.86 43428571
+ 0.36 0.07 0.86 50500000
+ 0.36 0.07 0.86 57571429
+ 0.36 0.07 0.86 64642857
+ 0.36 0.07 0.86 71714286
+ 0.36 0.07 0.86 78785714
+ 0.36 0.07 0.86 85857143
+ 0.36 0.07 0.86 92928571
+ 0.36 0.07 0.86 100000000
+ 0.36 0.07 0.93 1000000
+ 0.36 0.07 0.93 8071429
+ 0.36 0.07 0.93 15142857
+ 0.36 0.07 0.93 22214286
+ 0.36 0.07 0.93 29285714
+ 0.36 0.07 0.93 36357143
+ 0.36 0.07 0.93 43428571
+ 0.36 0.07 0.93 50500000
+ 0.36 0.07 0.93 57571429
+ 0.36 0.07 0.93 64642857
+ 0.36 0.07 0.93 71714286
+ 0.36 0.07 0.93 78785714
+ 0.36 0.07 0.93 85857143
+ 0.36 0.07 0.93 92928571
+ 0.36 0.07 0.93 100000000
+ 0.36 0.07 1.00 1000000
+ 0.36 0.07 1.00 8071429
+ 0.36 0.07 1.00 15142857
+ 0.36 0.07 1.00 22214286
+ 0.36 0.07 1.00 29285714
+ 0.36 0.07 1.00 36357143
+ 0.36 0.07 1.00 43428571
+ 0.36 0.07 1.00 50500000
+ 0.36 0.07 1.00 57571429
+ 0.36 0.07 1.00 64642857
+ 0.36 0.07 1.00 71714286
+ 0.36 0.07 1.00 78785714
+ 0.36 0.07 1.00 85857143
+ 0.36 0.07 1.00 92928571
+ 0.36 0.07 1.00 100000000
+ 0.36 0.14 0.00 1000000
+ 0.36 0.14 0.00 8071429
+ 0.36 0.14 0.00 15142857
+ 0.36 0.14 0.00 22214286
+ 0.36 0.14 0.00 29285714
+ 0.36 0.14 0.00 36357143
+ 0.36 0.14 0.00 43428571
+ 0.36 0.14 0.00 50500000
+ 0.36 0.14 0.00 57571429
+ 0.36 0.14 0.00 64642857
+ 0.36 0.14 0.00 71714286
+ 0.36 0.14 0.00 78785714
+ 0.36 0.14 0.00 85857143
+ 0.36 0.14 0.00 92928571
+ 0.36 0.14 0.00 100000000
+ 0.36 0.14 0.07 1000000
+ 0.36 0.14 0.07 8071429
+ 0.36 0.14 0.07 15142857
+ 0.36 0.14 0.07 22214286
+ 0.36 0.14 0.07 29285714
+ 0.36 0.14 0.07 36357143
+ 0.36 0.14 0.07 43428571
+ 0.36 0.14 0.07 50500000
+ 0.36 0.14 0.07 57571429
+ 0.36 0.14 0.07 64642857
+ 0.36 0.14 0.07 71714286
+ 0.36 0.14 0.07 78785714
+ 0.36 0.14 0.07 85857143
+ 0.36 0.14 0.07 92928571
+ 0.36 0.14 0.07 100000000
+ 0.36 0.14 0.14 1000000
+ 0.36 0.14 0.14 8071429
+ 0.36 0.14 0.14 15142857
+ 0.36 0.14 0.14 22214286
+ 0.36 0.14 0.14 29285714
+ 0.36 0.14 0.14 36357143
+ 0.36 0.14 0.14 43428571
+ 0.36 0.14 0.14 50500000
+ 0.36 0.14 0.14 57571429
+ 0.36 0.14 0.14 64642857
+ 0.36 0.14 0.14 71714286
+ 0.36 0.14 0.14 78785714
+ 0.36 0.14 0.14 85857143
+ 0.36 0.14 0.14 92928571
+ 0.36 0.14 0.14 100000000
+ 0.36 0.14 0.21 1000000
+ 0.36 0.14 0.21 8071429
+ 0.36 0.14 0.21 15142857
+ 0.36 0.14 0.21 22214286
+ 0.36 0.14 0.21 29285714
+ 0.36 0.14 0.21 36357143
+ 0.36 0.14 0.21 43428571
+ 0.36 0.14 0.21 50500000
+ 0.36 0.14 0.21 57571429
+ 0.36 0.14 0.21 64642857
+ 0.36 0.14 0.21 71714286
+ 0.36 0.14 0.21 78785714
+ 0.36 0.14 0.21 85857143
+ 0.36 0.14 0.21 92928571
+ 0.36 0.14 0.21 100000000
+ 0.36 0.14 0.29 1000000
+ 0.36 0.14 0.29 8071429
+ 0.36 0.14 0.29 15142857
+ 0.36 0.14 0.29 22214286
+ 0.36 0.14 0.29 29285714
+ 0.36 0.14 0.29 36357143
+ 0.36 0.14 0.29 43428571
+ 0.36 0.14 0.29 50500000
+ 0.36 0.14 0.29 57571429
+ 0.36 0.14 0.29 64642857
+ 0.36 0.14 0.29 71714286
+ 0.36 0.14 0.29 78785714
+ 0.36 0.14 0.29 85857143
+ 0.36 0.14 0.29 92928571
+ 0.36 0.14 0.29 100000000
+ 0.36 0.14 0.36 1000000
+ 0.36 0.14 0.36 8071429
+ 0.36 0.14 0.36 15142857
+ 0.36 0.14 0.36 22214286
+ 0.36 0.14 0.36 29285714
+ 0.36 0.14 0.36 36357143
+ 0.36 0.14 0.36 43428571
+ 0.36 0.14 0.36 50500000
+ 0.36 0.14 0.36 57571429
+ 0.36 0.14 0.36 64642857
+ 0.36 0.14 0.36 71714286
+ 0.36 0.14 0.36 78785714
+ 0.36 0.14 0.36 85857143
+ 0.36 0.14 0.36 92928571
+ 0.36 0.14 0.36 100000000
+ 0.36 0.14 0.43 1000000
+ 0.36 0.14 0.43 8071429
+ 0.36 0.14 0.43 15142857
+ 0.36 0.14 0.43 22214286
+ 0.36 0.14 0.43 29285714
+ 0.36 0.14 0.43 36357143
+ 0.36 0.14 0.43 43428571
+ 0.36 0.14 0.43 50500000
+ 0.36 0.14 0.43 57571429
+ 0.36 0.14 0.43 64642857
+ 0.36 0.14 0.43 71714286
+ 0.36 0.14 0.43 78785714
+ 0.36 0.14 0.43 85857143
+ 0.36 0.14 0.43 92928571
+ 0.36 0.14 0.43 100000000
+ 0.36 0.14 0.50 1000000
+ 0.36 0.14 0.50 8071429
+ 0.36 0.14 0.50 15142857
+ 0.36 0.14 0.50 22214286
+ 0.36 0.14 0.50 29285714
+ 0.36 0.14 0.50 36357143
+ 0.36 0.14 0.50 43428571
+ 0.36 0.14 0.50 50500000
+ 0.36 0.14 0.50 57571429
+ 0.36 0.14 0.50 64642857
+ 0.36 0.14 0.50 71714286
+ 0.36 0.14 0.50 78785714
+ 0.36 0.14 0.50 85857143
+ 0.36 0.14 0.50 92928571
+ 0.36 0.14 0.50 100000000
+ 0.36 0.14 0.57 1000000
+ 0.36 0.14 0.57 8071429
+ 0.36 0.14 0.57 15142857
+ 0.36 0.14 0.57 22214286
+ 0.36 0.14 0.57 29285714
+ 0.36 0.14 0.57 36357143
+ 0.36 0.14 0.57 43428571
+ 0.36 0.14 0.57 50500000
+ 0.36 0.14 0.57 57571429
+ 0.36 0.14 0.57 64642857
+ 0.36 0.14 0.57 71714286
+ 0.36 0.14 0.57 78785714
+ 0.36 0.14 0.57 85857143
+ 0.36 0.14 0.57 92928571
+ 0.36 0.14 0.57 100000000
+ 0.36 0.14 0.64 1000000
+ 0.36 0.14 0.64 8071429
+ 0.36 0.14 0.64 15142857
+ 0.36 0.14 0.64 22214286
+ 0.36 0.14 0.64 29285714
+ 0.36 0.14 0.64 36357143
+ 0.36 0.14 0.64 43428571
+ 0.36 0.14 0.64 50500000
+ 0.36 0.14 0.64 57571429
+ 0.36 0.14 0.64 64642857
+ 0.36 0.14 0.64 71714286
+ 0.36 0.14 0.64 78785714
+ 0.36 0.14 0.64 85857143
+ 0.36 0.14 0.64 92928571
+ 0.36 0.14 0.64 100000000
+ 0.36 0.14 0.71 1000000
+ 0.36 0.14 0.71 8071429
+ 0.36 0.14 0.71 15142857
+ 0.36 0.14 0.71 22214286
+ 0.36 0.14 0.71 29285714
+ 0.36 0.14 0.71 36357143
+ 0.36 0.14 0.71 43428571
+ 0.36 0.14 0.71 50500000
+ 0.36 0.14 0.71 57571429
+ 0.36 0.14 0.71 64642857
+ 0.36 0.14 0.71 71714286
+ 0.36 0.14 0.71 78785714
+ 0.36 0.14 0.71 85857143
+ 0.36 0.14 0.71 92928571
+ 0.36 0.14 0.71 100000000
+ 0.36 0.14 0.79 1000000
+ 0.36 0.14 0.79 8071429
+ 0.36 0.14 0.79 15142857
+ 0.36 0.14 0.79 22214286
+ 0.36 0.14 0.79 29285714
+ 0.36 0.14 0.79 36357143
+ 0.36 0.14 0.79 43428571
+ 0.36 0.14 0.79 50500000
+ 0.36 0.14 0.79 57571429
+ 0.36 0.14 0.79 64642857
+ 0.36 0.14 0.79 71714286
+ 0.36 0.14 0.79 78785714
+ 0.36 0.14 0.79 85857143
+ 0.36 0.14 0.79 92928571
+ 0.36 0.14 0.79 100000000
+ 0.36 0.14 0.86 1000000
+ 0.36 0.14 0.86 8071429
+ 0.36 0.14 0.86 15142857
+ 0.36 0.14 0.86 22214286
+ 0.36 0.14 0.86 29285714
+ 0.36 0.14 0.86 36357143
+ 0.36 0.14 0.86 43428571
+ 0.36 0.14 0.86 50500000
+ 0.36 0.14 0.86 57571429
+ 0.36 0.14 0.86 64642857
+ 0.36 0.14 0.86 71714286
+ 0.36 0.14 0.86 78785714
+ 0.36 0.14 0.86 85857143
+ 0.36 0.14 0.86 92928571
+ 0.36 0.14 0.86 100000000
+ 0.36 0.14 0.93 1000000
+ 0.36 0.14 0.93 8071429
+ 0.36 0.14 0.93 15142857
+ 0.36 0.14 0.93 22214286
+ 0.36 0.14 0.93 29285714
+ 0.36 0.14 0.93 36357143
+ 0.36 0.14 0.93 43428571
+ 0.36 0.14 0.93 50500000
+ 0.36 0.14 0.93 57571429
+ 0.36 0.14 0.93 64642857
+ 0.36 0.14 0.93 71714286
+ 0.36 0.14 0.93 78785714
+ 0.36 0.14 0.93 85857143
+ 0.36 0.14 0.93 92928571
+ 0.36 0.14 0.93 100000000
+ 0.36 0.14 1.00 1000000
+ 0.36 0.14 1.00 8071429
+ 0.36 0.14 1.00 15142857
+ 0.36 0.14 1.00 22214286
+ 0.36 0.14 1.00 29285714
+ 0.36 0.14 1.00 36357143
+ 0.36 0.14 1.00 43428571
+ 0.36 0.14 1.00 50500000
+ 0.36 0.14 1.00 57571429
+ 0.36 0.14 1.00 64642857
+ 0.36 0.14 1.00 71714286
+ 0.36 0.14 1.00 78785714
+ 0.36 0.14 1.00 85857143
+ 0.36 0.14 1.00 92928571
+ 0.36 0.14 1.00 100000000
+ 0.36 0.21 0.00 1000000
+ 0.36 0.21 0.00 8071429
+ 0.36 0.21 0.00 15142857
+ 0.36 0.21 0.00 22214286
+ 0.36 0.21 0.00 29285714
+ 0.36 0.21 0.00 36357143
+ 0.36 0.21 0.00 43428571
+ 0.36 0.21 0.00 50500000
+ 0.36 0.21 0.00 57571429
+ 0.36 0.21 0.00 64642857
+ 0.36 0.21 0.00 71714286
+ 0.36 0.21 0.00 78785714
+ 0.36 0.21 0.00 85857143
+ 0.36 0.21 0.00 92928571
+ 0.36 0.21 0.00 100000000
+ 0.36 0.21 0.07 1000000
+ 0.36 0.21 0.07 8071429
+ 0.36 0.21 0.07 15142857
+ 0.36 0.21 0.07 22214286
+ 0.36 0.21 0.07 29285714
+ 0.36 0.21 0.07 36357143
+ 0.36 0.21 0.07 43428571
+ 0.36 0.21 0.07 50500000
+ 0.36 0.21 0.07 57571429
+ 0.36 0.21 0.07 64642857
+ 0.36 0.21 0.07 71714286
+ 0.36 0.21 0.07 78785714
+ 0.36 0.21 0.07 85857143
+ 0.36 0.21 0.07 92928571
+ 0.36 0.21 0.07 100000000
+ 0.36 0.21 0.14 1000000
+ 0.36 0.21 0.14 8071429
+ 0.36 0.21 0.14 15142857
+ 0.36 0.21 0.14 22214286
+ 0.36 0.21 0.14 29285714
+ 0.36 0.21 0.14 36357143
+ 0.36 0.21 0.14 43428571
+ 0.36 0.21 0.14 50500000
+ 0.36 0.21 0.14 57571429
+ 0.36 0.21 0.14 64642857
+ 0.36 0.21 0.14 71714286
+ 0.36 0.21 0.14 78785714
+ 0.36 0.21 0.14 85857143
+ 0.36 0.21 0.14 92928571
+ 0.36 0.21 0.14 100000000
+ 0.36 0.21 0.21 1000000
+ 0.36 0.21 0.21 8071429
+ 0.36 0.21 0.21 15142857
+ 0.36 0.21 0.21 22214286
+ 0.36 0.21 0.21 29285714
+ 0.36 0.21 0.21 36357143
+ 0.36 0.21 0.21 43428571
+ 0.36 0.21 0.21 50500000
+ 0.36 0.21 0.21 57571429
+ 0.36 0.21 0.21 64642857
+ 0.36 0.21 0.21 71714286
+ 0.36 0.21 0.21 78785714
+ 0.36 0.21 0.21 85857143
+ 0.36 0.21 0.21 92928571
+ 0.36 0.21 0.21 100000000
+ 0.36 0.21 0.29 1000000
+ 0.36 0.21 0.29 8071429
+ 0.36 0.21 0.29 15142857
+ 0.36 0.21 0.29 22214286
+ 0.36 0.21 0.29 29285714
+ 0.36 0.21 0.29 36357143
+ 0.36 0.21 0.29 43428571
+ 0.36 0.21 0.29 50500000
+ 0.36 0.21 0.29 57571429
+ 0.36 0.21 0.29 64642857
+ 0.36 0.21 0.29 71714286
+ 0.36 0.21 0.29 78785714
+ 0.36 0.21 0.29 85857143
+ 0.36 0.21 0.29 92928571
+ 0.36 0.21 0.29 100000000
+ 0.36 0.21 0.36 1000000
+ 0.36 0.21 0.36 8071429
+ 0.36 0.21 0.36 15142857
+ 0.36 0.21 0.36 22214286
+ 0.36 0.21 0.36 29285714
+ 0.36 0.21 0.36 36357143
+ 0.36 0.21 0.36 43428571
+ 0.36 0.21 0.36 50500000
+ 0.36 0.21 0.36 57571429
+ 0.36 0.21 0.36 64642857
+ 0.36 0.21 0.36 71714286
+ 0.36 0.21 0.36 78785714
+ 0.36 0.21 0.36 85857143
+ 0.36 0.21 0.36 92928571
+ 0.36 0.21 0.36 100000000
+ 0.36 0.21 0.43 1000000
+ 0.36 0.21 0.43 8071429
+ 0.36 0.21 0.43 15142857
+ 0.36 0.21 0.43 22214286
+ 0.36 0.21 0.43 29285714
+ 0.36 0.21 0.43 36357143
+ 0.36 0.21 0.43 43428571
+ 0.36 0.21 0.43 50500000
+ 0.36 0.21 0.43 57571429
+ 0.36 0.21 0.43 64642857
+ 0.36 0.21 0.43 71714286
+ 0.36 0.21 0.43 78785714
+ 0.36 0.21 0.43 85857143
+ 0.36 0.21 0.43 92928571
+ 0.36 0.21 0.43 100000000
+ 0.36 0.21 0.50 1000000
+ 0.36 0.21 0.50 8071429
+ 0.36 0.21 0.50 15142857
+ 0.36 0.21 0.50 22214286
+ 0.36 0.21 0.50 29285714
+ 0.36 0.21 0.50 36357143
+ 0.36 0.21 0.50 43428571
+ 0.36 0.21 0.50 50500000
+ 0.36 0.21 0.50 57571429
+ 0.36 0.21 0.50 64642857
+ 0.36 0.21 0.50 71714286
+ 0.36 0.21 0.50 78785714
+ 0.36 0.21 0.50 85857143
+ 0.36 0.21 0.50 92928571
+ 0.36 0.21 0.50 100000000
+ 0.36 0.21 0.57 1000000
+ 0.36 0.21 0.57 8071429
+ 0.36 0.21 0.57 15142857
+ 0.36 0.21 0.57 22214286
+ 0.36 0.21 0.57 29285714
+ 0.36 0.21 0.57 36357143
+ 0.36 0.21 0.57 43428571
+ 0.36 0.21 0.57 50500000
+ 0.36 0.21 0.57 57571429
+ 0.36 0.21 0.57 64642857
+ 0.36 0.21 0.57 71714286
+ 0.36 0.21 0.57 78785714
+ 0.36 0.21 0.57 85857143
+ 0.36 0.21 0.57 92928571
+ 0.36 0.21 0.57 100000000
+ 0.36 0.21 0.64 1000000
+ 0.36 0.21 0.64 8071429
+ 0.36 0.21 0.64 15142857
+ 0.36 0.21 0.64 22214286
+ 0.36 0.21 0.64 29285714
+ 0.36 0.21 0.64 36357143
+ 0.36 0.21 0.64 43428571
+ 0.36 0.21 0.64 50500000
+ 0.36 0.21 0.64 57571429
+ 0.36 0.21 0.64 64642857
+ 0.36 0.21 0.64 71714286
+ 0.36 0.21 0.64 78785714
+ 0.36 0.21 0.64 85857143
+ 0.36 0.21 0.64 92928571
+ 0.36 0.21 0.64 100000000
+ 0.36 0.21 0.71 1000000
+ 0.36 0.21 0.71 8071429
+ 0.36 0.21 0.71 15142857
+ 0.36 0.21 0.71 22214286
+ 0.36 0.21 0.71 29285714
+ 0.36 0.21 0.71 36357143
+ 0.36 0.21 0.71 43428571
+ 0.36 0.21 0.71 50500000
+ 0.36 0.21 0.71 57571429
+ 0.36 0.21 0.71 64642857
+ 0.36 0.21 0.71 71714286
+ 0.36 0.21 0.71 78785714
+ 0.36 0.21 0.71 85857143
+ 0.36 0.21 0.71 92928571
+ 0.36 0.21 0.71 100000000
+ 0.36 0.21 0.79 1000000
+ 0.36 0.21 0.79 8071429
+ 0.36 0.21 0.79 15142857
+ 0.36 0.21 0.79 22214286
+ 0.36 0.21 0.79 29285714
+ 0.36 0.21 0.79 36357143
+ 0.36 0.21 0.79 43428571
+ 0.36 0.21 0.79 50500000
+ 0.36 0.21 0.79 57571429
+ 0.36 0.21 0.79 64642857
+ 0.36 0.21 0.79 71714286
+ 0.36 0.21 0.79 78785714
+ 0.36 0.21 0.79 85857143
+ 0.36 0.21 0.79 92928571
+ 0.36 0.21 0.79 100000000
+ 0.36 0.21 0.86 1000000
+ 0.36 0.21 0.86 8071429
+ 0.36 0.21 0.86 15142857
+ 0.36 0.21 0.86 22214286
+ 0.36 0.21 0.86 29285714
+ 0.36 0.21 0.86 36357143
+ 0.36 0.21 0.86 43428571
+ 0.36 0.21 0.86 50500000
+ 0.36 0.21 0.86 57571429
+ 0.36 0.21 0.86 64642857
+ 0.36 0.21 0.86 71714286
+ 0.36 0.21 0.86 78785714
+ 0.36 0.21 0.86 85857143
+ 0.36 0.21 0.86 92928571
+ 0.36 0.21 0.86 100000000
+ 0.36 0.21 0.93 1000000
+ 0.36 0.21 0.93 8071429
+ 0.36 0.21 0.93 15142857
+ 0.36 0.21 0.93 22214286
+ 0.36 0.21 0.93 29285714
+ 0.36 0.21 0.93 36357143
+ 0.36 0.21 0.93 43428571
+ 0.36 0.21 0.93 50500000
+ 0.36 0.21 0.93 57571429
+ 0.36 0.21 0.93 64642857
+ 0.36 0.21 0.93 71714286
+ 0.36 0.21 0.93 78785714
+ 0.36 0.21 0.93 85857143
+ 0.36 0.21 0.93 92928571
+ 0.36 0.21 0.93 100000000
+ 0.36 0.21 1.00 1000000
+ 0.36 0.21 1.00 8071429
+ 0.36 0.21 1.00 15142857
+ 0.36 0.21 1.00 22214286
+ 0.36 0.21 1.00 29285714
+ 0.36 0.21 1.00 36357143
+ 0.36 0.21 1.00 43428571
+ 0.36 0.21 1.00 50500000
+ 0.36 0.21 1.00 57571429
+ 0.36 0.21 1.00 64642857
+ 0.36 0.21 1.00 71714286
+ 0.36 0.21 1.00 78785714
+ 0.36 0.21 1.00 85857143
+ 0.36 0.21 1.00 92928571
+ 0.36 0.21 1.00 100000000
+ 0.36 0.29 0.00 1000000
+ 0.36 0.29 0.00 8071429
+ 0.36 0.29 0.00 15142857
+ 0.36 0.29 0.00 22214286
+ 0.36 0.29 0.00 29285714
+ 0.36 0.29 0.00 36357143
+ 0.36 0.29 0.00 43428571
+ 0.36 0.29 0.00 50500000
+ 0.36 0.29 0.00 57571429
+ 0.36 0.29 0.00 64642857
+ 0.36 0.29 0.00 71714286
+ 0.36 0.29 0.00 78785714
+ 0.36 0.29 0.00 85857143
+ 0.36 0.29 0.00 92928571
+ 0.36 0.29 0.00 100000000
+ 0.36 0.29 0.07 1000000
+ 0.36 0.29 0.07 8071429
+ 0.36 0.29 0.07 15142857
+ 0.36 0.29 0.07 22214286
+ 0.36 0.29 0.07 29285714
+ 0.36 0.29 0.07 36357143
+ 0.36 0.29 0.07 43428571
+ 0.36 0.29 0.07 50500000
+ 0.36 0.29 0.07 57571429
+ 0.36 0.29 0.07 64642857
+ 0.36 0.29 0.07 71714286
+ 0.36 0.29 0.07 78785714
+ 0.36 0.29 0.07 85857143
+ 0.36 0.29 0.07 92928571
+ 0.36 0.29 0.07 100000000
+ 0.36 0.29 0.14 1000000
+ 0.36 0.29 0.14 8071429
+ 0.36 0.29 0.14 15142857
+ 0.36 0.29 0.14 22214286
+ 0.36 0.29 0.14 29285714
+ 0.36 0.29 0.14 36357143
+ 0.36 0.29 0.14 43428571
+ 0.36 0.29 0.14 50500000
+ 0.36 0.29 0.14 57571429
+ 0.36 0.29 0.14 64642857
+ 0.36 0.29 0.14 71714286
+ 0.36 0.29 0.14 78785714
+ 0.36 0.29 0.14 85857143
+ 0.36 0.29 0.14 92928571
+ 0.36 0.29 0.14 100000000
+ 0.36 0.29 0.21 1000000
+ 0.36 0.29 0.21 8071429
+ 0.36 0.29 0.21 15142857
+ 0.36 0.29 0.21 22214286
+ 0.36 0.29 0.21 29285714
+ 0.36 0.29 0.21 36357143
+ 0.36 0.29 0.21 43428571
+ 0.36 0.29 0.21 50500000
+ 0.36 0.29 0.21 57571429
+ 0.36 0.29 0.21 64642857
+ 0.36 0.29 0.21 71714286
+ 0.36 0.29 0.21 78785714
+ 0.36 0.29 0.21 85857143
+ 0.36 0.29 0.21 92928571
+ 0.36 0.29 0.21 100000000
+ 0.36 0.29 0.29 1000000
+ 0.36 0.29 0.29 8071429
+ 0.36 0.29 0.29 15142857
+ 0.36 0.29 0.29 22214286
+ 0.36 0.29 0.29 29285714
+ 0.36 0.29 0.29 36357143
+ 0.36 0.29 0.29 43428571
+ 0.36 0.29 0.29 50500000
+ 0.36 0.29 0.29 57571429
+ 0.36 0.29 0.29 64642857
+ 0.36 0.29 0.29 71714286
+ 0.36 0.29 0.29 78785714
+ 0.36 0.29 0.29 85857143
+ 0.36 0.29 0.29 92928571
+ 0.36 0.29 0.29 100000000
+ 0.36 0.29 0.36 1000000
+ 0.36 0.29 0.36 8071429
+ 0.36 0.29 0.36 15142857
+ 0.36 0.29 0.36 22214286
+ 0.36 0.29 0.36 29285714
+ 0.36 0.29 0.36 36357143
+ 0.36 0.29 0.36 43428571
+ 0.36 0.29 0.36 50500000
+ 0.36 0.29 0.36 57571429
+ 0.36 0.29 0.36 64642857
+ 0.36 0.29 0.36 71714286
+ 0.36 0.29 0.36 78785714
+ 0.36 0.29 0.36 85857143
+ 0.36 0.29 0.36 92928571
+ 0.36 0.29 0.36 100000000
+ 0.36 0.29 0.43 1000000
+ 0.36 0.29 0.43 8071429
+ 0.36 0.29 0.43 15142857
+ 0.36 0.29 0.43 22214286
+ 0.36 0.29 0.43 29285714
+ 0.36 0.29 0.43 36357143
+ 0.36 0.29 0.43 43428571
+ 0.36 0.29 0.43 50500000
+ 0.36 0.29 0.43 57571429
+ 0.36 0.29 0.43 64642857
+ 0.36 0.29 0.43 71714286
+ 0.36 0.29 0.43 78785714
+ 0.36 0.29 0.43 85857143
+ 0.36 0.29 0.43 92928571
+ 0.36 0.29 0.43 100000000
+ 0.36 0.29 0.50 1000000
+ 0.36 0.29 0.50 8071429
+ 0.36 0.29 0.50 15142857
+ 0.36 0.29 0.50 22214286
+ 0.36 0.29 0.50 29285714
+ 0.36 0.29 0.50 36357143
+ 0.36 0.29 0.50 43428571
+ 0.36 0.29 0.50 50500000
+ 0.36 0.29 0.50 57571429
+ 0.36 0.29 0.50 64642857
+ 0.36 0.29 0.50 71714286
+ 0.36 0.29 0.50 78785714
+ 0.36 0.29 0.50 85857143
+ 0.36 0.29 0.50 92928571
+ 0.36 0.29 0.50 100000000
+ 0.36 0.29 0.57 1000000
+ 0.36 0.29 0.57 8071429
+ 0.36 0.29 0.57 15142857
+ 0.36 0.29 0.57 22214286
+ 0.36 0.29 0.57 29285714
+ 0.36 0.29 0.57 36357143
+ 0.36 0.29 0.57 43428571
+ 0.36 0.29 0.57 50500000
+ 0.36 0.29 0.57 57571429
+ 0.36 0.29 0.57 64642857
+ 0.36 0.29 0.57 71714286
+ 0.36 0.29 0.57 78785714
+ 0.36 0.29 0.57 85857143
+ 0.36 0.29 0.57 92928571
+ 0.36 0.29 0.57 100000000
+ 0.36 0.29 0.64 1000000
+ 0.36 0.29 0.64 8071429
+ 0.36 0.29 0.64 15142857
+ 0.36 0.29 0.64 22214286
+ 0.36 0.29 0.64 29285714
+ 0.36 0.29 0.64 36357143
+ 0.36 0.29 0.64 43428571
+ 0.36 0.29 0.64 50500000
+ 0.36 0.29 0.64 57571429
+ 0.36 0.29 0.64 64642857
+ 0.36 0.29 0.64 71714286
+ 0.36 0.29 0.64 78785714
+ 0.36 0.29 0.64 85857143
+ 0.36 0.29 0.64 92928571
+ 0.36 0.29 0.64 100000000
+ 0.36 0.29 0.71 1000000
+ 0.36 0.29 0.71 8071429
+ 0.36 0.29 0.71 15142857
+ 0.36 0.29 0.71 22214286
+ 0.36 0.29 0.71 29285714
+ 0.36 0.29 0.71 36357143
+ 0.36 0.29 0.71 43428571
+ 0.36 0.29 0.71 50500000
+ 0.36 0.29 0.71 57571429
+ 0.36 0.29 0.71 64642857
+ 0.36 0.29 0.71 71714286
+ 0.36 0.29 0.71 78785714
+ 0.36 0.29 0.71 85857143
+ 0.36 0.29 0.71 92928571
+ 0.36 0.29 0.71 100000000
+ 0.36 0.29 0.79 1000000
+ 0.36 0.29 0.79 8071429
+ 0.36 0.29 0.79 15142857
+ 0.36 0.29 0.79 22214286
+ 0.36 0.29 0.79 29285714
+ 0.36 0.29 0.79 36357143
+ 0.36 0.29 0.79 43428571
+ 0.36 0.29 0.79 50500000
+ 0.36 0.29 0.79 57571429
+ 0.36 0.29 0.79 64642857
+ 0.36 0.29 0.79 71714286
+ 0.36 0.29 0.79 78785714
+ 0.36 0.29 0.79 85857143
+ 0.36 0.29 0.79 92928571
+ 0.36 0.29 0.79 100000000
+ 0.36 0.29 0.86 1000000
+ 0.36 0.29 0.86 8071429
+ 0.36 0.29 0.86 15142857
+ 0.36 0.29 0.86 22214286
+ 0.36 0.29 0.86 29285714
+ 0.36 0.29 0.86 36357143
+ 0.36 0.29 0.86 43428571
+ 0.36 0.29 0.86 50500000
+ 0.36 0.29 0.86 57571429
+ 0.36 0.29 0.86 64642857
+ 0.36 0.29 0.86 71714286
+ 0.36 0.29 0.86 78785714
+ 0.36 0.29 0.86 85857143
+ 0.36 0.29 0.86 92928571
+ 0.36 0.29 0.86 100000000
+ 0.36 0.29 0.93 1000000
+ 0.36 0.29 0.93 8071429
+ 0.36 0.29 0.93 15142857
+ 0.36 0.29 0.93 22214286
+ 0.36 0.29 0.93 29285714
+ 0.36 0.29 0.93 36357143
+ 0.36 0.29 0.93 43428571
+ 0.36 0.29 0.93 50500000
+ 0.36 0.29 0.93 57571429
+ 0.36 0.29 0.93 64642857
+ 0.36 0.29 0.93 71714286
+ 0.36 0.29 0.93 78785714
+ 0.36 0.29 0.93 85857143
+ 0.36 0.29 0.93 92928571
+ 0.36 0.29 0.93 100000000
+ 0.36 0.29 1.00 1000000
+ 0.36 0.29 1.00 8071429
+ 0.36 0.29 1.00 15142857
+ 0.36 0.29 1.00 22214286
+ 0.36 0.29 1.00 29285714
+ 0.36 0.29 1.00 36357143
+ 0.36 0.29 1.00 43428571
+ 0.36 0.29 1.00 50500000
+ 0.36 0.29 1.00 57571429
+ 0.36 0.29 1.00 64642857
+ 0.36 0.29 1.00 71714286
+ 0.36 0.29 1.00 78785714
+ 0.36 0.29 1.00 85857143
+ 0.36 0.29 1.00 92928571
+ 0.36 0.29 1.00 100000000
+ 0.36 0.36 0.00 1000000
+ 0.36 0.36 0.00 8071429
+ 0.36 0.36 0.00 15142857
+ 0.36 0.36 0.00 22214286
+ 0.36 0.36 0.00 29285714
+ 0.36 0.36 0.00 36357143
+ 0.36 0.36 0.00 43428571
+ 0.36 0.36 0.00 50500000
+ 0.36 0.36 0.00 57571429
+ 0.36 0.36 0.00 64642857
+ 0.36 0.36 0.00 71714286
+ 0.36 0.36 0.00 78785714
+ 0.36 0.36 0.00 85857143
+ 0.36 0.36 0.00 92928571
+ 0.36 0.36 0.00 100000000
+ 0.36 0.36 0.07 1000000
+ 0.36 0.36 0.07 8071429
+ 0.36 0.36 0.07 15142857
+ 0.36 0.36 0.07 22214286
+ 0.36 0.36 0.07 29285714
+ 0.36 0.36 0.07 36357143
+ 0.36 0.36 0.07 43428571
+ 0.36 0.36 0.07 50500000
+ 0.36 0.36 0.07 57571429
+ 0.36 0.36 0.07 64642857
+ 0.36 0.36 0.07 71714286
+ 0.36 0.36 0.07 78785714
+ 0.36 0.36 0.07 85857143
+ 0.36 0.36 0.07 92928571
+ 0.36 0.36 0.07 100000000
+ 0.36 0.36 0.14 1000000
+ 0.36 0.36 0.14 8071429
+ 0.36 0.36 0.14 15142857
+ 0.36 0.36 0.14 22214286
+ 0.36 0.36 0.14 29285714
+ 0.36 0.36 0.14 36357143
+ 0.36 0.36 0.14 43428571
+ 0.36 0.36 0.14 50500000
+ 0.36 0.36 0.14 57571429
+ 0.36 0.36 0.14 64642857
+ 0.36 0.36 0.14 71714286
+ 0.36 0.36 0.14 78785714
+ 0.36 0.36 0.14 85857143
+ 0.36 0.36 0.14 92928571
+ 0.36 0.36 0.14 100000000
+ 0.36 0.36 0.21 1000000
+ 0.36 0.36 0.21 8071429
+ 0.36 0.36 0.21 15142857
+ 0.36 0.36 0.21 22214286
+ 0.36 0.36 0.21 29285714
+ 0.36 0.36 0.21 36357143
+ 0.36 0.36 0.21 43428571
+ 0.36 0.36 0.21 50500000
+ 0.36 0.36 0.21 57571429
+ 0.36 0.36 0.21 64642857
+ 0.36 0.36 0.21 71714286
+ 0.36 0.36 0.21 78785714
+ 0.36 0.36 0.21 85857143
+ 0.36 0.36 0.21 92928571
+ 0.36 0.36 0.21 100000000
+ 0.36 0.36 0.29 1000000
+ 0.36 0.36 0.29 8071429
+ 0.36 0.36 0.29 15142857
+ 0.36 0.36 0.29 22214286
+ 0.36 0.36 0.29 29285714
+ 0.36 0.36 0.29 36357143
+ 0.36 0.36 0.29 43428571
+ 0.36 0.36 0.29 50500000
+ 0.36 0.36 0.29 57571429
+ 0.36 0.36 0.29 64642857
+ 0.36 0.36 0.29 71714286
+ 0.36 0.36 0.29 78785714
+ 0.36 0.36 0.29 85857143
+ 0.36 0.36 0.29 92928571
+ 0.36 0.36 0.29 100000000
+ 0.36 0.36 0.36 1000000
+ 0.36 0.36 0.36 8071429
+ 0.36 0.36 0.36 15142857
+ 0.36 0.36 0.36 22214286
+ 0.36 0.36 0.36 29285714
+ 0.36 0.36 0.36 36357143
+ 0.36 0.36 0.36 43428571
+ 0.36 0.36 0.36 50500000
+ 0.36 0.36 0.36 57571429
+ 0.36 0.36 0.36 64642857
+ 0.36 0.36 0.36 71714286
+ 0.36 0.36 0.36 78785714
+ 0.36 0.36 0.36 85857143
+ 0.36 0.36 0.36 92928571
+ 0.36 0.36 0.36 100000000
+ 0.36 0.36 0.43 1000000
+ 0.36 0.36 0.43 8071429
+ 0.36 0.36 0.43 15142857
+ 0.36 0.36 0.43 22214286
+ 0.36 0.36 0.43 29285714
+ 0.36 0.36 0.43 36357143
+ 0.36 0.36 0.43 43428571
+ 0.36 0.36 0.43 50500000
+ 0.36 0.36 0.43 57571429
+ 0.36 0.36 0.43 64642857
+ 0.36 0.36 0.43 71714286
+ 0.36 0.36 0.43 78785714
+ 0.36 0.36 0.43 85857143
+ 0.36 0.36 0.43 92928571
+ 0.36 0.36 0.43 100000000
+ 0.36 0.36 0.50 1000000
+ 0.36 0.36 0.50 8071429
+ 0.36 0.36 0.50 15142857
+ 0.36 0.36 0.50 22214286
+ 0.36 0.36 0.50 29285714
+ 0.36 0.36 0.50 36357143
+ 0.36 0.36 0.50 43428571
+ 0.36 0.36 0.50 50500000
+ 0.36 0.36 0.50 57571429
+ 0.36 0.36 0.50 64642857
+ 0.36 0.36 0.50 71714286
+ 0.36 0.36 0.50 78785714
+ 0.36 0.36 0.50 85857143
+ 0.36 0.36 0.50 92928571
+ 0.36 0.36 0.50 100000000
+ 0.36 0.36 0.57 1000000
+ 0.36 0.36 0.57 8071429
+ 0.36 0.36 0.57 15142857
+ 0.36 0.36 0.57 22214286
+ 0.36 0.36 0.57 29285714
+ 0.36 0.36 0.57 36357143
+ 0.36 0.36 0.57 43428571
+ 0.36 0.36 0.57 50500000
+ 0.36 0.36 0.57 57571429
+ 0.36 0.36 0.57 64642857
+ 0.36 0.36 0.57 71714286
+ 0.36 0.36 0.57 78785714
+ 0.36 0.36 0.57 85857143
+ 0.36 0.36 0.57 92928571
+ 0.36 0.36 0.57 100000000
+ 0.36 0.36 0.64 1000000
+ 0.36 0.36 0.64 8071429
+ 0.36 0.36 0.64 15142857
+ 0.36 0.36 0.64 22214286
+ 0.36 0.36 0.64 29285714
+ 0.36 0.36 0.64 36357143
+ 0.36 0.36 0.64 43428571
+ 0.36 0.36 0.64 50500000
+ 0.36 0.36 0.64 57571429
+ 0.36 0.36 0.64 64642857
+ 0.36 0.36 0.64 71714286
+ 0.36 0.36 0.64 78785714
+ 0.36 0.36 0.64 85857143
+ 0.36 0.36 0.64 92928571
+ 0.36 0.36 0.64 100000000
+ 0.36 0.36 0.71 1000000
+ 0.36 0.36 0.71 8071429
+ 0.36 0.36 0.71 15142857
+ 0.36 0.36 0.71 22214286
+ 0.36 0.36 0.71 29285714
+ 0.36 0.36 0.71 36357143
+ 0.36 0.36 0.71 43428571
+ 0.36 0.36 0.71 50500000
+ 0.36 0.36 0.71 57571429
+ 0.36 0.36 0.71 64642857
+ 0.36 0.36 0.71 71714286
+ 0.36 0.36 0.71 78785714
+ 0.36 0.36 0.71 85857143
+ 0.36 0.36 0.71 92928571
+ 0.36 0.36 0.71 100000000
+ 0.36 0.36 0.79 1000000
+ 0.36 0.36 0.79 8071429
+ 0.36 0.36 0.79 15142857
+ 0.36 0.36 0.79 22214286
+ 0.36 0.36 0.79 29285714
+ 0.36 0.36 0.79 36357143
+ 0.36 0.36 0.79 43428571
+ 0.36 0.36 0.79 50500000
+ 0.36 0.36 0.79 57571429
+ 0.36 0.36 0.79 64642857
+ 0.36 0.36 0.79 71714286
+ 0.36 0.36 0.79 78785714
+ 0.36 0.36 0.79 85857143
+ 0.36 0.36 0.79 92928571
+ 0.36 0.36 0.79 100000000
+ 0.36 0.36 0.86 1000000
+ 0.36 0.36 0.86 8071429
+ 0.36 0.36 0.86 15142857
+ 0.36 0.36 0.86 22214286
+ 0.36 0.36 0.86 29285714
+ 0.36 0.36 0.86 36357143
+ 0.36 0.36 0.86 43428571
+ 0.36 0.36 0.86 50500000
+ 0.36 0.36 0.86 57571429
+ 0.36 0.36 0.86 64642857
+ 0.36 0.36 0.86 71714286
+ 0.36 0.36 0.86 78785714
+ 0.36 0.36 0.86 85857143
+ 0.36 0.36 0.86 92928571
+ 0.36 0.36 0.86 100000000
+ 0.36 0.36 0.93 1000000
+ 0.36 0.36 0.93 8071429
+ 0.36 0.36 0.93 15142857
+ 0.36 0.36 0.93 22214286
+ 0.36 0.36 0.93 29285714
+ 0.36 0.36 0.93 36357143
+ 0.36 0.36 0.93 43428571
+ 0.36 0.36 0.93 50500000
+ 0.36 0.36 0.93 57571429
+ 0.36 0.36 0.93 64642857
+ 0.36 0.36 0.93 71714286
+ 0.36 0.36 0.93 78785714
+ 0.36 0.36 0.93 85857143
+ 0.36 0.36 0.93 92928571
+ 0.36 0.36 0.93 100000000
+ 0.36 0.36 1.00 1000000
+ 0.36 0.36 1.00 8071429
+ 0.36 0.36 1.00 15142857
+ 0.36 0.36 1.00 22214286
+ 0.36 0.36 1.00 29285714
+ 0.36 0.36 1.00 36357143
+ 0.36 0.36 1.00 43428571
+ 0.36 0.36 1.00 50500000
+ 0.36 0.36 1.00 57571429
+ 0.36 0.36 1.00 64642857
+ 0.36 0.36 1.00 71714286
+ 0.36 0.36 1.00 78785714
+ 0.36 0.36 1.00 85857143
+ 0.36 0.36 1.00 92928571
+ 0.36 0.36 1.00 100000000
+ 0.36 0.43 0.00 1000000
+ 0.36 0.43 0.00 8071429
+ 0.36 0.43 0.00 15142857
+ 0.36 0.43 0.00 22214286
+ 0.36 0.43 0.00 29285714
+ 0.36 0.43 0.00 36357143
+ 0.36 0.43 0.00 43428571
+ 0.36 0.43 0.00 50500000
+ 0.36 0.43 0.00 57571429
+ 0.36 0.43 0.00 64642857
+ 0.36 0.43 0.00 71714286
+ 0.36 0.43 0.00 78785714
+ 0.36 0.43 0.00 85857143
+ 0.36 0.43 0.00 92928571
+ 0.36 0.43 0.00 100000000
+ 0.36 0.43 0.07 1000000
+ 0.36 0.43 0.07 8071429
+ 0.36 0.43 0.07 15142857
+ 0.36 0.43 0.07 22214286
+ 0.36 0.43 0.07 29285714
+ 0.36 0.43 0.07 36357143
+ 0.36 0.43 0.07 43428571
+ 0.36 0.43 0.07 50500000
+ 0.36 0.43 0.07 57571429
+ 0.36 0.43 0.07 64642857
+ 0.36 0.43 0.07 71714286
+ 0.36 0.43 0.07 78785714
+ 0.36 0.43 0.07 85857143
+ 0.36 0.43 0.07 92928571
+ 0.36 0.43 0.07 100000000
+ 0.36 0.43 0.14 1000000
+ 0.36 0.43 0.14 8071429
+ 0.36 0.43 0.14 15142857
+ 0.36 0.43 0.14 22214286
+ 0.36 0.43 0.14 29285714
+ 0.36 0.43 0.14 36357143
+ 0.36 0.43 0.14 43428571
+ 0.36 0.43 0.14 50500000
+ 0.36 0.43 0.14 57571429
+ 0.36 0.43 0.14 64642857
+ 0.36 0.43 0.14 71714286
+ 0.36 0.43 0.14 78785714
+ 0.36 0.43 0.14 85857143
+ 0.36 0.43 0.14 92928571
+ 0.36 0.43 0.14 100000000
+ 0.36 0.43 0.21 1000000
+ 0.36 0.43 0.21 8071429
+ 0.36 0.43 0.21 15142857
+ 0.36 0.43 0.21 22214286
+ 0.36 0.43 0.21 29285714
+ 0.36 0.43 0.21 36357143
+ 0.36 0.43 0.21 43428571
+ 0.36 0.43 0.21 50500000
+ 0.36 0.43 0.21 57571429
+ 0.36 0.43 0.21 64642857
+ 0.36 0.43 0.21 71714286
+ 0.36 0.43 0.21 78785714
+ 0.36 0.43 0.21 85857143
+ 0.36 0.43 0.21 92928571
+ 0.36 0.43 0.21 100000000
+ 0.36 0.43 0.29 1000000
+ 0.36 0.43 0.29 8071429
+ 0.36 0.43 0.29 15142857
+ 0.36 0.43 0.29 22214286
+ 0.36 0.43 0.29 29285714
+ 0.36 0.43 0.29 36357143
+ 0.36 0.43 0.29 43428571
+ 0.36 0.43 0.29 50500000
+ 0.36 0.43 0.29 57571429
+ 0.36 0.43 0.29 64642857
+ 0.36 0.43 0.29 71714286
+ 0.36 0.43 0.29 78785714
+ 0.36 0.43 0.29 85857143
+ 0.36 0.43 0.29 92928571
+ 0.36 0.43 0.29 100000000
+ 0.36 0.43 0.36 1000000
+ 0.36 0.43 0.36 8071429
+ 0.36 0.43 0.36 15142857
+ 0.36 0.43 0.36 22214286
+ 0.36 0.43 0.36 29285714
+ 0.36 0.43 0.36 36357143
+ 0.36 0.43 0.36 43428571
+ 0.36 0.43 0.36 50500000
+ 0.36 0.43 0.36 57571429
+ 0.36 0.43 0.36 64642857
+ 0.36 0.43 0.36 71714286
+ 0.36 0.43 0.36 78785714
+ 0.36 0.43 0.36 85857143
+ 0.36 0.43 0.36 92928571
+ 0.36 0.43 0.36 100000000
+ 0.36 0.43 0.43 1000000
+ 0.36 0.43 0.43 8071429
+ 0.36 0.43 0.43 15142857
+ 0.36 0.43 0.43 22214286
+ 0.36 0.43 0.43 29285714
+ 0.36 0.43 0.43 36357143
+ 0.36 0.43 0.43 43428571
+ 0.36 0.43 0.43 50500000
+ 0.36 0.43 0.43 57571429
+ 0.36 0.43 0.43 64642857
+ 0.36 0.43 0.43 71714286
+ 0.36 0.43 0.43 78785714
+ 0.36 0.43 0.43 85857143
+ 0.36 0.43 0.43 92928571
+ 0.36 0.43 0.43 100000000
+ 0.36 0.43 0.50 1000000
+ 0.36 0.43 0.50 8071429
+ 0.36 0.43 0.50 15142857
+ 0.36 0.43 0.50 22214286
+ 0.36 0.43 0.50 29285714
+ 0.36 0.43 0.50 36357143
+ 0.36 0.43 0.50 43428571
+ 0.36 0.43 0.50 50500000
+ 0.36 0.43 0.50 57571429
+ 0.36 0.43 0.50 64642857
+ 0.36 0.43 0.50 71714286
+ 0.36 0.43 0.50 78785714
+ 0.36 0.43 0.50 85857143
+ 0.36 0.43 0.50 92928571
+ 0.36 0.43 0.50 100000000
+ 0.36 0.43 0.57 1000000
+ 0.36 0.43 0.57 8071429
+ 0.36 0.43 0.57 15142857
+ 0.36 0.43 0.57 22214286
+ 0.36 0.43 0.57 29285714
+ 0.36 0.43 0.57 36357143
+ 0.36 0.43 0.57 43428571
+ 0.36 0.43 0.57 50500000
+ 0.36 0.43 0.57 57571429
+ 0.36 0.43 0.57 64642857
+ 0.36 0.43 0.57 71714286
+ 0.36 0.43 0.57 78785714
+ 0.36 0.43 0.57 85857143
+ 0.36 0.43 0.57 92928571
+ 0.36 0.43 0.57 100000000
+ 0.36 0.43 0.64 1000000
+ 0.36 0.43 0.64 8071429
+ 0.36 0.43 0.64 15142857
+ 0.36 0.43 0.64 22214286
+ 0.36 0.43 0.64 29285714
+ 0.36 0.43 0.64 36357143
+ 0.36 0.43 0.64 43428571
+ 0.36 0.43 0.64 50500000
+ 0.36 0.43 0.64 57571429
+ 0.36 0.43 0.64 64642857
+ 0.36 0.43 0.64 71714286
+ 0.36 0.43 0.64 78785714
+ 0.36 0.43 0.64 85857143
+ 0.36 0.43 0.64 92928571
+ 0.36 0.43 0.64 100000000
+ 0.36 0.43 0.71 1000000
+ 0.36 0.43 0.71 8071429
+ 0.36 0.43 0.71 15142857
+ 0.36 0.43 0.71 22214286
+ 0.36 0.43 0.71 29285714
+ 0.36 0.43 0.71 36357143
+ 0.36 0.43 0.71 43428571
+ 0.36 0.43 0.71 50500000
+ 0.36 0.43 0.71 57571429
+ 0.36 0.43 0.71 64642857
+ 0.36 0.43 0.71 71714286
+ 0.36 0.43 0.71 78785714
+ 0.36 0.43 0.71 85857143
+ 0.36 0.43 0.71 92928571
+ 0.36 0.43 0.71 100000000
+ 0.36 0.43 0.79 1000000
+ 0.36 0.43 0.79 8071429
+ 0.36 0.43 0.79 15142857
+ 0.36 0.43 0.79 22214286
+ 0.36 0.43 0.79 29285714
+ 0.36 0.43 0.79 36357143
+ 0.36 0.43 0.79 43428571
+ 0.36 0.43 0.79 50500000
+ 0.36 0.43 0.79 57571429
+ 0.36 0.43 0.79 64642857
+ 0.36 0.43 0.79 71714286
+ 0.36 0.43 0.79 78785714
+ 0.36 0.43 0.79 85857143
+ 0.36 0.43 0.79 92928571
+ 0.36 0.43 0.79 100000000
+ 0.36 0.43 0.86 1000000
+ 0.36 0.43 0.86 8071429
+ 0.36 0.43 0.86 15142857
+ 0.36 0.43 0.86 22214286
+ 0.36 0.43 0.86 29285714
+ 0.36 0.43 0.86 36357143
+ 0.36 0.43 0.86 43428571
+ 0.36 0.43 0.86 50500000
+ 0.36 0.43 0.86 57571429
+ 0.36 0.43 0.86 64642857
+ 0.36 0.43 0.86 71714286
+ 0.36 0.43 0.86 78785714
+ 0.36 0.43 0.86 85857143
+ 0.36 0.43 0.86 92928571
+ 0.36 0.43 0.86 100000000
+ 0.36 0.43 0.93 1000000
+ 0.36 0.43 0.93 8071429
+ 0.36 0.43 0.93 15142857
+ 0.36 0.43 0.93 22214286
+ 0.36 0.43 0.93 29285714
+ 0.36 0.43 0.93 36357143
+ 0.36 0.43 0.93 43428571
+ 0.36 0.43 0.93 50500000
+ 0.36 0.43 0.93 57571429
+ 0.36 0.43 0.93 64642857
+ 0.36 0.43 0.93 71714286
+ 0.36 0.43 0.93 78785714
+ 0.36 0.43 0.93 85857143
+ 0.36 0.43 0.93 92928571
+ 0.36 0.43 0.93 100000000
+ 0.36 0.43 1.00 1000000
+ 0.36 0.43 1.00 8071429
+ 0.36 0.43 1.00 15142857
+ 0.36 0.43 1.00 22214286
+ 0.36 0.43 1.00 29285714
+ 0.36 0.43 1.00 36357143
+ 0.36 0.43 1.00 43428571
+ 0.36 0.43 1.00 50500000
+ 0.36 0.43 1.00 57571429
+ 0.36 0.43 1.00 64642857
+ 0.36 0.43 1.00 71714286
+ 0.36 0.43 1.00 78785714
+ 0.36 0.43 1.00 85857143
+ 0.36 0.43 1.00 92928571
+ 0.36 0.43 1.00 100000000
+ 0.36 0.50 0.00 1000000
+ 0.36 0.50 0.00 8071429
+ 0.36 0.50 0.00 15142857
+ 0.36 0.50 0.00 22214286
+ 0.36 0.50 0.00 29285714
+ 0.36 0.50 0.00 36357143
+ 0.36 0.50 0.00 43428571
+ 0.36 0.50 0.00 50500000
+ 0.36 0.50 0.00 57571429
+ 0.36 0.50 0.00 64642857
+ 0.36 0.50 0.00 71714286
+ 0.36 0.50 0.00 78785714
+ 0.36 0.50 0.00 85857143
+ 0.36 0.50 0.00 92928571
+ 0.36 0.50 0.00 100000000
+ 0.36 0.50 0.07 1000000
+ 0.36 0.50 0.07 8071429
+ 0.36 0.50 0.07 15142857
+ 0.36 0.50 0.07 22214286
+ 0.36 0.50 0.07 29285714
+ 0.36 0.50 0.07 36357143
+ 0.36 0.50 0.07 43428571
+ 0.36 0.50 0.07 50500000
+ 0.36 0.50 0.07 57571429
+ 0.36 0.50 0.07 64642857
+ 0.36 0.50 0.07 71714286
+ 0.36 0.50 0.07 78785714
+ 0.36 0.50 0.07 85857143
+ 0.36 0.50 0.07 92928571
+ 0.36 0.50 0.07 100000000
+ 0.36 0.50 0.14 1000000
+ 0.36 0.50 0.14 8071429
+ 0.36 0.50 0.14 15142857
+ 0.36 0.50 0.14 22214286
+ 0.36 0.50 0.14 29285714
+ 0.36 0.50 0.14 36357143
+ 0.36 0.50 0.14 43428571
+ 0.36 0.50 0.14 50500000
+ 0.36 0.50 0.14 57571429
+ 0.36 0.50 0.14 64642857
+ 0.36 0.50 0.14 71714286
+ 0.36 0.50 0.14 78785714
+ 0.36 0.50 0.14 85857143
+ 0.36 0.50 0.14 92928571
+ 0.36 0.50 0.14 100000000
+ 0.36 0.50 0.21 1000000
+ 0.36 0.50 0.21 8071429
+ 0.36 0.50 0.21 15142857
+ 0.36 0.50 0.21 22214286
+ 0.36 0.50 0.21 29285714
+ 0.36 0.50 0.21 36357143
+ 0.36 0.50 0.21 43428571
+ 0.36 0.50 0.21 50500000
+ 0.36 0.50 0.21 57571429
+ 0.36 0.50 0.21 64642857
+ 0.36 0.50 0.21 71714286
+ 0.36 0.50 0.21 78785714
+ 0.36 0.50 0.21 85857143
+ 0.36 0.50 0.21 92928571
+ 0.36 0.50 0.21 100000000
+ 0.36 0.50 0.29 1000000
+ 0.36 0.50 0.29 8071429
+ 0.36 0.50 0.29 15142857
+ 0.36 0.50 0.29 22214286
+ 0.36 0.50 0.29 29285714
+ 0.36 0.50 0.29 36357143
+ 0.36 0.50 0.29 43428571
+ 0.36 0.50 0.29 50500000
+ 0.36 0.50 0.29 57571429
+ 0.36 0.50 0.29 64642857
+ 0.36 0.50 0.29 71714286
+ 0.36 0.50 0.29 78785714
+ 0.36 0.50 0.29 85857143
+ 0.36 0.50 0.29 92928571
+ 0.36 0.50 0.29 100000000
+ 0.36 0.50 0.36 1000000
+ 0.36 0.50 0.36 8071429
+ 0.36 0.50 0.36 15142857
+ 0.36 0.50 0.36 22214286
+ 0.36 0.50 0.36 29285714
+ 0.36 0.50 0.36 36357143
+ 0.36 0.50 0.36 43428571
+ 0.36 0.50 0.36 50500000
+ 0.36 0.50 0.36 57571429
+ 0.36 0.50 0.36 64642857
+ 0.36 0.50 0.36 71714286
+ 0.36 0.50 0.36 78785714
+ 0.36 0.50 0.36 85857143
+ 0.36 0.50 0.36 92928571
+ 0.36 0.50 0.36 100000000
+ 0.36 0.50 0.43 1000000
+ 0.36 0.50 0.43 8071429
+ 0.36 0.50 0.43 15142857
+ 0.36 0.50 0.43 22214286
+ 0.36 0.50 0.43 29285714
+ 0.36 0.50 0.43 36357143
+ 0.36 0.50 0.43 43428571
+ 0.36 0.50 0.43 50500000
+ 0.36 0.50 0.43 57571429
+ 0.36 0.50 0.43 64642857
+ 0.36 0.50 0.43 71714286
+ 0.36 0.50 0.43 78785714
+ 0.36 0.50 0.43 85857143
+ 0.36 0.50 0.43 92928571
+ 0.36 0.50 0.43 100000000
+ 0.36 0.50 0.50 1000000
+ 0.36 0.50 0.50 8071429
+ 0.36 0.50 0.50 15142857
+ 0.36 0.50 0.50 22214286
+ 0.36 0.50 0.50 29285714
+ 0.36 0.50 0.50 36357143
+ 0.36 0.50 0.50 43428571
+ 0.36 0.50 0.50 50500000
+ 0.36 0.50 0.50 57571429
+ 0.36 0.50 0.50 64642857
+ 0.36 0.50 0.50 71714286
+ 0.36 0.50 0.50 78785714
+ 0.36 0.50 0.50 85857143
+ 0.36 0.50 0.50 92928571
+ 0.36 0.50 0.50 100000000
+ 0.36 0.50 0.57 1000000
+ 0.36 0.50 0.57 8071429
+ 0.36 0.50 0.57 15142857
+ 0.36 0.50 0.57 22214286
+ 0.36 0.50 0.57 29285714
+ 0.36 0.50 0.57 36357143
+ 0.36 0.50 0.57 43428571
+ 0.36 0.50 0.57 50500000
+ 0.36 0.50 0.57 57571429
+ 0.36 0.50 0.57 64642857
+ 0.36 0.50 0.57 71714286
+ 0.36 0.50 0.57 78785714
+ 0.36 0.50 0.57 85857143
+ 0.36 0.50 0.57 92928571
+ 0.36 0.50 0.57 100000000
+ 0.36 0.50 0.64 1000000
+ 0.36 0.50 0.64 8071429
+ 0.36 0.50 0.64 15142857
+ 0.36 0.50 0.64 22214286
+ 0.36 0.50 0.64 29285714
+ 0.36 0.50 0.64 36357143
+ 0.36 0.50 0.64 43428571
+ 0.36 0.50 0.64 50500000
+ 0.36 0.50 0.64 57571429
+ 0.36 0.50 0.64 64642857
+ 0.36 0.50 0.64 71714286
+ 0.36 0.50 0.64 78785714
+ 0.36 0.50 0.64 85857143
+ 0.36 0.50 0.64 92928571
+ 0.36 0.50 0.64 100000000
+ 0.36 0.50 0.71 1000000
+ 0.36 0.50 0.71 8071429
+ 0.36 0.50 0.71 15142857
+ 0.36 0.50 0.71 22214286
+ 0.36 0.50 0.71 29285714
+ 0.36 0.50 0.71 36357143
+ 0.36 0.50 0.71 43428571
+ 0.36 0.50 0.71 50500000
+ 0.36 0.50 0.71 57571429
+ 0.36 0.50 0.71 64642857
+ 0.36 0.50 0.71 71714286
+ 0.36 0.50 0.71 78785714
+ 0.36 0.50 0.71 85857143
+ 0.36 0.50 0.71 92928571
+ 0.36 0.50 0.71 100000000
+ 0.36 0.50 0.79 1000000
+ 0.36 0.50 0.79 8071429
+ 0.36 0.50 0.79 15142857
+ 0.36 0.50 0.79 22214286
+ 0.36 0.50 0.79 29285714
+ 0.36 0.50 0.79 36357143
+ 0.36 0.50 0.79 43428571
+ 0.36 0.50 0.79 50500000
+ 0.36 0.50 0.79 57571429
+ 0.36 0.50 0.79 64642857
+ 0.36 0.50 0.79 71714286
+ 0.36 0.50 0.79 78785714
+ 0.36 0.50 0.79 85857143
+ 0.36 0.50 0.79 92928571
+ 0.36 0.50 0.79 100000000
+ 0.36 0.50 0.86 1000000
+ 0.36 0.50 0.86 8071429
+ 0.36 0.50 0.86 15142857
+ 0.36 0.50 0.86 22214286
+ 0.36 0.50 0.86 29285714
+ 0.36 0.50 0.86 36357143
+ 0.36 0.50 0.86 43428571
+ 0.36 0.50 0.86 50500000
+ 0.36 0.50 0.86 57571429
+ 0.36 0.50 0.86 64642857
+ 0.36 0.50 0.86 71714286
+ 0.36 0.50 0.86 78785714
+ 0.36 0.50 0.86 85857143
+ 0.36 0.50 0.86 92928571
+ 0.36 0.50 0.86 100000000
+ 0.36 0.50 0.93 1000000
+ 0.36 0.50 0.93 8071429
+ 0.36 0.50 0.93 15142857
+ 0.36 0.50 0.93 22214286
+ 0.36 0.50 0.93 29285714
+ 0.36 0.50 0.93 36357143
+ 0.36 0.50 0.93 43428571
+ 0.36 0.50 0.93 50500000
+ 0.36 0.50 0.93 57571429
+ 0.36 0.50 0.93 64642857
+ 0.36 0.50 0.93 71714286
+ 0.36 0.50 0.93 78785714
+ 0.36 0.50 0.93 85857143
+ 0.36 0.50 0.93 92928571
+ 0.36 0.50 0.93 100000000
+ 0.36 0.50 1.00 1000000
+ 0.36 0.50 1.00 8071429
+ 0.36 0.50 1.00 15142857
+ 0.36 0.50 1.00 22214286
+ 0.36 0.50 1.00 29285714
+ 0.36 0.50 1.00 36357143
+ 0.36 0.50 1.00 43428571
+ 0.36 0.50 1.00 50500000
+ 0.36 0.50 1.00 57571429
+ 0.36 0.50 1.00 64642857
+ 0.36 0.50 1.00 71714286
+ 0.36 0.50 1.00 78785714
+ 0.36 0.50 1.00 85857143
+ 0.36 0.50 1.00 92928571
+ 0.36 0.50 1.00 100000000
+ 0.36 0.57 0.00 1000000
+ 0.36 0.57 0.00 8071429
+ 0.36 0.57 0.00 15142857
+ 0.36 0.57 0.00 22214286
+ 0.36 0.57 0.00 29285714
+ 0.36 0.57 0.00 36357143
+ 0.36 0.57 0.00 43428571
+ 0.36 0.57 0.00 50500000
+ 0.36 0.57 0.00 57571429
+ 0.36 0.57 0.00 64642857
+ 0.36 0.57 0.00 71714286
+ 0.36 0.57 0.00 78785714
+ 0.36 0.57 0.00 85857143
+ 0.36 0.57 0.00 92928571
+ 0.36 0.57 0.00 100000000
+ 0.36 0.57 0.07 1000000
+ 0.36 0.57 0.07 8071429
+ 0.36 0.57 0.07 15142857
+ 0.36 0.57 0.07 22214286
+ 0.36 0.57 0.07 29285714
+ 0.36 0.57 0.07 36357143
+ 0.36 0.57 0.07 43428571
+ 0.36 0.57 0.07 50500000
+ 0.36 0.57 0.07 57571429
+ 0.36 0.57 0.07 64642857
+ 0.36 0.57 0.07 71714286
+ 0.36 0.57 0.07 78785714
+ 0.36 0.57 0.07 85857143
+ 0.36 0.57 0.07 92928571
+ 0.36 0.57 0.07 100000000
+ 0.36 0.57 0.14 1000000
+ 0.36 0.57 0.14 8071429
+ 0.36 0.57 0.14 15142857
+ 0.36 0.57 0.14 22214286
+ 0.36 0.57 0.14 29285714
+ 0.36 0.57 0.14 36357143
+ 0.36 0.57 0.14 43428571
+ 0.36 0.57 0.14 50500000
+ 0.36 0.57 0.14 57571429
+ 0.36 0.57 0.14 64642857
+ 0.36 0.57 0.14 71714286
+ 0.36 0.57 0.14 78785714
+ 0.36 0.57 0.14 85857143
+ 0.36 0.57 0.14 92928571
+ 0.36 0.57 0.14 100000000
+ 0.36 0.57 0.21 1000000
+ 0.36 0.57 0.21 8071429
+ 0.36 0.57 0.21 15142857
+ 0.36 0.57 0.21 22214286
+ 0.36 0.57 0.21 29285714
+ 0.36 0.57 0.21 36357143
+ 0.36 0.57 0.21 43428571
+ 0.36 0.57 0.21 50500000
+ 0.36 0.57 0.21 57571429
+ 0.36 0.57 0.21 64642857
+ 0.36 0.57 0.21 71714286
+ 0.36 0.57 0.21 78785714
+ 0.36 0.57 0.21 85857143
+ 0.36 0.57 0.21 92928571
+ 0.36 0.57 0.21 100000000
+ 0.36 0.57 0.29 1000000
+ 0.36 0.57 0.29 8071429
+ 0.36 0.57 0.29 15142857
+ 0.36 0.57 0.29 22214286
+ 0.36 0.57 0.29 29285714
+ 0.36 0.57 0.29 36357143
+ 0.36 0.57 0.29 43428571
+ 0.36 0.57 0.29 50500000
+ 0.36 0.57 0.29 57571429
+ 0.36 0.57 0.29 64642857
+ 0.36 0.57 0.29 71714286
+ 0.36 0.57 0.29 78785714
+ 0.36 0.57 0.29 85857143
+ 0.36 0.57 0.29 92928571
+ 0.36 0.57 0.29 100000000
+ 0.36 0.57 0.36 1000000
+ 0.36 0.57 0.36 8071429
+ 0.36 0.57 0.36 15142857
+ 0.36 0.57 0.36 22214286
+ 0.36 0.57 0.36 29285714
+ 0.36 0.57 0.36 36357143
+ 0.36 0.57 0.36 43428571
+ 0.36 0.57 0.36 50500000
+ 0.36 0.57 0.36 57571429
+ 0.36 0.57 0.36 64642857
+ 0.36 0.57 0.36 71714286
+ 0.36 0.57 0.36 78785714
+ 0.36 0.57 0.36 85857143
+ 0.36 0.57 0.36 92928571
+ 0.36 0.57 0.36 100000000
+ 0.36 0.57 0.43 1000000
+ 0.36 0.57 0.43 8071429
+ 0.36 0.57 0.43 15142857
+ 0.36 0.57 0.43 22214286
+ 0.36 0.57 0.43 29285714
+ 0.36 0.57 0.43 36357143
+ 0.36 0.57 0.43 43428571
+ 0.36 0.57 0.43 50500000
+ 0.36 0.57 0.43 57571429
+ 0.36 0.57 0.43 64642857
+ 0.36 0.57 0.43 71714286
+ 0.36 0.57 0.43 78785714
+ 0.36 0.57 0.43 85857143
+ 0.36 0.57 0.43 92928571
+ 0.36 0.57 0.43 100000000
+ 0.36 0.57 0.50 1000000
+ 0.36 0.57 0.50 8071429
+ 0.36 0.57 0.50 15142857
+ 0.36 0.57 0.50 22214286
+ 0.36 0.57 0.50 29285714
+ 0.36 0.57 0.50 36357143
+ 0.36 0.57 0.50 43428571
+ 0.36 0.57 0.50 50500000
+ 0.36 0.57 0.50 57571429
+ 0.36 0.57 0.50 64642857
+ 0.36 0.57 0.50 71714286
+ 0.36 0.57 0.50 78785714
+ 0.36 0.57 0.50 85857143
+ 0.36 0.57 0.50 92928571
+ 0.36 0.57 0.50 100000000
+ 0.36 0.57 0.57 1000000
+ 0.36 0.57 0.57 8071429
+ 0.36 0.57 0.57 15142857
+ 0.36 0.57 0.57 22214286
+ 0.36 0.57 0.57 29285714
+ 0.36 0.57 0.57 36357143
+ 0.36 0.57 0.57 43428571
+ 0.36 0.57 0.57 50500000
+ 0.36 0.57 0.57 57571429
+ 0.36 0.57 0.57 64642857
+ 0.36 0.57 0.57 71714286
+ 0.36 0.57 0.57 78785714
+ 0.36 0.57 0.57 85857143
+ 0.36 0.57 0.57 92928571
+ 0.36 0.57 0.57 100000000
+ 0.36 0.57 0.64 1000000
+ 0.36 0.57 0.64 8071429
+ 0.36 0.57 0.64 15142857
+ 0.36 0.57 0.64 22214286
+ 0.36 0.57 0.64 29285714
+ 0.36 0.57 0.64 36357143
+ 0.36 0.57 0.64 43428571
+ 0.36 0.57 0.64 50500000
+ 0.36 0.57 0.64 57571429
+ 0.36 0.57 0.64 64642857
+ 0.36 0.57 0.64 71714286
+ 0.36 0.57 0.64 78785714
+ 0.36 0.57 0.64 85857143
+ 0.36 0.57 0.64 92928571
+ 0.36 0.57 0.64 100000000
+ 0.36 0.57 0.71 1000000
+ 0.36 0.57 0.71 8071429
+ 0.36 0.57 0.71 15142857
+ 0.36 0.57 0.71 22214286
+ 0.36 0.57 0.71 29285714
+ 0.36 0.57 0.71 36357143
+ 0.36 0.57 0.71 43428571
+ 0.36 0.57 0.71 50500000
+ 0.36 0.57 0.71 57571429
+ 0.36 0.57 0.71 64642857
+ 0.36 0.57 0.71 71714286
+ 0.36 0.57 0.71 78785714
+ 0.36 0.57 0.71 85857143
+ 0.36 0.57 0.71 92928571
+ 0.36 0.57 0.71 100000000
+ 0.36 0.57 0.79 1000000
+ 0.36 0.57 0.79 8071429
+ 0.36 0.57 0.79 15142857
+ 0.36 0.57 0.79 22214286
+ 0.36 0.57 0.79 29285714
+ 0.36 0.57 0.79 36357143
+ 0.36 0.57 0.79 43428571
+ 0.36 0.57 0.79 50500000
+ 0.36 0.57 0.79 57571429
+ 0.36 0.57 0.79 64642857
+ 0.36 0.57 0.79 71714286
+ 0.36 0.57 0.79 78785714
+ 0.36 0.57 0.79 85857143
+ 0.36 0.57 0.79 92928571
+ 0.36 0.57 0.79 100000000
+ 0.36 0.57 0.86 1000000
+ 0.36 0.57 0.86 8071429
+ 0.36 0.57 0.86 15142857
+ 0.36 0.57 0.86 22214286
+ 0.36 0.57 0.86 29285714
+ 0.36 0.57 0.86 36357143
+ 0.36 0.57 0.86 43428571
+ 0.36 0.57 0.86 50500000
+ 0.36 0.57 0.86 57571429
+ 0.36 0.57 0.86 64642857
+ 0.36 0.57 0.86 71714286
+ 0.36 0.57 0.86 78785714
+ 0.36 0.57 0.86 85857143
+ 0.36 0.57 0.86 92928571
+ 0.36 0.57 0.86 100000000
+ 0.36 0.57 0.93 1000000
+ 0.36 0.57 0.93 8071429
+ 0.36 0.57 0.93 15142857
+ 0.36 0.57 0.93 22214286
+ 0.36 0.57 0.93 29285714
+ 0.36 0.57 0.93 36357143
+ 0.36 0.57 0.93 43428571
+ 0.36 0.57 0.93 50500000
+ 0.36 0.57 0.93 57571429
+ 0.36 0.57 0.93 64642857
+ 0.36 0.57 0.93 71714286
+ 0.36 0.57 0.93 78785714
+ 0.36 0.57 0.93 85857143
+ 0.36 0.57 0.93 92928571
+ 0.36 0.57 0.93 100000000
+ 0.36 0.57 1.00 1000000
+ 0.36 0.57 1.00 8071429
+ 0.36 0.57 1.00 15142857
+ 0.36 0.57 1.00 22214286
+ 0.36 0.57 1.00 29285714
+ 0.36 0.57 1.00 36357143
+ 0.36 0.57 1.00 43428571
+ 0.36 0.57 1.00 50500000
+ 0.36 0.57 1.00 57571429
+ 0.36 0.57 1.00 64642857
+ 0.36 0.57 1.00 71714286
+ 0.36 0.57 1.00 78785714
+ 0.36 0.57 1.00 85857143
+ 0.36 0.57 1.00 92928571
+ 0.36 0.57 1.00 100000000
+ 0.36 0.64 0.00 1000000
+ 0.36 0.64 0.00 8071429
+ 0.36 0.64 0.00 15142857
+ 0.36 0.64 0.00 22214286
+ 0.36 0.64 0.00 29285714
+ 0.36 0.64 0.00 36357143
+ 0.36 0.64 0.00 43428571
+ 0.36 0.64 0.00 50500000
+ 0.36 0.64 0.00 57571429
+ 0.36 0.64 0.00 64642857
+ 0.36 0.64 0.00 71714286
+ 0.36 0.64 0.00 78785714
+ 0.36 0.64 0.00 85857143
+ 0.36 0.64 0.00 92928571
+ 0.36 0.64 0.00 100000000
+ 0.36 0.64 0.07 1000000
+ 0.36 0.64 0.07 8071429
+ 0.36 0.64 0.07 15142857
+ 0.36 0.64 0.07 22214286
+ 0.36 0.64 0.07 29285714
+ 0.36 0.64 0.07 36357143
+ 0.36 0.64 0.07 43428571
+ 0.36 0.64 0.07 50500000
+ 0.36 0.64 0.07 57571429
+ 0.36 0.64 0.07 64642857
+ 0.36 0.64 0.07 71714286
+ 0.36 0.64 0.07 78785714
+ 0.36 0.64 0.07 85857143
+ 0.36 0.64 0.07 92928571
+ 0.36 0.64 0.07 100000000
+ 0.36 0.64 0.14 1000000
+ 0.36 0.64 0.14 8071429
+ 0.36 0.64 0.14 15142857
+ 0.36 0.64 0.14 22214286
+ 0.36 0.64 0.14 29285714
+ 0.36 0.64 0.14 36357143
+ 0.36 0.64 0.14 43428571
+ 0.36 0.64 0.14 50500000
+ 0.36 0.64 0.14 57571429
+ 0.36 0.64 0.14 64642857
+ 0.36 0.64 0.14 71714286
+ 0.36 0.64 0.14 78785714
+ 0.36 0.64 0.14 85857143
+ 0.36 0.64 0.14 92928571
+ 0.36 0.64 0.14 100000000
+ 0.36 0.64 0.21 1000000
+ 0.36 0.64 0.21 8071429
+ 0.36 0.64 0.21 15142857
+ 0.36 0.64 0.21 22214286
+ 0.36 0.64 0.21 29285714
+ 0.36 0.64 0.21 36357143
+ 0.36 0.64 0.21 43428571
+ 0.36 0.64 0.21 50500000
+ 0.36 0.64 0.21 57571429
+ 0.36 0.64 0.21 64642857
+ 0.36 0.64 0.21 71714286
+ 0.36 0.64 0.21 78785714
+ 0.36 0.64 0.21 85857143
+ 0.36 0.64 0.21 92928571
+ 0.36 0.64 0.21 100000000
+ 0.36 0.64 0.29 1000000
+ 0.36 0.64 0.29 8071429
+ 0.36 0.64 0.29 15142857
+ 0.36 0.64 0.29 22214286
+ 0.36 0.64 0.29 29285714
+ 0.36 0.64 0.29 36357143
+ 0.36 0.64 0.29 43428571
+ 0.36 0.64 0.29 50500000
+ 0.36 0.64 0.29 57571429
+ 0.36 0.64 0.29 64642857
+ 0.36 0.64 0.29 71714286
+ 0.36 0.64 0.29 78785714
+ 0.36 0.64 0.29 85857143
+ 0.36 0.64 0.29 92928571
+ 0.36 0.64 0.29 100000000
+ 0.36 0.64 0.36 1000000
+ 0.36 0.64 0.36 8071429
+ 0.36 0.64 0.36 15142857
+ 0.36 0.64 0.36 22214286
+ 0.36 0.64 0.36 29285714
+ 0.36 0.64 0.36 36357143
+ 0.36 0.64 0.36 43428571
+ 0.36 0.64 0.36 50500000
+ 0.36 0.64 0.36 57571429
+ 0.36 0.64 0.36 64642857
+ 0.36 0.64 0.36 71714286
+ 0.36 0.64 0.36 78785714
+ 0.36 0.64 0.36 85857143
+ 0.36 0.64 0.36 92928571
+ 0.36 0.64 0.36 100000000
+ 0.36 0.64 0.43 1000000
+ 0.36 0.64 0.43 8071429
+ 0.36 0.64 0.43 15142857
+ 0.36 0.64 0.43 22214286
+ 0.36 0.64 0.43 29285714
+ 0.36 0.64 0.43 36357143
+ 0.36 0.64 0.43 43428571
+ 0.36 0.64 0.43 50500000
+ 0.36 0.64 0.43 57571429
+ 0.36 0.64 0.43 64642857
+ 0.36 0.64 0.43 71714286
+ 0.36 0.64 0.43 78785714
+ 0.36 0.64 0.43 85857143
+ 0.36 0.64 0.43 92928571
+ 0.36 0.64 0.43 100000000
+ 0.36 0.64 0.50 1000000
+ 0.36 0.64 0.50 8071429
+ 0.36 0.64 0.50 15142857
+ 0.36 0.64 0.50 22214286
+ 0.36 0.64 0.50 29285714
+ 0.36 0.64 0.50 36357143
+ 0.36 0.64 0.50 43428571
+ 0.36 0.64 0.50 50500000
+ 0.36 0.64 0.50 57571429
+ 0.36 0.64 0.50 64642857
+ 0.36 0.64 0.50 71714286
+ 0.36 0.64 0.50 78785714
+ 0.36 0.64 0.50 85857143
+ 0.36 0.64 0.50 92928571
+ 0.36 0.64 0.50 100000000
+ 0.36 0.64 0.57 1000000
+ 0.36 0.64 0.57 8071429
+ 0.36 0.64 0.57 15142857
+ 0.36 0.64 0.57 22214286
+ 0.36 0.64 0.57 29285714
+ 0.36 0.64 0.57 36357143
+ 0.36 0.64 0.57 43428571
+ 0.36 0.64 0.57 50500000
+ 0.36 0.64 0.57 57571429
+ 0.36 0.64 0.57 64642857
+ 0.36 0.64 0.57 71714286
+ 0.36 0.64 0.57 78785714
+ 0.36 0.64 0.57 85857143
+ 0.36 0.64 0.57 92928571
+ 0.36 0.64 0.57 100000000
+ 0.36 0.64 0.64 1000000
+ 0.36 0.64 0.64 8071429
+ 0.36 0.64 0.64 15142857
+ 0.36 0.64 0.64 22214286
+ 0.36 0.64 0.64 29285714
+ 0.36 0.64 0.64 36357143
+ 0.36 0.64 0.64 43428571
+ 0.36 0.64 0.64 50500000
+ 0.36 0.64 0.64 57571429
+ 0.36 0.64 0.64 64642857
+ 0.36 0.64 0.64 71714286
+ 0.36 0.64 0.64 78785714
+ 0.36 0.64 0.64 85857143
+ 0.36 0.64 0.64 92928571
+ 0.36 0.64 0.64 100000000
+ 0.36 0.64 0.71 1000000
+ 0.36 0.64 0.71 8071429
+ 0.36 0.64 0.71 15142857
+ 0.36 0.64 0.71 22214286
+ 0.36 0.64 0.71 29285714
+ 0.36 0.64 0.71 36357143
+ 0.36 0.64 0.71 43428571
+ 0.36 0.64 0.71 50500000
+ 0.36 0.64 0.71 57571429
+ 0.36 0.64 0.71 64642857
+ 0.36 0.64 0.71 71714286
+ 0.36 0.64 0.71 78785714
+ 0.36 0.64 0.71 85857143
+ 0.36 0.64 0.71 92928571
+ 0.36 0.64 0.71 100000000
+ 0.36 0.64 0.79 1000000
+ 0.36 0.64 0.79 8071429
+ 0.36 0.64 0.79 15142857
+ 0.36 0.64 0.79 22214286
+ 0.36 0.64 0.79 29285714
+ 0.36 0.64 0.79 36357143
+ 0.36 0.64 0.79 43428571
+ 0.36 0.64 0.79 50500000
+ 0.36 0.64 0.79 57571429
+ 0.36 0.64 0.79 64642857
+ 0.36 0.64 0.79 71714286
+ 0.36 0.64 0.79 78785714
+ 0.36 0.64 0.79 85857143
+ 0.36 0.64 0.79 92928571
+ 0.36 0.64 0.79 100000000
+ 0.36 0.64 0.86 1000000
+ 0.36 0.64 0.86 8071429
+ 0.36 0.64 0.86 15142857
+ 0.36 0.64 0.86 22214286
+ 0.36 0.64 0.86 29285714
+ 0.36 0.64 0.86 36357143
+ 0.36 0.64 0.86 43428571
+ 0.36 0.64 0.86 50500000
+ 0.36 0.64 0.86 57571429
+ 0.36 0.64 0.86 64642857
+ 0.36 0.64 0.86 71714286
+ 0.36 0.64 0.86 78785714
+ 0.36 0.64 0.86 85857143
+ 0.36 0.64 0.86 92928571
+ 0.36 0.64 0.86 100000000
+ 0.36 0.64 0.93 1000000
+ 0.36 0.64 0.93 8071429
+ 0.36 0.64 0.93 15142857
+ 0.36 0.64 0.93 22214286
+ 0.36 0.64 0.93 29285714
+ 0.36 0.64 0.93 36357143
+ 0.36 0.64 0.93 43428571
+ 0.36 0.64 0.93 50500000
+ 0.36 0.64 0.93 57571429
+ 0.36 0.64 0.93 64642857
+ 0.36 0.64 0.93 71714286
+ 0.36 0.64 0.93 78785714
+ 0.36 0.64 0.93 85857143
+ 0.36 0.64 0.93 92928571
+ 0.36 0.64 0.93 100000000
+ 0.36 0.64 1.00 1000000
+ 0.36 0.64 1.00 8071429
+ 0.36 0.64 1.00 15142857
+ 0.36 0.64 1.00 22214286
+ 0.36 0.64 1.00 29285714
+ 0.36 0.64 1.00 36357143
+ 0.36 0.64 1.00 43428571
+ 0.36 0.64 1.00 50500000
+ 0.36 0.64 1.00 57571429
+ 0.36 0.64 1.00 64642857
+ 0.36 0.64 1.00 71714286
+ 0.36 0.64 1.00 78785714
+ 0.36 0.64 1.00 85857143
+ 0.36 0.64 1.00 92928571
+ 0.36 0.64 1.00 100000000
+ 0.36 0.71 0.00 1000000
+ 0.36 0.71 0.00 8071429
+ 0.36 0.71 0.00 15142857
+ 0.36 0.71 0.00 22214286
+ 0.36 0.71 0.00 29285714
+ 0.36 0.71 0.00 36357143
+ 0.36 0.71 0.00 43428571
+ 0.36 0.71 0.00 50500000
+ 0.36 0.71 0.00 57571429
+ 0.36 0.71 0.00 64642857
+ 0.36 0.71 0.00 71714286
+ 0.36 0.71 0.00 78785714
+ 0.36 0.71 0.00 85857143
+ 0.36 0.71 0.00 92928571
+ 0.36 0.71 0.00 100000000
+ 0.36 0.71 0.07 1000000
+ 0.36 0.71 0.07 8071429
+ 0.36 0.71 0.07 15142857
+ 0.36 0.71 0.07 22214286
+ 0.36 0.71 0.07 29285714
+ 0.36 0.71 0.07 36357143
+ 0.36 0.71 0.07 43428571
+ 0.36 0.71 0.07 50500000
+ 0.36 0.71 0.07 57571429
+ 0.36 0.71 0.07 64642857
+ 0.36 0.71 0.07 71714286
+ 0.36 0.71 0.07 78785714
+ 0.36 0.71 0.07 85857143
+ 0.36 0.71 0.07 92928571
+ 0.36 0.71 0.07 100000000
+ 0.36 0.71 0.14 1000000
+ 0.36 0.71 0.14 8071429
+ 0.36 0.71 0.14 15142857
+ 0.36 0.71 0.14 22214286
+ 0.36 0.71 0.14 29285714
+ 0.36 0.71 0.14 36357143
+ 0.36 0.71 0.14 43428571
+ 0.36 0.71 0.14 50500000
+ 0.36 0.71 0.14 57571429
+ 0.36 0.71 0.14 64642857
+ 0.36 0.71 0.14 71714286
+ 0.36 0.71 0.14 78785714
+ 0.36 0.71 0.14 85857143
+ 0.36 0.71 0.14 92928571
+ 0.36 0.71 0.14 100000000
+ 0.36 0.71 0.21 1000000
+ 0.36 0.71 0.21 8071429
+ 0.36 0.71 0.21 15142857
+ 0.36 0.71 0.21 22214286
+ 0.36 0.71 0.21 29285714
+ 0.36 0.71 0.21 36357143
+ 0.36 0.71 0.21 43428571
+ 0.36 0.71 0.21 50500000
+ 0.36 0.71 0.21 57571429
+ 0.36 0.71 0.21 64642857
+ 0.36 0.71 0.21 71714286
+ 0.36 0.71 0.21 78785714
+ 0.36 0.71 0.21 85857143
+ 0.36 0.71 0.21 92928571
+ 0.36 0.71 0.21 100000000
+ 0.36 0.71 0.29 1000000
+ 0.36 0.71 0.29 8071429
+ 0.36 0.71 0.29 15142857
+ 0.36 0.71 0.29 22214286
+ 0.36 0.71 0.29 29285714
+ 0.36 0.71 0.29 36357143
+ 0.36 0.71 0.29 43428571
+ 0.36 0.71 0.29 50500000
+ 0.36 0.71 0.29 57571429
+ 0.36 0.71 0.29 64642857
+ 0.36 0.71 0.29 71714286
+ 0.36 0.71 0.29 78785714
+ 0.36 0.71 0.29 85857143
+ 0.36 0.71 0.29 92928571
+ 0.36 0.71 0.29 100000000
+ 0.36 0.71 0.36 1000000
+ 0.36 0.71 0.36 8071429
+ 0.36 0.71 0.36 15142857
+ 0.36 0.71 0.36 22214286
+ 0.36 0.71 0.36 29285714
+ 0.36 0.71 0.36 36357143
+ 0.36 0.71 0.36 43428571
+ 0.36 0.71 0.36 50500000
+ 0.36 0.71 0.36 57571429
+ 0.36 0.71 0.36 64642857
+ 0.36 0.71 0.36 71714286
+ 0.36 0.71 0.36 78785714
+ 0.36 0.71 0.36 85857143
+ 0.36 0.71 0.36 92928571
+ 0.36 0.71 0.36 100000000
+ 0.36 0.71 0.43 1000000
+ 0.36 0.71 0.43 8071429
+ 0.36 0.71 0.43 15142857
+ 0.36 0.71 0.43 22214286
+ 0.36 0.71 0.43 29285714
+ 0.36 0.71 0.43 36357143
+ 0.36 0.71 0.43 43428571
+ 0.36 0.71 0.43 50500000
+ 0.36 0.71 0.43 57571429
+ 0.36 0.71 0.43 64642857
+ 0.36 0.71 0.43 71714286
+ 0.36 0.71 0.43 78785714
+ 0.36 0.71 0.43 85857143
+ 0.36 0.71 0.43 92928571
+ 0.36 0.71 0.43 100000000
+ 0.36 0.71 0.50 1000000
+ 0.36 0.71 0.50 8071429
+ 0.36 0.71 0.50 15142857
+ 0.36 0.71 0.50 22214286
+ 0.36 0.71 0.50 29285714
+ 0.36 0.71 0.50 36357143
+ 0.36 0.71 0.50 43428571
+ 0.36 0.71 0.50 50500000
+ 0.36 0.71 0.50 57571429
+ 0.36 0.71 0.50 64642857
+ 0.36 0.71 0.50 71714286
+ 0.36 0.71 0.50 78785714
+ 0.36 0.71 0.50 85857143
+ 0.36 0.71 0.50 92928571
+ 0.36 0.71 0.50 100000000
+ 0.36 0.71 0.57 1000000
+ 0.36 0.71 0.57 8071429
+ 0.36 0.71 0.57 15142857
+ 0.36 0.71 0.57 22214286
+ 0.36 0.71 0.57 29285714
+ 0.36 0.71 0.57 36357143
+ 0.36 0.71 0.57 43428571
+ 0.36 0.71 0.57 50500000
+ 0.36 0.71 0.57 57571429
+ 0.36 0.71 0.57 64642857
+ 0.36 0.71 0.57 71714286
+ 0.36 0.71 0.57 78785714
+ 0.36 0.71 0.57 85857143
+ 0.36 0.71 0.57 92928571
+ 0.36 0.71 0.57 100000000
+ 0.36 0.71 0.64 1000000
+ 0.36 0.71 0.64 8071429
+ 0.36 0.71 0.64 15142857
+ 0.36 0.71 0.64 22214286
+ 0.36 0.71 0.64 29285714
+ 0.36 0.71 0.64 36357143
+ 0.36 0.71 0.64 43428571
+ 0.36 0.71 0.64 50500000
+ 0.36 0.71 0.64 57571429
+ 0.36 0.71 0.64 64642857
+ 0.36 0.71 0.64 71714286
+ 0.36 0.71 0.64 78785714
+ 0.36 0.71 0.64 85857143
+ 0.36 0.71 0.64 92928571
+ 0.36 0.71 0.64 100000000
+ 0.36 0.71 0.71 1000000
+ 0.36 0.71 0.71 8071429
+ 0.36 0.71 0.71 15142857
+ 0.36 0.71 0.71 22214286
+ 0.36 0.71 0.71 29285714
+ 0.36 0.71 0.71 36357143
+ 0.36 0.71 0.71 43428571
+ 0.36 0.71 0.71 50500000
+ 0.36 0.71 0.71 57571429
+ 0.36 0.71 0.71 64642857
+ 0.36 0.71 0.71 71714286
+ 0.36 0.71 0.71 78785714
+ 0.36 0.71 0.71 85857143
+ 0.36 0.71 0.71 92928571
+ 0.36 0.71 0.71 100000000
+ 0.36 0.71 0.79 1000000
+ 0.36 0.71 0.79 8071429
+ 0.36 0.71 0.79 15142857
+ 0.36 0.71 0.79 22214286
+ 0.36 0.71 0.79 29285714
+ 0.36 0.71 0.79 36357143
+ 0.36 0.71 0.79 43428571
+ 0.36 0.71 0.79 50500000
+ 0.36 0.71 0.79 57571429
+ 0.36 0.71 0.79 64642857
+ 0.36 0.71 0.79 71714286
+ 0.36 0.71 0.79 78785714
+ 0.36 0.71 0.79 85857143
+ 0.36 0.71 0.79 92928571
+ 0.36 0.71 0.79 100000000
+ 0.36 0.71 0.86 1000000
+ 0.36 0.71 0.86 8071429
+ 0.36 0.71 0.86 15142857
+ 0.36 0.71 0.86 22214286
+ 0.36 0.71 0.86 29285714
+ 0.36 0.71 0.86 36357143
+ 0.36 0.71 0.86 43428571
+ 0.36 0.71 0.86 50500000
+ 0.36 0.71 0.86 57571429
+ 0.36 0.71 0.86 64642857
+ 0.36 0.71 0.86 71714286
+ 0.36 0.71 0.86 78785714
+ 0.36 0.71 0.86 85857143
+ 0.36 0.71 0.86 92928571
+ 0.36 0.71 0.86 100000000
+ 0.36 0.71 0.93 1000000
+ 0.36 0.71 0.93 8071429
+ 0.36 0.71 0.93 15142857
+ 0.36 0.71 0.93 22214286
+ 0.36 0.71 0.93 29285714
+ 0.36 0.71 0.93 36357143
+ 0.36 0.71 0.93 43428571
+ 0.36 0.71 0.93 50500000
+ 0.36 0.71 0.93 57571429
+ 0.36 0.71 0.93 64642857
+ 0.36 0.71 0.93 71714286
+ 0.36 0.71 0.93 78785714
+ 0.36 0.71 0.93 85857143
+ 0.36 0.71 0.93 92928571
+ 0.36 0.71 0.93 100000000
+ 0.36 0.71 1.00 1000000
+ 0.36 0.71 1.00 8071429
+ 0.36 0.71 1.00 15142857
+ 0.36 0.71 1.00 22214286
+ 0.36 0.71 1.00 29285714
+ 0.36 0.71 1.00 36357143
+ 0.36 0.71 1.00 43428571
+ 0.36 0.71 1.00 50500000
+ 0.36 0.71 1.00 57571429
+ 0.36 0.71 1.00 64642857
+ 0.36 0.71 1.00 71714286
+ 0.36 0.71 1.00 78785714
+ 0.36 0.71 1.00 85857143
+ 0.36 0.71 1.00 92928571
+ 0.36 0.71 1.00 100000000
+ 0.36 0.79 0.00 1000000
+ 0.36 0.79 0.00 8071429
+ 0.36 0.79 0.00 15142857
+ 0.36 0.79 0.00 22214286
+ 0.36 0.79 0.00 29285714
+ 0.36 0.79 0.00 36357143
+ 0.36 0.79 0.00 43428571
+ 0.36 0.79 0.00 50500000
+ 0.36 0.79 0.00 57571429
+ 0.36 0.79 0.00 64642857
+ 0.36 0.79 0.00 71714286
+ 0.36 0.79 0.00 78785714
+ 0.36 0.79 0.00 85857143
+ 0.36 0.79 0.00 92928571
+ 0.36 0.79 0.00 100000000
+ 0.36 0.79 0.07 1000000
+ 0.36 0.79 0.07 8071429
+ 0.36 0.79 0.07 15142857
+ 0.36 0.79 0.07 22214286
+ 0.36 0.79 0.07 29285714
+ 0.36 0.79 0.07 36357143
+ 0.36 0.79 0.07 43428571
+ 0.36 0.79 0.07 50500000
+ 0.36 0.79 0.07 57571429
+ 0.36 0.79 0.07 64642857
+ 0.36 0.79 0.07 71714286
+ 0.36 0.79 0.07 78785714
+ 0.36 0.79 0.07 85857143
+ 0.36 0.79 0.07 92928571
+ 0.36 0.79 0.07 100000000
+ 0.36 0.79 0.14 1000000
+ 0.36 0.79 0.14 8071429
+ 0.36 0.79 0.14 15142857
+ 0.36 0.79 0.14 22214286
+ 0.36 0.79 0.14 29285714
+ 0.36 0.79 0.14 36357143
+ 0.36 0.79 0.14 43428571
+ 0.36 0.79 0.14 50500000
+ 0.36 0.79 0.14 57571429
+ 0.36 0.79 0.14 64642857
+ 0.36 0.79 0.14 71714286
+ 0.36 0.79 0.14 78785714
+ 0.36 0.79 0.14 85857143
+ 0.36 0.79 0.14 92928571
+ 0.36 0.79 0.14 100000000
+ 0.36 0.79 0.21 1000000
+ 0.36 0.79 0.21 8071429
+ 0.36 0.79 0.21 15142857
+ 0.36 0.79 0.21 22214286
+ 0.36 0.79 0.21 29285714
+ 0.36 0.79 0.21 36357143
+ 0.36 0.79 0.21 43428571
+ 0.36 0.79 0.21 50500000
+ 0.36 0.79 0.21 57571429
+ 0.36 0.79 0.21 64642857
+ 0.36 0.79 0.21 71714286
+ 0.36 0.79 0.21 78785714
+ 0.36 0.79 0.21 85857143
+ 0.36 0.79 0.21 92928571
+ 0.36 0.79 0.21 100000000
+ 0.36 0.79 0.29 1000000
+ 0.36 0.79 0.29 8071429
+ 0.36 0.79 0.29 15142857
+ 0.36 0.79 0.29 22214286
+ 0.36 0.79 0.29 29285714
+ 0.36 0.79 0.29 36357143
+ 0.36 0.79 0.29 43428571
+ 0.36 0.79 0.29 50500000
+ 0.36 0.79 0.29 57571429
+ 0.36 0.79 0.29 64642857
+ 0.36 0.79 0.29 71714286
+ 0.36 0.79 0.29 78785714
+ 0.36 0.79 0.29 85857143
+ 0.36 0.79 0.29 92928571
+ 0.36 0.79 0.29 100000000
+ 0.36 0.79 0.36 1000000
+ 0.36 0.79 0.36 8071429
+ 0.36 0.79 0.36 15142857
+ 0.36 0.79 0.36 22214286
+ 0.36 0.79 0.36 29285714
+ 0.36 0.79 0.36 36357143
+ 0.36 0.79 0.36 43428571
+ 0.36 0.79 0.36 50500000
+ 0.36 0.79 0.36 57571429
+ 0.36 0.79 0.36 64642857
+ 0.36 0.79 0.36 71714286
+ 0.36 0.79 0.36 78785714
+ 0.36 0.79 0.36 85857143
+ 0.36 0.79 0.36 92928571
+ 0.36 0.79 0.36 100000000
+ 0.36 0.79 0.43 1000000
+ 0.36 0.79 0.43 8071429
+ 0.36 0.79 0.43 15142857
+ 0.36 0.79 0.43 22214286
+ 0.36 0.79 0.43 29285714
+ 0.36 0.79 0.43 36357143
+ 0.36 0.79 0.43 43428571
+ 0.36 0.79 0.43 50500000
+ 0.36 0.79 0.43 57571429
+ 0.36 0.79 0.43 64642857
+ 0.36 0.79 0.43 71714286
+ 0.36 0.79 0.43 78785714
+ 0.36 0.79 0.43 85857143
+ 0.36 0.79 0.43 92928571
+ 0.36 0.79 0.43 100000000
+ 0.36 0.79 0.50 1000000
+ 0.36 0.79 0.50 8071429
+ 0.36 0.79 0.50 15142857
+ 0.36 0.79 0.50 22214286
+ 0.36 0.79 0.50 29285714
+ 0.36 0.79 0.50 36357143
+ 0.36 0.79 0.50 43428571
+ 0.36 0.79 0.50 50500000
+ 0.36 0.79 0.50 57571429
+ 0.36 0.79 0.50 64642857
+ 0.36 0.79 0.50 71714286
+ 0.36 0.79 0.50 78785714
+ 0.36 0.79 0.50 85857143
+ 0.36 0.79 0.50 92928571
+ 0.36 0.79 0.50 100000000
+ 0.36 0.79 0.57 1000000
+ 0.36 0.79 0.57 8071429
+ 0.36 0.79 0.57 15142857
+ 0.36 0.79 0.57 22214286
+ 0.36 0.79 0.57 29285714
+ 0.36 0.79 0.57 36357143
+ 0.36 0.79 0.57 43428571
+ 0.36 0.79 0.57 50500000
+ 0.36 0.79 0.57 57571429
+ 0.36 0.79 0.57 64642857
+ 0.36 0.79 0.57 71714286
+ 0.36 0.79 0.57 78785714
+ 0.36 0.79 0.57 85857143
+ 0.36 0.79 0.57 92928571
+ 0.36 0.79 0.57 100000000
+ 0.36 0.79 0.64 1000000
+ 0.36 0.79 0.64 8071429
+ 0.36 0.79 0.64 15142857
+ 0.36 0.79 0.64 22214286
+ 0.36 0.79 0.64 29285714
+ 0.36 0.79 0.64 36357143
+ 0.36 0.79 0.64 43428571
+ 0.36 0.79 0.64 50500000
+ 0.36 0.79 0.64 57571429
+ 0.36 0.79 0.64 64642857
+ 0.36 0.79 0.64 71714286
+ 0.36 0.79 0.64 78785714
+ 0.36 0.79 0.64 85857143
+ 0.36 0.79 0.64 92928571
+ 0.36 0.79 0.64 100000000
+ 0.36 0.79 0.71 1000000
+ 0.36 0.79 0.71 8071429
+ 0.36 0.79 0.71 15142857
+ 0.36 0.79 0.71 22214286
+ 0.36 0.79 0.71 29285714
+ 0.36 0.79 0.71 36357143
+ 0.36 0.79 0.71 43428571
+ 0.36 0.79 0.71 50500000
+ 0.36 0.79 0.71 57571429
+ 0.36 0.79 0.71 64642857
+ 0.36 0.79 0.71 71714286
+ 0.36 0.79 0.71 78785714
+ 0.36 0.79 0.71 85857143
+ 0.36 0.79 0.71 92928571
+ 0.36 0.79 0.71 100000000
+ 0.36 0.79 0.79 1000000
+ 0.36 0.79 0.79 8071429
+ 0.36 0.79 0.79 15142857
+ 0.36 0.79 0.79 22214286
+ 0.36 0.79 0.79 29285714
+ 0.36 0.79 0.79 36357143
+ 0.36 0.79 0.79 43428571
+ 0.36 0.79 0.79 50500000
+ 0.36 0.79 0.79 57571429
+ 0.36 0.79 0.79 64642857
+ 0.36 0.79 0.79 71714286
+ 0.36 0.79 0.79 78785714
+ 0.36 0.79 0.79 85857143
+ 0.36 0.79 0.79 92928571
+ 0.36 0.79 0.79 100000000
+ 0.36 0.79 0.86 1000000
+ 0.36 0.79 0.86 8071429
+ 0.36 0.79 0.86 15142857
+ 0.36 0.79 0.86 22214286
+ 0.36 0.79 0.86 29285714
+ 0.36 0.79 0.86 36357143
+ 0.36 0.79 0.86 43428571
+ 0.36 0.79 0.86 50500000
+ 0.36 0.79 0.86 57571429
+ 0.36 0.79 0.86 64642857
+ 0.36 0.79 0.86 71714286
+ 0.36 0.79 0.86 78785714
+ 0.36 0.79 0.86 85857143
+ 0.36 0.79 0.86 92928571
+ 0.36 0.79 0.86 100000000
+ 0.36 0.79 0.93 1000000
+ 0.36 0.79 0.93 8071429
+ 0.36 0.79 0.93 15142857
+ 0.36 0.79 0.93 22214286
+ 0.36 0.79 0.93 29285714
+ 0.36 0.79 0.93 36357143
+ 0.36 0.79 0.93 43428571
+ 0.36 0.79 0.93 50500000
+ 0.36 0.79 0.93 57571429
+ 0.36 0.79 0.93 64642857
+ 0.36 0.79 0.93 71714286
+ 0.36 0.79 0.93 78785714
+ 0.36 0.79 0.93 85857143
+ 0.36 0.79 0.93 92928571
+ 0.36 0.79 0.93 100000000
+ 0.36 0.79 1.00 1000000
+ 0.36 0.79 1.00 8071429
+ 0.36 0.79 1.00 15142857
+ 0.36 0.79 1.00 22214286
+ 0.36 0.79 1.00 29285714
+ 0.36 0.79 1.00 36357143
+ 0.36 0.79 1.00 43428571
+ 0.36 0.79 1.00 50500000
+ 0.36 0.79 1.00 57571429
+ 0.36 0.79 1.00 64642857
+ 0.36 0.79 1.00 71714286
+ 0.36 0.79 1.00 78785714
+ 0.36 0.79 1.00 85857143
+ 0.36 0.79 1.00 92928571
+ 0.36 0.79 1.00 100000000
+ 0.36 0.86 0.00 1000000
+ 0.36 0.86 0.00 8071429
+ 0.36 0.86 0.00 15142857
+ 0.36 0.86 0.00 22214286
+ 0.36 0.86 0.00 29285714
+ 0.36 0.86 0.00 36357143
+ 0.36 0.86 0.00 43428571
+ 0.36 0.86 0.00 50500000
+ 0.36 0.86 0.00 57571429
+ 0.36 0.86 0.00 64642857
+ 0.36 0.86 0.00 71714286
+ 0.36 0.86 0.00 78785714
+ 0.36 0.86 0.00 85857143
+ 0.36 0.86 0.00 92928571
+ 0.36 0.86 0.00 100000000
+ 0.36 0.86 0.07 1000000
+ 0.36 0.86 0.07 8071429
+ 0.36 0.86 0.07 15142857
+ 0.36 0.86 0.07 22214286
+ 0.36 0.86 0.07 29285714
+ 0.36 0.86 0.07 36357143
+ 0.36 0.86 0.07 43428571
+ 0.36 0.86 0.07 50500000
+ 0.36 0.86 0.07 57571429
+ 0.36 0.86 0.07 64642857
+ 0.36 0.86 0.07 71714286
+ 0.36 0.86 0.07 78785714
+ 0.36 0.86 0.07 85857143
+ 0.36 0.86 0.07 92928571
+ 0.36 0.86 0.07 100000000
+ 0.36 0.86 0.14 1000000
+ 0.36 0.86 0.14 8071429
+ 0.36 0.86 0.14 15142857
+ 0.36 0.86 0.14 22214286
+ 0.36 0.86 0.14 29285714
+ 0.36 0.86 0.14 36357143
+ 0.36 0.86 0.14 43428571
+ 0.36 0.86 0.14 50500000
+ 0.36 0.86 0.14 57571429
+ 0.36 0.86 0.14 64642857
+ 0.36 0.86 0.14 71714286
+ 0.36 0.86 0.14 78785714
+ 0.36 0.86 0.14 85857143
+ 0.36 0.86 0.14 92928571
+ 0.36 0.86 0.14 100000000
+ 0.36 0.86 0.21 1000000
+ 0.36 0.86 0.21 8071429
+ 0.36 0.86 0.21 15142857
+ 0.36 0.86 0.21 22214286
+ 0.36 0.86 0.21 29285714
+ 0.36 0.86 0.21 36357143
+ 0.36 0.86 0.21 43428571
+ 0.36 0.86 0.21 50500000
+ 0.36 0.86 0.21 57571429
+ 0.36 0.86 0.21 64642857
+ 0.36 0.86 0.21 71714286
+ 0.36 0.86 0.21 78785714
+ 0.36 0.86 0.21 85857143
+ 0.36 0.86 0.21 92928571
+ 0.36 0.86 0.21 100000000
+ 0.36 0.86 0.29 1000000
+ 0.36 0.86 0.29 8071429
+ 0.36 0.86 0.29 15142857
+ 0.36 0.86 0.29 22214286
+ 0.36 0.86 0.29 29285714
+ 0.36 0.86 0.29 36357143
+ 0.36 0.86 0.29 43428571
+ 0.36 0.86 0.29 50500000
+ 0.36 0.86 0.29 57571429
+ 0.36 0.86 0.29 64642857
+ 0.36 0.86 0.29 71714286
+ 0.36 0.86 0.29 78785714
+ 0.36 0.86 0.29 85857143
+ 0.36 0.86 0.29 92928571
+ 0.36 0.86 0.29 100000000
+ 0.36 0.86 0.36 1000000
+ 0.36 0.86 0.36 8071429
+ 0.36 0.86 0.36 15142857
+ 0.36 0.86 0.36 22214286
+ 0.36 0.86 0.36 29285714
+ 0.36 0.86 0.36 36357143
+ 0.36 0.86 0.36 43428571
+ 0.36 0.86 0.36 50500000
+ 0.36 0.86 0.36 57571429
+ 0.36 0.86 0.36 64642857
+ 0.36 0.86 0.36 71714286
+ 0.36 0.86 0.36 78785714
+ 0.36 0.86 0.36 85857143
+ 0.36 0.86 0.36 92928571
+ 0.36 0.86 0.36 100000000
+ 0.36 0.86 0.43 1000000
+ 0.36 0.86 0.43 8071429
+ 0.36 0.86 0.43 15142857
+ 0.36 0.86 0.43 22214286
+ 0.36 0.86 0.43 29285714
+ 0.36 0.86 0.43 36357143
+ 0.36 0.86 0.43 43428571
+ 0.36 0.86 0.43 50500000
+ 0.36 0.86 0.43 57571429
+ 0.36 0.86 0.43 64642857
+ 0.36 0.86 0.43 71714286
+ 0.36 0.86 0.43 78785714
+ 0.36 0.86 0.43 85857143
+ 0.36 0.86 0.43 92928571
+ 0.36 0.86 0.43 100000000
+ 0.36 0.86 0.50 1000000
+ 0.36 0.86 0.50 8071429
+ 0.36 0.86 0.50 15142857
+ 0.36 0.86 0.50 22214286
+ 0.36 0.86 0.50 29285714
+ 0.36 0.86 0.50 36357143
+ 0.36 0.86 0.50 43428571
+ 0.36 0.86 0.50 50500000
+ 0.36 0.86 0.50 57571429
+ 0.36 0.86 0.50 64642857
+ 0.36 0.86 0.50 71714286
+ 0.36 0.86 0.50 78785714
+ 0.36 0.86 0.50 85857143
+ 0.36 0.86 0.50 92928571
+ 0.36 0.86 0.50 100000000
+ 0.36 0.86 0.57 1000000
+ 0.36 0.86 0.57 8071429
+ 0.36 0.86 0.57 15142857
+ 0.36 0.86 0.57 22214286
+ 0.36 0.86 0.57 29285714
+ 0.36 0.86 0.57 36357143
+ 0.36 0.86 0.57 43428571
+ 0.36 0.86 0.57 50500000
+ 0.36 0.86 0.57 57571429
+ 0.36 0.86 0.57 64642857
+ 0.36 0.86 0.57 71714286
+ 0.36 0.86 0.57 78785714
+ 0.36 0.86 0.57 85857143
+ 0.36 0.86 0.57 92928571
+ 0.36 0.86 0.57 100000000
+ 0.36 0.86 0.64 1000000
+ 0.36 0.86 0.64 8071429
+ 0.36 0.86 0.64 15142857
+ 0.36 0.86 0.64 22214286
+ 0.36 0.86 0.64 29285714
+ 0.36 0.86 0.64 36357143
+ 0.36 0.86 0.64 43428571
+ 0.36 0.86 0.64 50500000
+ 0.36 0.86 0.64 57571429
+ 0.36 0.86 0.64 64642857
+ 0.36 0.86 0.64 71714286
+ 0.36 0.86 0.64 78785714
+ 0.36 0.86 0.64 85857143
+ 0.36 0.86 0.64 92928571
+ 0.36 0.86 0.64 100000000
+ 0.36 0.86 0.71 1000000
+ 0.36 0.86 0.71 8071429
+ 0.36 0.86 0.71 15142857
+ 0.36 0.86 0.71 22214286
+ 0.36 0.86 0.71 29285714
+ 0.36 0.86 0.71 36357143
+ 0.36 0.86 0.71 43428571
+ 0.36 0.86 0.71 50500000
+ 0.36 0.86 0.71 57571429
+ 0.36 0.86 0.71 64642857
+ 0.36 0.86 0.71 71714286
+ 0.36 0.86 0.71 78785714
+ 0.36 0.86 0.71 85857143
+ 0.36 0.86 0.71 92928571
+ 0.36 0.86 0.71 100000000
+ 0.36 0.86 0.79 1000000
+ 0.36 0.86 0.79 8071429
+ 0.36 0.86 0.79 15142857
+ 0.36 0.86 0.79 22214286
+ 0.36 0.86 0.79 29285714
+ 0.36 0.86 0.79 36357143
+ 0.36 0.86 0.79 43428571
+ 0.36 0.86 0.79 50500000
+ 0.36 0.86 0.79 57571429
+ 0.36 0.86 0.79 64642857
+ 0.36 0.86 0.79 71714286
+ 0.36 0.86 0.79 78785714
+ 0.36 0.86 0.79 85857143
+ 0.36 0.86 0.79 92928571
+ 0.36 0.86 0.79 100000000
+ 0.36 0.86 0.86 1000000
+ 0.36 0.86 0.86 8071429
+ 0.36 0.86 0.86 15142857
+ 0.36 0.86 0.86 22214286
+ 0.36 0.86 0.86 29285714
+ 0.36 0.86 0.86 36357143
+ 0.36 0.86 0.86 43428571
+ 0.36 0.86 0.86 50500000
+ 0.36 0.86 0.86 57571429
+ 0.36 0.86 0.86 64642857
+ 0.36 0.86 0.86 71714286
+ 0.36 0.86 0.86 78785714
+ 0.36 0.86 0.86 85857143
+ 0.36 0.86 0.86 92928571
+ 0.36 0.86 0.86 100000000
+ 0.36 0.86 0.93 1000000
+ 0.36 0.86 0.93 8071429
+ 0.36 0.86 0.93 15142857
+ 0.36 0.86 0.93 22214286
+ 0.36 0.86 0.93 29285714
+ 0.36 0.86 0.93 36357143
+ 0.36 0.86 0.93 43428571
+ 0.36 0.86 0.93 50500000
+ 0.36 0.86 0.93 57571429
+ 0.36 0.86 0.93 64642857
+ 0.36 0.86 0.93 71714286
+ 0.36 0.86 0.93 78785714
+ 0.36 0.86 0.93 85857143
+ 0.36 0.86 0.93 92928571
+ 0.36 0.86 0.93 100000000
+ 0.36 0.86 1.00 1000000
+ 0.36 0.86 1.00 8071429
+ 0.36 0.86 1.00 15142857
+ 0.36 0.86 1.00 22214286
+ 0.36 0.86 1.00 29285714
+ 0.36 0.86 1.00 36357143
+ 0.36 0.86 1.00 43428571
+ 0.36 0.86 1.00 50500000
+ 0.36 0.86 1.00 57571429
+ 0.36 0.86 1.00 64642857
+ 0.36 0.86 1.00 71714286
+ 0.36 0.86 1.00 78785714
+ 0.36 0.86 1.00 85857143
+ 0.36 0.86 1.00 92928571
+ 0.36 0.86 1.00 100000000
+ 0.36 0.93 0.00 1000000
+ 0.36 0.93 0.00 8071429
+ 0.36 0.93 0.00 15142857
+ 0.36 0.93 0.00 22214286
+ 0.36 0.93 0.00 29285714
+ 0.36 0.93 0.00 36357143
+ 0.36 0.93 0.00 43428571
+ 0.36 0.93 0.00 50500000
+ 0.36 0.93 0.00 57571429
+ 0.36 0.93 0.00 64642857
+ 0.36 0.93 0.00 71714286
+ 0.36 0.93 0.00 78785714
+ 0.36 0.93 0.00 85857143
+ 0.36 0.93 0.00 92928571
+ 0.36 0.93 0.00 100000000
+ 0.36 0.93 0.07 1000000
+ 0.36 0.93 0.07 8071429
+ 0.36 0.93 0.07 15142857
+ 0.36 0.93 0.07 22214286
+ 0.36 0.93 0.07 29285714
+ 0.36 0.93 0.07 36357143
+ 0.36 0.93 0.07 43428571
+ 0.36 0.93 0.07 50500000
+ 0.36 0.93 0.07 57571429
+ 0.36 0.93 0.07 64642857
+ 0.36 0.93 0.07 71714286
+ 0.36 0.93 0.07 78785714
+ 0.36 0.93 0.07 85857143
+ 0.36 0.93 0.07 92928571
+ 0.36 0.93 0.07 100000000
+ 0.36 0.93 0.14 1000000
+ 0.36 0.93 0.14 8071429
+ 0.36 0.93 0.14 15142857
+ 0.36 0.93 0.14 22214286
+ 0.36 0.93 0.14 29285714
+ 0.36 0.93 0.14 36357143
+ 0.36 0.93 0.14 43428571
+ 0.36 0.93 0.14 50500000
+ 0.36 0.93 0.14 57571429
+ 0.36 0.93 0.14 64642857
+ 0.36 0.93 0.14 71714286
+ 0.36 0.93 0.14 78785714
+ 0.36 0.93 0.14 85857143
+ 0.36 0.93 0.14 92928571
+ 0.36 0.93 0.14 100000000
+ 0.36 0.93 0.21 1000000
+ 0.36 0.93 0.21 8071429
+ 0.36 0.93 0.21 15142857
+ 0.36 0.93 0.21 22214286
+ 0.36 0.93 0.21 29285714
+ 0.36 0.93 0.21 36357143
+ 0.36 0.93 0.21 43428571
+ 0.36 0.93 0.21 50500000
+ 0.36 0.93 0.21 57571429
+ 0.36 0.93 0.21 64642857
+ 0.36 0.93 0.21 71714286
+ 0.36 0.93 0.21 78785714
+ 0.36 0.93 0.21 85857143
+ 0.36 0.93 0.21 92928571
+ 0.36 0.93 0.21 100000000
+ 0.36 0.93 0.29 1000000
+ 0.36 0.93 0.29 8071429
+ 0.36 0.93 0.29 15142857
+ 0.36 0.93 0.29 22214286
+ 0.36 0.93 0.29 29285714
+ 0.36 0.93 0.29 36357143
+ 0.36 0.93 0.29 43428571
+ 0.36 0.93 0.29 50500000
+ 0.36 0.93 0.29 57571429
+ 0.36 0.93 0.29 64642857
+ 0.36 0.93 0.29 71714286
+ 0.36 0.93 0.29 78785714
+ 0.36 0.93 0.29 85857143
+ 0.36 0.93 0.29 92928571
+ 0.36 0.93 0.29 100000000
+ 0.36 0.93 0.36 1000000
+ 0.36 0.93 0.36 8071429
+ 0.36 0.93 0.36 15142857
+ 0.36 0.93 0.36 22214286
+ 0.36 0.93 0.36 29285714
+ 0.36 0.93 0.36 36357143
+ 0.36 0.93 0.36 43428571
+ 0.36 0.93 0.36 50500000
+ 0.36 0.93 0.36 57571429
+ 0.36 0.93 0.36 64642857
+ 0.36 0.93 0.36 71714286
+ 0.36 0.93 0.36 78785714
+ 0.36 0.93 0.36 85857143
+ 0.36 0.93 0.36 92928571
+ 0.36 0.93 0.36 100000000
+ 0.36 0.93 0.43 1000000
+ 0.36 0.93 0.43 8071429
+ 0.36 0.93 0.43 15142857
+ 0.36 0.93 0.43 22214286
+ 0.36 0.93 0.43 29285714
+ 0.36 0.93 0.43 36357143
+ 0.36 0.93 0.43 43428571
+ 0.36 0.93 0.43 50500000
+ 0.36 0.93 0.43 57571429
+ 0.36 0.93 0.43 64642857
+ 0.36 0.93 0.43 71714286
+ 0.36 0.93 0.43 78785714
+ 0.36 0.93 0.43 85857143
+ 0.36 0.93 0.43 92928571
+ 0.36 0.93 0.43 100000000
+ 0.36 0.93 0.50 1000000
+ 0.36 0.93 0.50 8071429
+ 0.36 0.93 0.50 15142857
+ 0.36 0.93 0.50 22214286
+ 0.36 0.93 0.50 29285714
+ 0.36 0.93 0.50 36357143
+ 0.36 0.93 0.50 43428571
+ 0.36 0.93 0.50 50500000
+ 0.36 0.93 0.50 57571429
+ 0.36 0.93 0.50 64642857
+ 0.36 0.93 0.50 71714286
+ 0.36 0.93 0.50 78785714
+ 0.36 0.93 0.50 85857143
+ 0.36 0.93 0.50 92928571
+ 0.36 0.93 0.50 100000000
+ 0.36 0.93 0.57 1000000
+ 0.36 0.93 0.57 8071429
+ 0.36 0.93 0.57 15142857
+ 0.36 0.93 0.57 22214286
+ 0.36 0.93 0.57 29285714
+ 0.36 0.93 0.57 36357143
+ 0.36 0.93 0.57 43428571
+ 0.36 0.93 0.57 50500000
+ 0.36 0.93 0.57 57571429
+ 0.36 0.93 0.57 64642857
+ 0.36 0.93 0.57 71714286
+ 0.36 0.93 0.57 78785714
+ 0.36 0.93 0.57 85857143
+ 0.36 0.93 0.57 92928571
+ 0.36 0.93 0.57 100000000
+ 0.36 0.93 0.64 1000000
+ 0.36 0.93 0.64 8071429
+ 0.36 0.93 0.64 15142857
+ 0.36 0.93 0.64 22214286
+ 0.36 0.93 0.64 29285714
+ 0.36 0.93 0.64 36357143
+ 0.36 0.93 0.64 43428571
+ 0.36 0.93 0.64 50500000
+ 0.36 0.93 0.64 57571429
+ 0.36 0.93 0.64 64642857
+ 0.36 0.93 0.64 71714286
+ 0.36 0.93 0.64 78785714
+ 0.36 0.93 0.64 85857143
+ 0.36 0.93 0.64 92928571
+ 0.36 0.93 0.64 100000000
+ 0.36 0.93 0.71 1000000
+ 0.36 0.93 0.71 8071429
+ 0.36 0.93 0.71 15142857
+ 0.36 0.93 0.71 22214286
+ 0.36 0.93 0.71 29285714
+ 0.36 0.93 0.71 36357143
+ 0.36 0.93 0.71 43428571
+ 0.36 0.93 0.71 50500000
+ 0.36 0.93 0.71 57571429
+ 0.36 0.93 0.71 64642857
+ 0.36 0.93 0.71 71714286
+ 0.36 0.93 0.71 78785714
+ 0.36 0.93 0.71 85857143
+ 0.36 0.93 0.71 92928571
+ 0.36 0.93 0.71 100000000
+ 0.36 0.93 0.79 1000000
+ 0.36 0.93 0.79 8071429
+ 0.36 0.93 0.79 15142857
+ 0.36 0.93 0.79 22214286
+ 0.36 0.93 0.79 29285714
+ 0.36 0.93 0.79 36357143
+ 0.36 0.93 0.79 43428571
+ 0.36 0.93 0.79 50500000
+ 0.36 0.93 0.79 57571429
+ 0.36 0.93 0.79 64642857
+ 0.36 0.93 0.79 71714286
+ 0.36 0.93 0.79 78785714
+ 0.36 0.93 0.79 85857143
+ 0.36 0.93 0.79 92928571
+ 0.36 0.93 0.79 100000000
+ 0.36 0.93 0.86 1000000
+ 0.36 0.93 0.86 8071429
+ 0.36 0.93 0.86 15142857
+ 0.36 0.93 0.86 22214286
+ 0.36 0.93 0.86 29285714
+ 0.36 0.93 0.86 36357143
+ 0.36 0.93 0.86 43428571
+ 0.36 0.93 0.86 50500000
+ 0.36 0.93 0.86 57571429
+ 0.36 0.93 0.86 64642857
+ 0.36 0.93 0.86 71714286
+ 0.36 0.93 0.86 78785714
+ 0.36 0.93 0.86 85857143
+ 0.36 0.93 0.86 92928571
+ 0.36 0.93 0.86 100000000
+ 0.36 0.93 0.93 1000000
+ 0.36 0.93 0.93 8071429
+ 0.36 0.93 0.93 15142857
+ 0.36 0.93 0.93 22214286
+ 0.36 0.93 0.93 29285714
+ 0.36 0.93 0.93 36357143
+ 0.36 0.93 0.93 43428571
+ 0.36 0.93 0.93 50500000
+ 0.36 0.93 0.93 57571429
+ 0.36 0.93 0.93 64642857
+ 0.36 0.93 0.93 71714286
+ 0.36 0.93 0.93 78785714
+ 0.36 0.93 0.93 85857143
+ 0.36 0.93 0.93 92928571
+ 0.36 0.93 0.93 100000000
+ 0.36 0.93 1.00 1000000
+ 0.36 0.93 1.00 8071429
+ 0.36 0.93 1.00 15142857
+ 0.36 0.93 1.00 22214286
+ 0.36 0.93 1.00 29285714
+ 0.36 0.93 1.00 36357143
+ 0.36 0.93 1.00 43428571
+ 0.36 0.93 1.00 50500000
+ 0.36 0.93 1.00 57571429
+ 0.36 0.93 1.00 64642857
+ 0.36 0.93 1.00 71714286
+ 0.36 0.93 1.00 78785714
+ 0.36 0.93 1.00 85857143
+ 0.36 0.93 1.00 92928571
+ 0.36 0.93 1.00 100000000
+ 0.36 1.00 0.00 1000000
+ 0.36 1.00 0.00 8071429
+ 0.36 1.00 0.00 15142857
+ 0.36 1.00 0.00 22214286
+ 0.36 1.00 0.00 29285714
+ 0.36 1.00 0.00 36357143
+ 0.36 1.00 0.00 43428571
+ 0.36 1.00 0.00 50500000
+ 0.36 1.00 0.00 57571429
+ 0.36 1.00 0.00 64642857
+ 0.36 1.00 0.00 71714286
+ 0.36 1.00 0.00 78785714
+ 0.36 1.00 0.00 85857143
+ 0.36 1.00 0.00 92928571
+ 0.36 1.00 0.00 100000000
+ 0.36 1.00 0.07 1000000
+ 0.36 1.00 0.07 8071429
+ 0.36 1.00 0.07 15142857
+ 0.36 1.00 0.07 22214286
+ 0.36 1.00 0.07 29285714
+ 0.36 1.00 0.07 36357143
+ 0.36 1.00 0.07 43428571
+ 0.36 1.00 0.07 50500000
+ 0.36 1.00 0.07 57571429
+ 0.36 1.00 0.07 64642857
+ 0.36 1.00 0.07 71714286
+ 0.36 1.00 0.07 78785714
+ 0.36 1.00 0.07 85857143
+ 0.36 1.00 0.07 92928571
+ 0.36 1.00 0.07 100000000
+ 0.36 1.00 0.14 1000000
+ 0.36 1.00 0.14 8071429
+ 0.36 1.00 0.14 15142857
+ 0.36 1.00 0.14 22214286
+ 0.36 1.00 0.14 29285714
+ 0.36 1.00 0.14 36357143
+ 0.36 1.00 0.14 43428571
+ 0.36 1.00 0.14 50500000
+ 0.36 1.00 0.14 57571429
+ 0.36 1.00 0.14 64642857
+ 0.36 1.00 0.14 71714286
+ 0.36 1.00 0.14 78785714
+ 0.36 1.00 0.14 85857143
+ 0.36 1.00 0.14 92928571
+ 0.36 1.00 0.14 100000000
+ 0.36 1.00 0.21 1000000
+ 0.36 1.00 0.21 8071429
+ 0.36 1.00 0.21 15142857
+ 0.36 1.00 0.21 22214286
+ 0.36 1.00 0.21 29285714
+ 0.36 1.00 0.21 36357143
+ 0.36 1.00 0.21 43428571
+ 0.36 1.00 0.21 50500000
+ 0.36 1.00 0.21 57571429
+ 0.36 1.00 0.21 64642857
+ 0.36 1.00 0.21 71714286
+ 0.36 1.00 0.21 78785714
+ 0.36 1.00 0.21 85857143
+ 0.36 1.00 0.21 92928571
+ 0.36 1.00 0.21 100000000
+ 0.36 1.00 0.29 1000000
+ 0.36 1.00 0.29 8071429
+ 0.36 1.00 0.29 15142857
+ 0.36 1.00 0.29 22214286
+ 0.36 1.00 0.29 29285714
+ 0.36 1.00 0.29 36357143
+ 0.36 1.00 0.29 43428571
+ 0.36 1.00 0.29 50500000
+ 0.36 1.00 0.29 57571429
+ 0.36 1.00 0.29 64642857
+ 0.36 1.00 0.29 71714286
+ 0.36 1.00 0.29 78785714
+ 0.36 1.00 0.29 85857143
+ 0.36 1.00 0.29 92928571
+ 0.36 1.00 0.29 100000000
+ 0.36 1.00 0.36 1000000
+ 0.36 1.00 0.36 8071429
+ 0.36 1.00 0.36 15142857
+ 0.36 1.00 0.36 22214286
+ 0.36 1.00 0.36 29285714
+ 0.36 1.00 0.36 36357143
+ 0.36 1.00 0.36 43428571
+ 0.36 1.00 0.36 50500000
+ 0.36 1.00 0.36 57571429
+ 0.36 1.00 0.36 64642857
+ 0.36 1.00 0.36 71714286
+ 0.36 1.00 0.36 78785714
+ 0.36 1.00 0.36 85857143
+ 0.36 1.00 0.36 92928571
+ 0.36 1.00 0.36 100000000
+ 0.36 1.00 0.43 1000000
+ 0.36 1.00 0.43 8071429
+ 0.36 1.00 0.43 15142857
+ 0.36 1.00 0.43 22214286
+ 0.36 1.00 0.43 29285714
+ 0.36 1.00 0.43 36357143
+ 0.36 1.00 0.43 43428571
+ 0.36 1.00 0.43 50500000
+ 0.36 1.00 0.43 57571429
+ 0.36 1.00 0.43 64642857
+ 0.36 1.00 0.43 71714286
+ 0.36 1.00 0.43 78785714
+ 0.36 1.00 0.43 85857143
+ 0.36 1.00 0.43 92928571
+ 0.36 1.00 0.43 100000000
+ 0.36 1.00 0.50 1000000
+ 0.36 1.00 0.50 8071429
+ 0.36 1.00 0.50 15142857
+ 0.36 1.00 0.50 22214286
+ 0.36 1.00 0.50 29285714
+ 0.36 1.00 0.50 36357143
+ 0.36 1.00 0.50 43428571
+ 0.36 1.00 0.50 50500000
+ 0.36 1.00 0.50 57571429
+ 0.36 1.00 0.50 64642857
+ 0.36 1.00 0.50 71714286
+ 0.36 1.00 0.50 78785714
+ 0.36 1.00 0.50 85857143
+ 0.36 1.00 0.50 92928571
+ 0.36 1.00 0.50 100000000
+ 0.36 1.00 0.57 1000000
+ 0.36 1.00 0.57 8071429
+ 0.36 1.00 0.57 15142857
+ 0.36 1.00 0.57 22214286
+ 0.36 1.00 0.57 29285714
+ 0.36 1.00 0.57 36357143
+ 0.36 1.00 0.57 43428571
+ 0.36 1.00 0.57 50500000
+ 0.36 1.00 0.57 57571429
+ 0.36 1.00 0.57 64642857
+ 0.36 1.00 0.57 71714286
+ 0.36 1.00 0.57 78785714
+ 0.36 1.00 0.57 85857143
+ 0.36 1.00 0.57 92928571
+ 0.36 1.00 0.57 100000000
+ 0.36 1.00 0.64 1000000
+ 0.36 1.00 0.64 8071429
+ 0.36 1.00 0.64 15142857
+ 0.36 1.00 0.64 22214286
+ 0.36 1.00 0.64 29285714
+ 0.36 1.00 0.64 36357143
+ 0.36 1.00 0.64 43428571
+ 0.36 1.00 0.64 50500000
+ 0.36 1.00 0.64 57571429
+ 0.36 1.00 0.64 64642857
+ 0.36 1.00 0.64 71714286
+ 0.36 1.00 0.64 78785714
+ 0.36 1.00 0.64 85857143
+ 0.36 1.00 0.64 92928571
+ 0.36 1.00 0.64 100000000
+ 0.36 1.00 0.71 1000000
+ 0.36 1.00 0.71 8071429
+ 0.36 1.00 0.71 15142857
+ 0.36 1.00 0.71 22214286
+ 0.36 1.00 0.71 29285714
+ 0.36 1.00 0.71 36357143
+ 0.36 1.00 0.71 43428571
+ 0.36 1.00 0.71 50500000
+ 0.36 1.00 0.71 57571429
+ 0.36 1.00 0.71 64642857
+ 0.36 1.00 0.71 71714286
+ 0.36 1.00 0.71 78785714
+ 0.36 1.00 0.71 85857143
+ 0.36 1.00 0.71 92928571
+ 0.36 1.00 0.71 100000000
+ 0.36 1.00 0.79 1000000
+ 0.36 1.00 0.79 8071429
+ 0.36 1.00 0.79 15142857
+ 0.36 1.00 0.79 22214286
+ 0.36 1.00 0.79 29285714
+ 0.36 1.00 0.79 36357143
+ 0.36 1.00 0.79 43428571
+ 0.36 1.00 0.79 50500000
+ 0.36 1.00 0.79 57571429
+ 0.36 1.00 0.79 64642857
+ 0.36 1.00 0.79 71714286
+ 0.36 1.00 0.79 78785714
+ 0.36 1.00 0.79 85857143
+ 0.36 1.00 0.79 92928571
+ 0.36 1.00 0.79 100000000
+ 0.36 1.00 0.86 1000000
+ 0.36 1.00 0.86 8071429
+ 0.36 1.00 0.86 15142857
+ 0.36 1.00 0.86 22214286
+ 0.36 1.00 0.86 29285714
+ 0.36 1.00 0.86 36357143
+ 0.36 1.00 0.86 43428571
+ 0.36 1.00 0.86 50500000
+ 0.36 1.00 0.86 57571429
+ 0.36 1.00 0.86 64642857
+ 0.36 1.00 0.86 71714286
+ 0.36 1.00 0.86 78785714
+ 0.36 1.00 0.86 85857143
+ 0.36 1.00 0.86 92928571
+ 0.36 1.00 0.86 100000000
+ 0.36 1.00 0.93 1000000
+ 0.36 1.00 0.93 8071429
+ 0.36 1.00 0.93 15142857
+ 0.36 1.00 0.93 22214286
+ 0.36 1.00 0.93 29285714
+ 0.36 1.00 0.93 36357143
+ 0.36 1.00 0.93 43428571
+ 0.36 1.00 0.93 50500000
+ 0.36 1.00 0.93 57571429
+ 0.36 1.00 0.93 64642857
+ 0.36 1.00 0.93 71714286
+ 0.36 1.00 0.93 78785714
+ 0.36 1.00 0.93 85857143
+ 0.36 1.00 0.93 92928571
+ 0.36 1.00 0.93 100000000
+ 0.36 1.00 1.00 1000000
+ 0.36 1.00 1.00 8071429
+ 0.36 1.00 1.00 15142857
+ 0.36 1.00 1.00 22214286
+ 0.36 1.00 1.00 29285714
+ 0.36 1.00 1.00 36357143
+ 0.36 1.00 1.00 43428571
+ 0.36 1.00 1.00 50500000
+ 0.36 1.00 1.00 57571429
+ 0.36 1.00 1.00 64642857
+ 0.36 1.00 1.00 71714286
+ 0.36 1.00 1.00 78785714
+ 0.36 1.00 1.00 85857143
+ 0.36 1.00 1.00 92928571
+ 0.36 1.00 1.00 100000000
+ 0.43 0.00 0.00 1000000
+ 0.43 0.00 0.00 8071429
+ 0.43 0.00 0.00 15142857
+ 0.43 0.00 0.00 22214286
+ 0.43 0.00 0.00 29285714
+ 0.43 0.00 0.00 36357143
+ 0.43 0.00 0.00 43428571
+ 0.43 0.00 0.00 50500000
+ 0.43 0.00 0.00 57571429
+ 0.43 0.00 0.00 64642857
+ 0.43 0.00 0.00 71714286
+ 0.43 0.00 0.00 78785714
+ 0.43 0.00 0.00 85857143
+ 0.43 0.00 0.00 92928571
+ 0.43 0.00 0.00 100000000
+ 0.43 0.00 0.07 1000000
+ 0.43 0.00 0.07 8071429
+ 0.43 0.00 0.07 15142857
+ 0.43 0.00 0.07 22214286
+ 0.43 0.00 0.07 29285714
+ 0.43 0.00 0.07 36357143
+ 0.43 0.00 0.07 43428571
+ 0.43 0.00 0.07 50500000
+ 0.43 0.00 0.07 57571429
+ 0.43 0.00 0.07 64642857
+ 0.43 0.00 0.07 71714286
+ 0.43 0.00 0.07 78785714
+ 0.43 0.00 0.07 85857143
+ 0.43 0.00 0.07 92928571
+ 0.43 0.00 0.07 100000000
+ 0.43 0.00 0.14 1000000
+ 0.43 0.00 0.14 8071429
+ 0.43 0.00 0.14 15142857
+ 0.43 0.00 0.14 22214286
+ 0.43 0.00 0.14 29285714
+ 0.43 0.00 0.14 36357143
+ 0.43 0.00 0.14 43428571
+ 0.43 0.00 0.14 50500000
+ 0.43 0.00 0.14 57571429
+ 0.43 0.00 0.14 64642857
+ 0.43 0.00 0.14 71714286
+ 0.43 0.00 0.14 78785714
+ 0.43 0.00 0.14 85857143
+ 0.43 0.00 0.14 92928571
+ 0.43 0.00 0.14 100000000
+ 0.43 0.00 0.21 1000000
+ 0.43 0.00 0.21 8071429
+ 0.43 0.00 0.21 15142857
+ 0.43 0.00 0.21 22214286
+ 0.43 0.00 0.21 29285714
+ 0.43 0.00 0.21 36357143
+ 0.43 0.00 0.21 43428571
+ 0.43 0.00 0.21 50500000
+ 0.43 0.00 0.21 57571429
+ 0.43 0.00 0.21 64642857
+ 0.43 0.00 0.21 71714286
+ 0.43 0.00 0.21 78785714
+ 0.43 0.00 0.21 85857143
+ 0.43 0.00 0.21 92928571
+ 0.43 0.00 0.21 100000000
+ 0.43 0.00 0.29 1000000
+ 0.43 0.00 0.29 8071429
+ 0.43 0.00 0.29 15142857
+ 0.43 0.00 0.29 22214286
+ 0.43 0.00 0.29 29285714
+ 0.43 0.00 0.29 36357143
+ 0.43 0.00 0.29 43428571
+ 0.43 0.00 0.29 50500000
+ 0.43 0.00 0.29 57571429
+ 0.43 0.00 0.29 64642857
+ 0.43 0.00 0.29 71714286
+ 0.43 0.00 0.29 78785714
+ 0.43 0.00 0.29 85857143
+ 0.43 0.00 0.29 92928571
+ 0.43 0.00 0.29 100000000
+ 0.43 0.00 0.36 1000000
+ 0.43 0.00 0.36 8071429
+ 0.43 0.00 0.36 15142857
+ 0.43 0.00 0.36 22214286
+ 0.43 0.00 0.36 29285714
+ 0.43 0.00 0.36 36357143
+ 0.43 0.00 0.36 43428571
+ 0.43 0.00 0.36 50500000
+ 0.43 0.00 0.36 57571429
+ 0.43 0.00 0.36 64642857
+ 0.43 0.00 0.36 71714286
+ 0.43 0.00 0.36 78785714
+ 0.43 0.00 0.36 85857143
+ 0.43 0.00 0.36 92928571
+ 0.43 0.00 0.36 100000000
+ 0.43 0.00 0.43 1000000
+ 0.43 0.00 0.43 8071429
+ 0.43 0.00 0.43 15142857
+ 0.43 0.00 0.43 22214286
+ 0.43 0.00 0.43 29285714
+ 0.43 0.00 0.43 36357143
+ 0.43 0.00 0.43 43428571
+ 0.43 0.00 0.43 50500000
+ 0.43 0.00 0.43 57571429
+ 0.43 0.00 0.43 64642857
+ 0.43 0.00 0.43 71714286
+ 0.43 0.00 0.43 78785714
+ 0.43 0.00 0.43 85857143
+ 0.43 0.00 0.43 92928571
+ 0.43 0.00 0.43 100000000
+ 0.43 0.00 0.50 1000000
+ 0.43 0.00 0.50 8071429
+ 0.43 0.00 0.50 15142857
+ 0.43 0.00 0.50 22214286
+ 0.43 0.00 0.50 29285714
+ 0.43 0.00 0.50 36357143
+ 0.43 0.00 0.50 43428571
+ 0.43 0.00 0.50 50500000
+ 0.43 0.00 0.50 57571429
+ 0.43 0.00 0.50 64642857
+ 0.43 0.00 0.50 71714286
+ 0.43 0.00 0.50 78785714
+ 0.43 0.00 0.50 85857143
+ 0.43 0.00 0.50 92928571
+ 0.43 0.00 0.50 100000000
+ 0.43 0.00 0.57 1000000
+ 0.43 0.00 0.57 8071429
+ 0.43 0.00 0.57 15142857
+ 0.43 0.00 0.57 22214286
+ 0.43 0.00 0.57 29285714
+ 0.43 0.00 0.57 36357143
+ 0.43 0.00 0.57 43428571
+ 0.43 0.00 0.57 50500000
+ 0.43 0.00 0.57 57571429
+ 0.43 0.00 0.57 64642857
+ 0.43 0.00 0.57 71714286
+ 0.43 0.00 0.57 78785714
+ 0.43 0.00 0.57 85857143
+ 0.43 0.00 0.57 92928571
+ 0.43 0.00 0.57 100000000
+ 0.43 0.00 0.64 1000000
+ 0.43 0.00 0.64 8071429
+ 0.43 0.00 0.64 15142857
+ 0.43 0.00 0.64 22214286
+ 0.43 0.00 0.64 29285714
+ 0.43 0.00 0.64 36357143
+ 0.43 0.00 0.64 43428571
+ 0.43 0.00 0.64 50500000
+ 0.43 0.00 0.64 57571429
+ 0.43 0.00 0.64 64642857
+ 0.43 0.00 0.64 71714286
+ 0.43 0.00 0.64 78785714
+ 0.43 0.00 0.64 85857143
+ 0.43 0.00 0.64 92928571
+ 0.43 0.00 0.64 100000000
+ 0.43 0.00 0.71 1000000
+ 0.43 0.00 0.71 8071429
+ 0.43 0.00 0.71 15142857
+ 0.43 0.00 0.71 22214286
+ 0.43 0.00 0.71 29285714
+ 0.43 0.00 0.71 36357143
+ 0.43 0.00 0.71 43428571
+ 0.43 0.00 0.71 50500000
+ 0.43 0.00 0.71 57571429
+ 0.43 0.00 0.71 64642857
+ 0.43 0.00 0.71 71714286
+ 0.43 0.00 0.71 78785714
+ 0.43 0.00 0.71 85857143
+ 0.43 0.00 0.71 92928571
+ 0.43 0.00 0.71 100000000
+ 0.43 0.00 0.79 1000000
+ 0.43 0.00 0.79 8071429
+ 0.43 0.00 0.79 15142857
+ 0.43 0.00 0.79 22214286
+ 0.43 0.00 0.79 29285714
+ 0.43 0.00 0.79 36357143
+ 0.43 0.00 0.79 43428571
+ 0.43 0.00 0.79 50500000
+ 0.43 0.00 0.79 57571429
+ 0.43 0.00 0.79 64642857
+ 0.43 0.00 0.79 71714286
+ 0.43 0.00 0.79 78785714
+ 0.43 0.00 0.79 85857143
+ 0.43 0.00 0.79 92928571
+ 0.43 0.00 0.79 100000000
+ 0.43 0.00 0.86 1000000
+ 0.43 0.00 0.86 8071429
+ 0.43 0.00 0.86 15142857
+ 0.43 0.00 0.86 22214286
+ 0.43 0.00 0.86 29285714
+ 0.43 0.00 0.86 36357143
+ 0.43 0.00 0.86 43428571
+ 0.43 0.00 0.86 50500000
+ 0.43 0.00 0.86 57571429
+ 0.43 0.00 0.86 64642857
+ 0.43 0.00 0.86 71714286
+ 0.43 0.00 0.86 78785714
+ 0.43 0.00 0.86 85857143
+ 0.43 0.00 0.86 92928571
+ 0.43 0.00 0.86 100000000
+ 0.43 0.00 0.93 1000000
+ 0.43 0.00 0.93 8071429
+ 0.43 0.00 0.93 15142857
+ 0.43 0.00 0.93 22214286
+ 0.43 0.00 0.93 29285714
+ 0.43 0.00 0.93 36357143
+ 0.43 0.00 0.93 43428571
+ 0.43 0.00 0.93 50500000
+ 0.43 0.00 0.93 57571429
+ 0.43 0.00 0.93 64642857
+ 0.43 0.00 0.93 71714286
+ 0.43 0.00 0.93 78785714
+ 0.43 0.00 0.93 85857143
+ 0.43 0.00 0.93 92928571
+ 0.43 0.00 0.93 100000000
+ 0.43 0.00 1.00 1000000
+ 0.43 0.00 1.00 8071429
+ 0.43 0.00 1.00 15142857
+ 0.43 0.00 1.00 22214286
+ 0.43 0.00 1.00 29285714
+ 0.43 0.00 1.00 36357143
+ 0.43 0.00 1.00 43428571
+ 0.43 0.00 1.00 50500000
+ 0.43 0.00 1.00 57571429
+ 0.43 0.00 1.00 64642857
+ 0.43 0.00 1.00 71714286
+ 0.43 0.00 1.00 78785714
+ 0.43 0.00 1.00 85857143
+ 0.43 0.00 1.00 92928571
+ 0.43 0.00 1.00 100000000
+ 0.43 0.07 0.00 1000000
+ 0.43 0.07 0.00 8071429
+ 0.43 0.07 0.00 15142857
+ 0.43 0.07 0.00 22214286
+ 0.43 0.07 0.00 29285714
+ 0.43 0.07 0.00 36357143
+ 0.43 0.07 0.00 43428571
+ 0.43 0.07 0.00 50500000
+ 0.43 0.07 0.00 57571429
+ 0.43 0.07 0.00 64642857
+ 0.43 0.07 0.00 71714286
+ 0.43 0.07 0.00 78785714
+ 0.43 0.07 0.00 85857143
+ 0.43 0.07 0.00 92928571
+ 0.43 0.07 0.00 100000000
+ 0.43 0.07 0.07 1000000
+ 0.43 0.07 0.07 8071429
+ 0.43 0.07 0.07 15142857
+ 0.43 0.07 0.07 22214286
+ 0.43 0.07 0.07 29285714
+ 0.43 0.07 0.07 36357143
+ 0.43 0.07 0.07 43428571
+ 0.43 0.07 0.07 50500000
+ 0.43 0.07 0.07 57571429
+ 0.43 0.07 0.07 64642857
+ 0.43 0.07 0.07 71714286
+ 0.43 0.07 0.07 78785714
+ 0.43 0.07 0.07 85857143
+ 0.43 0.07 0.07 92928571
+ 0.43 0.07 0.07 100000000
+ 0.43 0.07 0.14 1000000
+ 0.43 0.07 0.14 8071429
+ 0.43 0.07 0.14 15142857
+ 0.43 0.07 0.14 22214286
+ 0.43 0.07 0.14 29285714
+ 0.43 0.07 0.14 36357143
+ 0.43 0.07 0.14 43428571
+ 0.43 0.07 0.14 50500000
+ 0.43 0.07 0.14 57571429
+ 0.43 0.07 0.14 64642857
+ 0.43 0.07 0.14 71714286
+ 0.43 0.07 0.14 78785714
+ 0.43 0.07 0.14 85857143
+ 0.43 0.07 0.14 92928571
+ 0.43 0.07 0.14 100000000
+ 0.43 0.07 0.21 1000000
+ 0.43 0.07 0.21 8071429
+ 0.43 0.07 0.21 15142857
+ 0.43 0.07 0.21 22214286
+ 0.43 0.07 0.21 29285714
+ 0.43 0.07 0.21 36357143
+ 0.43 0.07 0.21 43428571
+ 0.43 0.07 0.21 50500000
+ 0.43 0.07 0.21 57571429
+ 0.43 0.07 0.21 64642857
+ 0.43 0.07 0.21 71714286
+ 0.43 0.07 0.21 78785714
+ 0.43 0.07 0.21 85857143
+ 0.43 0.07 0.21 92928571
+ 0.43 0.07 0.21 100000000
+ 0.43 0.07 0.29 1000000
+ 0.43 0.07 0.29 8071429
+ 0.43 0.07 0.29 15142857
+ 0.43 0.07 0.29 22214286
+ 0.43 0.07 0.29 29285714
+ 0.43 0.07 0.29 36357143
+ 0.43 0.07 0.29 43428571
+ 0.43 0.07 0.29 50500000
+ 0.43 0.07 0.29 57571429
+ 0.43 0.07 0.29 64642857
+ 0.43 0.07 0.29 71714286
+ 0.43 0.07 0.29 78785714
+ 0.43 0.07 0.29 85857143
+ 0.43 0.07 0.29 92928571
+ 0.43 0.07 0.29 100000000
+ 0.43 0.07 0.36 1000000
+ 0.43 0.07 0.36 8071429
+ 0.43 0.07 0.36 15142857
+ 0.43 0.07 0.36 22214286
+ 0.43 0.07 0.36 29285714
+ 0.43 0.07 0.36 36357143
+ 0.43 0.07 0.36 43428571
+ 0.43 0.07 0.36 50500000
+ 0.43 0.07 0.36 57571429
+ 0.43 0.07 0.36 64642857
+ 0.43 0.07 0.36 71714286
+ 0.43 0.07 0.36 78785714
+ 0.43 0.07 0.36 85857143
+ 0.43 0.07 0.36 92928571
+ 0.43 0.07 0.36 100000000
+ 0.43 0.07 0.43 1000000
+ 0.43 0.07 0.43 8071429
+ 0.43 0.07 0.43 15142857
+ 0.43 0.07 0.43 22214286
+ 0.43 0.07 0.43 29285714
+ 0.43 0.07 0.43 36357143
+ 0.43 0.07 0.43 43428571
+ 0.43 0.07 0.43 50500000
+ 0.43 0.07 0.43 57571429
+ 0.43 0.07 0.43 64642857
+ 0.43 0.07 0.43 71714286
+ 0.43 0.07 0.43 78785714
+ 0.43 0.07 0.43 85857143
+ 0.43 0.07 0.43 92928571
+ 0.43 0.07 0.43 100000000
+ 0.43 0.07 0.50 1000000
+ 0.43 0.07 0.50 8071429
+ 0.43 0.07 0.50 15142857
+ 0.43 0.07 0.50 22214286
+ 0.43 0.07 0.50 29285714
+ 0.43 0.07 0.50 36357143
+ 0.43 0.07 0.50 43428571
+ 0.43 0.07 0.50 50500000
+ 0.43 0.07 0.50 57571429
+ 0.43 0.07 0.50 64642857
+ 0.43 0.07 0.50 71714286
+ 0.43 0.07 0.50 78785714
+ 0.43 0.07 0.50 85857143
+ 0.43 0.07 0.50 92928571
+ 0.43 0.07 0.50 100000000
+ 0.43 0.07 0.57 1000000
+ 0.43 0.07 0.57 8071429
+ 0.43 0.07 0.57 15142857
+ 0.43 0.07 0.57 22214286
+ 0.43 0.07 0.57 29285714
+ 0.43 0.07 0.57 36357143
+ 0.43 0.07 0.57 43428571
+ 0.43 0.07 0.57 50500000
+ 0.43 0.07 0.57 57571429
+ 0.43 0.07 0.57 64642857
+ 0.43 0.07 0.57 71714286
+ 0.43 0.07 0.57 78785714
+ 0.43 0.07 0.57 85857143
+ 0.43 0.07 0.57 92928571
+ 0.43 0.07 0.57 100000000
+ 0.43 0.07 0.64 1000000
+ 0.43 0.07 0.64 8071429
+ 0.43 0.07 0.64 15142857
+ 0.43 0.07 0.64 22214286
+ 0.43 0.07 0.64 29285714
+ 0.43 0.07 0.64 36357143
+ 0.43 0.07 0.64 43428571
+ 0.43 0.07 0.64 50500000
+ 0.43 0.07 0.64 57571429
+ 0.43 0.07 0.64 64642857
+ 0.43 0.07 0.64 71714286
+ 0.43 0.07 0.64 78785714
+ 0.43 0.07 0.64 85857143
+ 0.43 0.07 0.64 92928571
+ 0.43 0.07 0.64 100000000
+ 0.43 0.07 0.71 1000000
+ 0.43 0.07 0.71 8071429
+ 0.43 0.07 0.71 15142857
+ 0.43 0.07 0.71 22214286
+ 0.43 0.07 0.71 29285714
+ 0.43 0.07 0.71 36357143
+ 0.43 0.07 0.71 43428571
+ 0.43 0.07 0.71 50500000
+ 0.43 0.07 0.71 57571429
+ 0.43 0.07 0.71 64642857
+ 0.43 0.07 0.71 71714286
+ 0.43 0.07 0.71 78785714
+ 0.43 0.07 0.71 85857143
+ 0.43 0.07 0.71 92928571
+ 0.43 0.07 0.71 100000000
+ 0.43 0.07 0.79 1000000
+ 0.43 0.07 0.79 8071429
+ 0.43 0.07 0.79 15142857
+ 0.43 0.07 0.79 22214286
+ 0.43 0.07 0.79 29285714
+ 0.43 0.07 0.79 36357143
+ 0.43 0.07 0.79 43428571
+ 0.43 0.07 0.79 50500000
+ 0.43 0.07 0.79 57571429
+ 0.43 0.07 0.79 64642857
+ 0.43 0.07 0.79 71714286
+ 0.43 0.07 0.79 78785714
+ 0.43 0.07 0.79 85857143
+ 0.43 0.07 0.79 92928571
+ 0.43 0.07 0.79 100000000
+ 0.43 0.07 0.86 1000000
+ 0.43 0.07 0.86 8071429
+ 0.43 0.07 0.86 15142857
+ 0.43 0.07 0.86 22214286
+ 0.43 0.07 0.86 29285714
+ 0.43 0.07 0.86 36357143
+ 0.43 0.07 0.86 43428571
+ 0.43 0.07 0.86 50500000
+ 0.43 0.07 0.86 57571429
+ 0.43 0.07 0.86 64642857
+ 0.43 0.07 0.86 71714286
+ 0.43 0.07 0.86 78785714
+ 0.43 0.07 0.86 85857143
+ 0.43 0.07 0.86 92928571
+ 0.43 0.07 0.86 100000000
+ 0.43 0.07 0.93 1000000
+ 0.43 0.07 0.93 8071429
+ 0.43 0.07 0.93 15142857
+ 0.43 0.07 0.93 22214286
+ 0.43 0.07 0.93 29285714
+ 0.43 0.07 0.93 36357143
+ 0.43 0.07 0.93 43428571
+ 0.43 0.07 0.93 50500000
+ 0.43 0.07 0.93 57571429
+ 0.43 0.07 0.93 64642857
+ 0.43 0.07 0.93 71714286
+ 0.43 0.07 0.93 78785714
+ 0.43 0.07 0.93 85857143
+ 0.43 0.07 0.93 92928571
+ 0.43 0.07 0.93 100000000
+ 0.43 0.07 1.00 1000000
+ 0.43 0.07 1.00 8071429
+ 0.43 0.07 1.00 15142857
+ 0.43 0.07 1.00 22214286
+ 0.43 0.07 1.00 29285714
+ 0.43 0.07 1.00 36357143
+ 0.43 0.07 1.00 43428571
+ 0.43 0.07 1.00 50500000
+ 0.43 0.07 1.00 57571429
+ 0.43 0.07 1.00 64642857
+ 0.43 0.07 1.00 71714286
+ 0.43 0.07 1.00 78785714
+ 0.43 0.07 1.00 85857143
+ 0.43 0.07 1.00 92928571
+ 0.43 0.07 1.00 100000000
+ 0.43 0.14 0.00 1000000
+ 0.43 0.14 0.00 8071429
+ 0.43 0.14 0.00 15142857
+ 0.43 0.14 0.00 22214286
+ 0.43 0.14 0.00 29285714
+ 0.43 0.14 0.00 36357143
+ 0.43 0.14 0.00 43428571
+ 0.43 0.14 0.00 50500000
+ 0.43 0.14 0.00 57571429
+ 0.43 0.14 0.00 64642857
+ 0.43 0.14 0.00 71714286
+ 0.43 0.14 0.00 78785714
+ 0.43 0.14 0.00 85857143
+ 0.43 0.14 0.00 92928571
+ 0.43 0.14 0.00 100000000
+ 0.43 0.14 0.07 1000000
+ 0.43 0.14 0.07 8071429
+ 0.43 0.14 0.07 15142857
+ 0.43 0.14 0.07 22214286
+ 0.43 0.14 0.07 29285714
+ 0.43 0.14 0.07 36357143
+ 0.43 0.14 0.07 43428571
+ 0.43 0.14 0.07 50500000
+ 0.43 0.14 0.07 57571429
+ 0.43 0.14 0.07 64642857
+ 0.43 0.14 0.07 71714286
+ 0.43 0.14 0.07 78785714
+ 0.43 0.14 0.07 85857143
+ 0.43 0.14 0.07 92928571
+ 0.43 0.14 0.07 100000000
+ 0.43 0.14 0.14 1000000
+ 0.43 0.14 0.14 8071429
+ 0.43 0.14 0.14 15142857
+ 0.43 0.14 0.14 22214286
+ 0.43 0.14 0.14 29285714
+ 0.43 0.14 0.14 36357143
+ 0.43 0.14 0.14 43428571
+ 0.43 0.14 0.14 50500000
+ 0.43 0.14 0.14 57571429
+ 0.43 0.14 0.14 64642857
+ 0.43 0.14 0.14 71714286
+ 0.43 0.14 0.14 78785714
+ 0.43 0.14 0.14 85857143
+ 0.43 0.14 0.14 92928571
+ 0.43 0.14 0.14 100000000
+ 0.43 0.14 0.21 1000000
+ 0.43 0.14 0.21 8071429
+ 0.43 0.14 0.21 15142857
+ 0.43 0.14 0.21 22214286
+ 0.43 0.14 0.21 29285714
+ 0.43 0.14 0.21 36357143
+ 0.43 0.14 0.21 43428571
+ 0.43 0.14 0.21 50500000
+ 0.43 0.14 0.21 57571429
+ 0.43 0.14 0.21 64642857
+ 0.43 0.14 0.21 71714286
+ 0.43 0.14 0.21 78785714
+ 0.43 0.14 0.21 85857143
+ 0.43 0.14 0.21 92928571
+ 0.43 0.14 0.21 100000000
+ 0.43 0.14 0.29 1000000
+ 0.43 0.14 0.29 8071429
+ 0.43 0.14 0.29 15142857
+ 0.43 0.14 0.29 22214286
+ 0.43 0.14 0.29 29285714
+ 0.43 0.14 0.29 36357143
+ 0.43 0.14 0.29 43428571
+ 0.43 0.14 0.29 50500000
+ 0.43 0.14 0.29 57571429
+ 0.43 0.14 0.29 64642857
+ 0.43 0.14 0.29 71714286
+ 0.43 0.14 0.29 78785714
+ 0.43 0.14 0.29 85857143
+ 0.43 0.14 0.29 92928571
+ 0.43 0.14 0.29 100000000
+ 0.43 0.14 0.36 1000000
+ 0.43 0.14 0.36 8071429
+ 0.43 0.14 0.36 15142857
+ 0.43 0.14 0.36 22214286
+ 0.43 0.14 0.36 29285714
+ 0.43 0.14 0.36 36357143
+ 0.43 0.14 0.36 43428571
+ 0.43 0.14 0.36 50500000
+ 0.43 0.14 0.36 57571429
+ 0.43 0.14 0.36 64642857
+ 0.43 0.14 0.36 71714286
+ 0.43 0.14 0.36 78785714
+ 0.43 0.14 0.36 85857143
+ 0.43 0.14 0.36 92928571
+ 0.43 0.14 0.36 100000000
+ 0.43 0.14 0.43 1000000
+ 0.43 0.14 0.43 8071429
+ 0.43 0.14 0.43 15142857
+ 0.43 0.14 0.43 22214286
+ 0.43 0.14 0.43 29285714
+ 0.43 0.14 0.43 36357143
+ 0.43 0.14 0.43 43428571
+ 0.43 0.14 0.43 50500000
+ 0.43 0.14 0.43 57571429
+ 0.43 0.14 0.43 64642857
+ 0.43 0.14 0.43 71714286
+ 0.43 0.14 0.43 78785714
+ 0.43 0.14 0.43 85857143
+ 0.43 0.14 0.43 92928571
+ 0.43 0.14 0.43 100000000
+ 0.43 0.14 0.50 1000000
+ 0.43 0.14 0.50 8071429
+ 0.43 0.14 0.50 15142857
+ 0.43 0.14 0.50 22214286
+ 0.43 0.14 0.50 29285714
+ 0.43 0.14 0.50 36357143
+ 0.43 0.14 0.50 43428571
+ 0.43 0.14 0.50 50500000
+ 0.43 0.14 0.50 57571429
+ 0.43 0.14 0.50 64642857
+ 0.43 0.14 0.50 71714286
+ 0.43 0.14 0.50 78785714
+ 0.43 0.14 0.50 85857143
+ 0.43 0.14 0.50 92928571
+ 0.43 0.14 0.50 100000000
+ 0.43 0.14 0.57 1000000
+ 0.43 0.14 0.57 8071429
+ 0.43 0.14 0.57 15142857
+ 0.43 0.14 0.57 22214286
+ 0.43 0.14 0.57 29285714
+ 0.43 0.14 0.57 36357143
+ 0.43 0.14 0.57 43428571
+ 0.43 0.14 0.57 50500000
+ 0.43 0.14 0.57 57571429
+ 0.43 0.14 0.57 64642857
+ 0.43 0.14 0.57 71714286
+ 0.43 0.14 0.57 78785714
+ 0.43 0.14 0.57 85857143
+ 0.43 0.14 0.57 92928571
+ 0.43 0.14 0.57 100000000
+ 0.43 0.14 0.64 1000000
+ 0.43 0.14 0.64 8071429
+ 0.43 0.14 0.64 15142857
+ 0.43 0.14 0.64 22214286
+ 0.43 0.14 0.64 29285714
+ 0.43 0.14 0.64 36357143
+ 0.43 0.14 0.64 43428571
+ 0.43 0.14 0.64 50500000
+ 0.43 0.14 0.64 57571429
+ 0.43 0.14 0.64 64642857
+ 0.43 0.14 0.64 71714286
+ 0.43 0.14 0.64 78785714
+ 0.43 0.14 0.64 85857143
+ 0.43 0.14 0.64 92928571
+ 0.43 0.14 0.64 100000000
+ 0.43 0.14 0.71 1000000
+ 0.43 0.14 0.71 8071429
+ 0.43 0.14 0.71 15142857
+ 0.43 0.14 0.71 22214286
+ 0.43 0.14 0.71 29285714
+ 0.43 0.14 0.71 36357143
+ 0.43 0.14 0.71 43428571
+ 0.43 0.14 0.71 50500000
+ 0.43 0.14 0.71 57571429
+ 0.43 0.14 0.71 64642857
+ 0.43 0.14 0.71 71714286
+ 0.43 0.14 0.71 78785714
+ 0.43 0.14 0.71 85857143
+ 0.43 0.14 0.71 92928571
+ 0.43 0.14 0.71 100000000
+ 0.43 0.14 0.79 1000000
+ 0.43 0.14 0.79 8071429
+ 0.43 0.14 0.79 15142857
+ 0.43 0.14 0.79 22214286
+ 0.43 0.14 0.79 29285714
+ 0.43 0.14 0.79 36357143
+ 0.43 0.14 0.79 43428571
+ 0.43 0.14 0.79 50500000
+ 0.43 0.14 0.79 57571429
+ 0.43 0.14 0.79 64642857
+ 0.43 0.14 0.79 71714286
+ 0.43 0.14 0.79 78785714
+ 0.43 0.14 0.79 85857143
+ 0.43 0.14 0.79 92928571
+ 0.43 0.14 0.79 100000000
+ 0.43 0.14 0.86 1000000
+ 0.43 0.14 0.86 8071429
+ 0.43 0.14 0.86 15142857
+ 0.43 0.14 0.86 22214286
+ 0.43 0.14 0.86 29285714
+ 0.43 0.14 0.86 36357143
+ 0.43 0.14 0.86 43428571
+ 0.43 0.14 0.86 50500000
+ 0.43 0.14 0.86 57571429
+ 0.43 0.14 0.86 64642857
+ 0.43 0.14 0.86 71714286
+ 0.43 0.14 0.86 78785714
+ 0.43 0.14 0.86 85857143
+ 0.43 0.14 0.86 92928571
+ 0.43 0.14 0.86 100000000
+ 0.43 0.14 0.93 1000000
+ 0.43 0.14 0.93 8071429
+ 0.43 0.14 0.93 15142857
+ 0.43 0.14 0.93 22214286
+ 0.43 0.14 0.93 29285714
+ 0.43 0.14 0.93 36357143
+ 0.43 0.14 0.93 43428571
+ 0.43 0.14 0.93 50500000
+ 0.43 0.14 0.93 57571429
+ 0.43 0.14 0.93 64642857
+ 0.43 0.14 0.93 71714286
+ 0.43 0.14 0.93 78785714
+ 0.43 0.14 0.93 85857143
+ 0.43 0.14 0.93 92928571
+ 0.43 0.14 0.93 100000000
+ 0.43 0.14 1.00 1000000
+ 0.43 0.14 1.00 8071429
+ 0.43 0.14 1.00 15142857
+ 0.43 0.14 1.00 22214286
+ 0.43 0.14 1.00 29285714
+ 0.43 0.14 1.00 36357143
+ 0.43 0.14 1.00 43428571
+ 0.43 0.14 1.00 50500000
+ 0.43 0.14 1.00 57571429
+ 0.43 0.14 1.00 64642857
+ 0.43 0.14 1.00 71714286
+ 0.43 0.14 1.00 78785714
+ 0.43 0.14 1.00 85857143
+ 0.43 0.14 1.00 92928571
+ 0.43 0.14 1.00 100000000
+ 0.43 0.21 0.00 1000000
+ 0.43 0.21 0.00 8071429
+ 0.43 0.21 0.00 15142857
+ 0.43 0.21 0.00 22214286
+ 0.43 0.21 0.00 29285714
+ 0.43 0.21 0.00 36357143
+ 0.43 0.21 0.00 43428571
+ 0.43 0.21 0.00 50500000
+ 0.43 0.21 0.00 57571429
+ 0.43 0.21 0.00 64642857
+ 0.43 0.21 0.00 71714286
+ 0.43 0.21 0.00 78785714
+ 0.43 0.21 0.00 85857143
+ 0.43 0.21 0.00 92928571
+ 0.43 0.21 0.00 100000000
+ 0.43 0.21 0.07 1000000
+ 0.43 0.21 0.07 8071429
+ 0.43 0.21 0.07 15142857
+ 0.43 0.21 0.07 22214286
+ 0.43 0.21 0.07 29285714
+ 0.43 0.21 0.07 36357143
+ 0.43 0.21 0.07 43428571
+ 0.43 0.21 0.07 50500000
+ 0.43 0.21 0.07 57571429
+ 0.43 0.21 0.07 64642857
+ 0.43 0.21 0.07 71714286
+ 0.43 0.21 0.07 78785714
+ 0.43 0.21 0.07 85857143
+ 0.43 0.21 0.07 92928571
+ 0.43 0.21 0.07 100000000
+ 0.43 0.21 0.14 1000000
+ 0.43 0.21 0.14 8071429
+ 0.43 0.21 0.14 15142857
+ 0.43 0.21 0.14 22214286
+ 0.43 0.21 0.14 29285714
+ 0.43 0.21 0.14 36357143
+ 0.43 0.21 0.14 43428571
+ 0.43 0.21 0.14 50500000
+ 0.43 0.21 0.14 57571429
+ 0.43 0.21 0.14 64642857
+ 0.43 0.21 0.14 71714286
+ 0.43 0.21 0.14 78785714
+ 0.43 0.21 0.14 85857143
+ 0.43 0.21 0.14 92928571
+ 0.43 0.21 0.14 100000000
+ 0.43 0.21 0.21 1000000
+ 0.43 0.21 0.21 8071429
+ 0.43 0.21 0.21 15142857
+ 0.43 0.21 0.21 22214286
+ 0.43 0.21 0.21 29285714
+ 0.43 0.21 0.21 36357143
+ 0.43 0.21 0.21 43428571
+ 0.43 0.21 0.21 50500000
+ 0.43 0.21 0.21 57571429
+ 0.43 0.21 0.21 64642857
+ 0.43 0.21 0.21 71714286
+ 0.43 0.21 0.21 78785714
+ 0.43 0.21 0.21 85857143
+ 0.43 0.21 0.21 92928571
+ 0.43 0.21 0.21 100000000
+ 0.43 0.21 0.29 1000000
+ 0.43 0.21 0.29 8071429
+ 0.43 0.21 0.29 15142857
+ 0.43 0.21 0.29 22214286
+ 0.43 0.21 0.29 29285714
+ 0.43 0.21 0.29 36357143
+ 0.43 0.21 0.29 43428571
+ 0.43 0.21 0.29 50500000
+ 0.43 0.21 0.29 57571429
+ 0.43 0.21 0.29 64642857
+ 0.43 0.21 0.29 71714286
+ 0.43 0.21 0.29 78785714
+ 0.43 0.21 0.29 85857143
+ 0.43 0.21 0.29 92928571
+ 0.43 0.21 0.29 100000000
+ 0.43 0.21 0.36 1000000
+ 0.43 0.21 0.36 8071429
+ 0.43 0.21 0.36 15142857
+ 0.43 0.21 0.36 22214286
+ 0.43 0.21 0.36 29285714
+ 0.43 0.21 0.36 36357143
+ 0.43 0.21 0.36 43428571
+ 0.43 0.21 0.36 50500000
+ 0.43 0.21 0.36 57571429
+ 0.43 0.21 0.36 64642857
+ 0.43 0.21 0.36 71714286
+ 0.43 0.21 0.36 78785714
+ 0.43 0.21 0.36 85857143
+ 0.43 0.21 0.36 92928571
+ 0.43 0.21 0.36 100000000
+ 0.43 0.21 0.43 1000000
+ 0.43 0.21 0.43 8071429
+ 0.43 0.21 0.43 15142857
+ 0.43 0.21 0.43 22214286
+ 0.43 0.21 0.43 29285714
+ 0.43 0.21 0.43 36357143
+ 0.43 0.21 0.43 43428571
+ 0.43 0.21 0.43 50500000
+ 0.43 0.21 0.43 57571429
+ 0.43 0.21 0.43 64642857
+ 0.43 0.21 0.43 71714286
+ 0.43 0.21 0.43 78785714
+ 0.43 0.21 0.43 85857143
+ 0.43 0.21 0.43 92928571
+ 0.43 0.21 0.43 100000000
+ 0.43 0.21 0.50 1000000
+ 0.43 0.21 0.50 8071429
+ 0.43 0.21 0.50 15142857
+ 0.43 0.21 0.50 22214286
+ 0.43 0.21 0.50 29285714
+ 0.43 0.21 0.50 36357143
+ 0.43 0.21 0.50 43428571
+ 0.43 0.21 0.50 50500000
+ 0.43 0.21 0.50 57571429
+ 0.43 0.21 0.50 64642857
+ 0.43 0.21 0.50 71714286
+ 0.43 0.21 0.50 78785714
+ 0.43 0.21 0.50 85857143
+ 0.43 0.21 0.50 92928571
+ 0.43 0.21 0.50 100000000
+ 0.43 0.21 0.57 1000000
+ 0.43 0.21 0.57 8071429
+ 0.43 0.21 0.57 15142857
+ 0.43 0.21 0.57 22214286
+ 0.43 0.21 0.57 29285714
+ 0.43 0.21 0.57 36357143
+ 0.43 0.21 0.57 43428571
+ 0.43 0.21 0.57 50500000
+ 0.43 0.21 0.57 57571429
+ 0.43 0.21 0.57 64642857
+ 0.43 0.21 0.57 71714286
+ 0.43 0.21 0.57 78785714
+ 0.43 0.21 0.57 85857143
+ 0.43 0.21 0.57 92928571
+ 0.43 0.21 0.57 100000000
+ 0.43 0.21 0.64 1000000
+ 0.43 0.21 0.64 8071429
+ 0.43 0.21 0.64 15142857
+ 0.43 0.21 0.64 22214286
+ 0.43 0.21 0.64 29285714
+ 0.43 0.21 0.64 36357143
+ 0.43 0.21 0.64 43428571
+ 0.43 0.21 0.64 50500000
+ 0.43 0.21 0.64 57571429
+ 0.43 0.21 0.64 64642857
+ 0.43 0.21 0.64 71714286
+ 0.43 0.21 0.64 78785714
+ 0.43 0.21 0.64 85857143
+ 0.43 0.21 0.64 92928571
+ 0.43 0.21 0.64 100000000
+ 0.43 0.21 0.71 1000000
+ 0.43 0.21 0.71 8071429
+ 0.43 0.21 0.71 15142857
+ 0.43 0.21 0.71 22214286
+ 0.43 0.21 0.71 29285714
+ 0.43 0.21 0.71 36357143
+ 0.43 0.21 0.71 43428571
+ 0.43 0.21 0.71 50500000
+ 0.43 0.21 0.71 57571429
+ 0.43 0.21 0.71 64642857
+ 0.43 0.21 0.71 71714286
+ 0.43 0.21 0.71 78785714
+ 0.43 0.21 0.71 85857143
+ 0.43 0.21 0.71 92928571
+ 0.43 0.21 0.71 100000000
+ 0.43 0.21 0.79 1000000
+ 0.43 0.21 0.79 8071429
+ 0.43 0.21 0.79 15142857
+ 0.43 0.21 0.79 22214286
+ 0.43 0.21 0.79 29285714
+ 0.43 0.21 0.79 36357143
+ 0.43 0.21 0.79 43428571
+ 0.43 0.21 0.79 50500000
+ 0.43 0.21 0.79 57571429
+ 0.43 0.21 0.79 64642857
+ 0.43 0.21 0.79 71714286
+ 0.43 0.21 0.79 78785714
+ 0.43 0.21 0.79 85857143
+ 0.43 0.21 0.79 92928571
+ 0.43 0.21 0.79 100000000
+ 0.43 0.21 0.86 1000000
+ 0.43 0.21 0.86 8071429
+ 0.43 0.21 0.86 15142857
+ 0.43 0.21 0.86 22214286
+ 0.43 0.21 0.86 29285714
+ 0.43 0.21 0.86 36357143
+ 0.43 0.21 0.86 43428571
+ 0.43 0.21 0.86 50500000
+ 0.43 0.21 0.86 57571429
+ 0.43 0.21 0.86 64642857
+ 0.43 0.21 0.86 71714286
+ 0.43 0.21 0.86 78785714
+ 0.43 0.21 0.86 85857143
+ 0.43 0.21 0.86 92928571
+ 0.43 0.21 0.86 100000000
+ 0.43 0.21 0.93 1000000
+ 0.43 0.21 0.93 8071429
+ 0.43 0.21 0.93 15142857
+ 0.43 0.21 0.93 22214286
+ 0.43 0.21 0.93 29285714
+ 0.43 0.21 0.93 36357143
+ 0.43 0.21 0.93 43428571
+ 0.43 0.21 0.93 50500000
+ 0.43 0.21 0.93 57571429
+ 0.43 0.21 0.93 64642857
+ 0.43 0.21 0.93 71714286
+ 0.43 0.21 0.93 78785714
+ 0.43 0.21 0.93 85857143
+ 0.43 0.21 0.93 92928571
+ 0.43 0.21 0.93 100000000
+ 0.43 0.21 1.00 1000000
+ 0.43 0.21 1.00 8071429
+ 0.43 0.21 1.00 15142857
+ 0.43 0.21 1.00 22214286
+ 0.43 0.21 1.00 29285714
+ 0.43 0.21 1.00 36357143
+ 0.43 0.21 1.00 43428571
+ 0.43 0.21 1.00 50500000
+ 0.43 0.21 1.00 57571429
+ 0.43 0.21 1.00 64642857
+ 0.43 0.21 1.00 71714286
+ 0.43 0.21 1.00 78785714
+ 0.43 0.21 1.00 85857143
+ 0.43 0.21 1.00 92928571
+ 0.43 0.21 1.00 100000000
+ 0.43 0.29 0.00 1000000
+ 0.43 0.29 0.00 8071429
+ 0.43 0.29 0.00 15142857
+ 0.43 0.29 0.00 22214286
+ 0.43 0.29 0.00 29285714
+ 0.43 0.29 0.00 36357143
+ 0.43 0.29 0.00 43428571
+ 0.43 0.29 0.00 50500000
+ 0.43 0.29 0.00 57571429
+ 0.43 0.29 0.00 64642857
+ 0.43 0.29 0.00 71714286
+ 0.43 0.29 0.00 78785714
+ 0.43 0.29 0.00 85857143
+ 0.43 0.29 0.00 92928571
+ 0.43 0.29 0.00 100000000
+ 0.43 0.29 0.07 1000000
+ 0.43 0.29 0.07 8071429
+ 0.43 0.29 0.07 15142857
+ 0.43 0.29 0.07 22214286
+ 0.43 0.29 0.07 29285714
+ 0.43 0.29 0.07 36357143
+ 0.43 0.29 0.07 43428571
+ 0.43 0.29 0.07 50500000
+ 0.43 0.29 0.07 57571429
+ 0.43 0.29 0.07 64642857
+ 0.43 0.29 0.07 71714286
+ 0.43 0.29 0.07 78785714
+ 0.43 0.29 0.07 85857143
+ 0.43 0.29 0.07 92928571
+ 0.43 0.29 0.07 100000000
+ 0.43 0.29 0.14 1000000
+ 0.43 0.29 0.14 8071429
+ 0.43 0.29 0.14 15142857
+ 0.43 0.29 0.14 22214286
+ 0.43 0.29 0.14 29285714
+ 0.43 0.29 0.14 36357143
+ 0.43 0.29 0.14 43428571
+ 0.43 0.29 0.14 50500000
+ 0.43 0.29 0.14 57571429
+ 0.43 0.29 0.14 64642857
+ 0.43 0.29 0.14 71714286
+ 0.43 0.29 0.14 78785714
+ 0.43 0.29 0.14 85857143
+ 0.43 0.29 0.14 92928571
+ 0.43 0.29 0.14 100000000
+ 0.43 0.29 0.21 1000000
+ 0.43 0.29 0.21 8071429
+ 0.43 0.29 0.21 15142857
+ 0.43 0.29 0.21 22214286
+ 0.43 0.29 0.21 29285714
+ 0.43 0.29 0.21 36357143
+ 0.43 0.29 0.21 43428571
+ 0.43 0.29 0.21 50500000
+ 0.43 0.29 0.21 57571429
+ 0.43 0.29 0.21 64642857
+ 0.43 0.29 0.21 71714286
+ 0.43 0.29 0.21 78785714
+ 0.43 0.29 0.21 85857143
+ 0.43 0.29 0.21 92928571
+ 0.43 0.29 0.21 100000000
+ 0.43 0.29 0.29 1000000
+ 0.43 0.29 0.29 8071429
+ 0.43 0.29 0.29 15142857
+ 0.43 0.29 0.29 22214286
+ 0.43 0.29 0.29 29285714
+ 0.43 0.29 0.29 36357143
+ 0.43 0.29 0.29 43428571
+ 0.43 0.29 0.29 50500000
+ 0.43 0.29 0.29 57571429
+ 0.43 0.29 0.29 64642857
+ 0.43 0.29 0.29 71714286
+ 0.43 0.29 0.29 78785714
+ 0.43 0.29 0.29 85857143
+ 0.43 0.29 0.29 92928571
+ 0.43 0.29 0.29 100000000
+ 0.43 0.29 0.36 1000000
+ 0.43 0.29 0.36 8071429
+ 0.43 0.29 0.36 15142857
+ 0.43 0.29 0.36 22214286
+ 0.43 0.29 0.36 29285714
+ 0.43 0.29 0.36 36357143
+ 0.43 0.29 0.36 43428571
+ 0.43 0.29 0.36 50500000
+ 0.43 0.29 0.36 57571429
+ 0.43 0.29 0.36 64642857
+ 0.43 0.29 0.36 71714286
+ 0.43 0.29 0.36 78785714
+ 0.43 0.29 0.36 85857143
+ 0.43 0.29 0.36 92928571
+ 0.43 0.29 0.36 100000000
+ 0.43 0.29 0.43 1000000
+ 0.43 0.29 0.43 8071429
+ 0.43 0.29 0.43 15142857
+ 0.43 0.29 0.43 22214286
+ 0.43 0.29 0.43 29285714
+ 0.43 0.29 0.43 36357143
+ 0.43 0.29 0.43 43428571
+ 0.43 0.29 0.43 50500000
+ 0.43 0.29 0.43 57571429
+ 0.43 0.29 0.43 64642857
+ 0.43 0.29 0.43 71714286
+ 0.43 0.29 0.43 78785714
+ 0.43 0.29 0.43 85857143
+ 0.43 0.29 0.43 92928571
+ 0.43 0.29 0.43 100000000
+ 0.43 0.29 0.50 1000000
+ 0.43 0.29 0.50 8071429
+ 0.43 0.29 0.50 15142857
+ 0.43 0.29 0.50 22214286
+ 0.43 0.29 0.50 29285714
+ 0.43 0.29 0.50 36357143
+ 0.43 0.29 0.50 43428571
+ 0.43 0.29 0.50 50500000
+ 0.43 0.29 0.50 57571429
+ 0.43 0.29 0.50 64642857
+ 0.43 0.29 0.50 71714286
+ 0.43 0.29 0.50 78785714
+ 0.43 0.29 0.50 85857143
+ 0.43 0.29 0.50 92928571
+ 0.43 0.29 0.50 100000000
+ 0.43 0.29 0.57 1000000
+ 0.43 0.29 0.57 8071429
+ 0.43 0.29 0.57 15142857
+ 0.43 0.29 0.57 22214286
+ 0.43 0.29 0.57 29285714
+ 0.43 0.29 0.57 36357143
+ 0.43 0.29 0.57 43428571
+ 0.43 0.29 0.57 50500000
+ 0.43 0.29 0.57 57571429
+ 0.43 0.29 0.57 64642857
+ 0.43 0.29 0.57 71714286
+ 0.43 0.29 0.57 78785714
+ 0.43 0.29 0.57 85857143
+ 0.43 0.29 0.57 92928571
+ 0.43 0.29 0.57 100000000
+ 0.43 0.29 0.64 1000000
+ 0.43 0.29 0.64 8071429
+ 0.43 0.29 0.64 15142857
+ 0.43 0.29 0.64 22214286
+ 0.43 0.29 0.64 29285714
+ 0.43 0.29 0.64 36357143
+ 0.43 0.29 0.64 43428571
+ 0.43 0.29 0.64 50500000
+ 0.43 0.29 0.64 57571429
+ 0.43 0.29 0.64 64642857
+ 0.43 0.29 0.64 71714286
+ 0.43 0.29 0.64 78785714
+ 0.43 0.29 0.64 85857143
+ 0.43 0.29 0.64 92928571
+ 0.43 0.29 0.64 100000000
+ 0.43 0.29 0.71 1000000
+ 0.43 0.29 0.71 8071429
+ 0.43 0.29 0.71 15142857
+ 0.43 0.29 0.71 22214286
+ 0.43 0.29 0.71 29285714
+ 0.43 0.29 0.71 36357143
+ 0.43 0.29 0.71 43428571
+ 0.43 0.29 0.71 50500000
+ 0.43 0.29 0.71 57571429
+ 0.43 0.29 0.71 64642857
+ 0.43 0.29 0.71 71714286
+ 0.43 0.29 0.71 78785714
+ 0.43 0.29 0.71 85857143
+ 0.43 0.29 0.71 92928571
+ 0.43 0.29 0.71 100000000
+ 0.43 0.29 0.79 1000000
+ 0.43 0.29 0.79 8071429
+ 0.43 0.29 0.79 15142857
+ 0.43 0.29 0.79 22214286
+ 0.43 0.29 0.79 29285714
+ 0.43 0.29 0.79 36357143
+ 0.43 0.29 0.79 43428571
+ 0.43 0.29 0.79 50500000
+ 0.43 0.29 0.79 57571429
+ 0.43 0.29 0.79 64642857
+ 0.43 0.29 0.79 71714286
+ 0.43 0.29 0.79 78785714
+ 0.43 0.29 0.79 85857143
+ 0.43 0.29 0.79 92928571
+ 0.43 0.29 0.79 100000000
+ 0.43 0.29 0.86 1000000
+ 0.43 0.29 0.86 8071429
+ 0.43 0.29 0.86 15142857
+ 0.43 0.29 0.86 22214286
+ 0.43 0.29 0.86 29285714
+ 0.43 0.29 0.86 36357143
+ 0.43 0.29 0.86 43428571
+ 0.43 0.29 0.86 50500000
+ 0.43 0.29 0.86 57571429
+ 0.43 0.29 0.86 64642857
+ 0.43 0.29 0.86 71714286
+ 0.43 0.29 0.86 78785714
+ 0.43 0.29 0.86 85857143
+ 0.43 0.29 0.86 92928571
+ 0.43 0.29 0.86 100000000
+ 0.43 0.29 0.93 1000000
+ 0.43 0.29 0.93 8071429
+ 0.43 0.29 0.93 15142857
+ 0.43 0.29 0.93 22214286
+ 0.43 0.29 0.93 29285714
+ 0.43 0.29 0.93 36357143
+ 0.43 0.29 0.93 43428571
+ 0.43 0.29 0.93 50500000
+ 0.43 0.29 0.93 57571429
+ 0.43 0.29 0.93 64642857
+ 0.43 0.29 0.93 71714286
+ 0.43 0.29 0.93 78785714
+ 0.43 0.29 0.93 85857143
+ 0.43 0.29 0.93 92928571
+ 0.43 0.29 0.93 100000000
+ 0.43 0.29 1.00 1000000
+ 0.43 0.29 1.00 8071429
+ 0.43 0.29 1.00 15142857
+ 0.43 0.29 1.00 22214286
+ 0.43 0.29 1.00 29285714
+ 0.43 0.29 1.00 36357143
+ 0.43 0.29 1.00 43428571
+ 0.43 0.29 1.00 50500000
+ 0.43 0.29 1.00 57571429
+ 0.43 0.29 1.00 64642857
+ 0.43 0.29 1.00 71714286
+ 0.43 0.29 1.00 78785714
+ 0.43 0.29 1.00 85857143
+ 0.43 0.29 1.00 92928571
+ 0.43 0.29 1.00 100000000
+ 0.43 0.36 0.00 1000000
+ 0.43 0.36 0.00 8071429
+ 0.43 0.36 0.00 15142857
+ 0.43 0.36 0.00 22214286
+ 0.43 0.36 0.00 29285714
+ 0.43 0.36 0.00 36357143
+ 0.43 0.36 0.00 43428571
+ 0.43 0.36 0.00 50500000
+ 0.43 0.36 0.00 57571429
+ 0.43 0.36 0.00 64642857
+ 0.43 0.36 0.00 71714286
+ 0.43 0.36 0.00 78785714
+ 0.43 0.36 0.00 85857143
+ 0.43 0.36 0.00 92928571
+ 0.43 0.36 0.00 100000000
+ 0.43 0.36 0.07 1000000
+ 0.43 0.36 0.07 8071429
+ 0.43 0.36 0.07 15142857
+ 0.43 0.36 0.07 22214286
+ 0.43 0.36 0.07 29285714
+ 0.43 0.36 0.07 36357143
+ 0.43 0.36 0.07 43428571
+ 0.43 0.36 0.07 50500000
+ 0.43 0.36 0.07 57571429
+ 0.43 0.36 0.07 64642857
+ 0.43 0.36 0.07 71714286
+ 0.43 0.36 0.07 78785714
+ 0.43 0.36 0.07 85857143
+ 0.43 0.36 0.07 92928571
+ 0.43 0.36 0.07 100000000
+ 0.43 0.36 0.14 1000000
+ 0.43 0.36 0.14 8071429
+ 0.43 0.36 0.14 15142857
+ 0.43 0.36 0.14 22214286
+ 0.43 0.36 0.14 29285714
+ 0.43 0.36 0.14 36357143
+ 0.43 0.36 0.14 43428571
+ 0.43 0.36 0.14 50500000
+ 0.43 0.36 0.14 57571429
+ 0.43 0.36 0.14 64642857
+ 0.43 0.36 0.14 71714286
+ 0.43 0.36 0.14 78785714
+ 0.43 0.36 0.14 85857143
+ 0.43 0.36 0.14 92928571
+ 0.43 0.36 0.14 100000000
+ 0.43 0.36 0.21 1000000
+ 0.43 0.36 0.21 8071429
+ 0.43 0.36 0.21 15142857
+ 0.43 0.36 0.21 22214286
+ 0.43 0.36 0.21 29285714
+ 0.43 0.36 0.21 36357143
+ 0.43 0.36 0.21 43428571
+ 0.43 0.36 0.21 50500000
+ 0.43 0.36 0.21 57571429
+ 0.43 0.36 0.21 64642857
+ 0.43 0.36 0.21 71714286
+ 0.43 0.36 0.21 78785714
+ 0.43 0.36 0.21 85857143
+ 0.43 0.36 0.21 92928571
+ 0.43 0.36 0.21 100000000
+ 0.43 0.36 0.29 1000000
+ 0.43 0.36 0.29 8071429
+ 0.43 0.36 0.29 15142857
+ 0.43 0.36 0.29 22214286
+ 0.43 0.36 0.29 29285714
+ 0.43 0.36 0.29 36357143
+ 0.43 0.36 0.29 43428571
+ 0.43 0.36 0.29 50500000
+ 0.43 0.36 0.29 57571429
+ 0.43 0.36 0.29 64642857
+ 0.43 0.36 0.29 71714286
+ 0.43 0.36 0.29 78785714
+ 0.43 0.36 0.29 85857143
+ 0.43 0.36 0.29 92928571
+ 0.43 0.36 0.29 100000000
+ 0.43 0.36 0.36 1000000
+ 0.43 0.36 0.36 8071429
+ 0.43 0.36 0.36 15142857
+ 0.43 0.36 0.36 22214286
+ 0.43 0.36 0.36 29285714
+ 0.43 0.36 0.36 36357143
+ 0.43 0.36 0.36 43428571
+ 0.43 0.36 0.36 50500000
+ 0.43 0.36 0.36 57571429
+ 0.43 0.36 0.36 64642857
+ 0.43 0.36 0.36 71714286
+ 0.43 0.36 0.36 78785714
+ 0.43 0.36 0.36 85857143
+ 0.43 0.36 0.36 92928571
+ 0.43 0.36 0.36 100000000
+ 0.43 0.36 0.43 1000000
+ 0.43 0.36 0.43 8071429
+ 0.43 0.36 0.43 15142857
+ 0.43 0.36 0.43 22214286
+ 0.43 0.36 0.43 29285714
+ 0.43 0.36 0.43 36357143
+ 0.43 0.36 0.43 43428571
+ 0.43 0.36 0.43 50500000
+ 0.43 0.36 0.43 57571429
+ 0.43 0.36 0.43 64642857
+ 0.43 0.36 0.43 71714286
+ 0.43 0.36 0.43 78785714
+ 0.43 0.36 0.43 85857143
+ 0.43 0.36 0.43 92928571
+ 0.43 0.36 0.43 100000000
+ 0.43 0.36 0.50 1000000
+ 0.43 0.36 0.50 8071429
+ 0.43 0.36 0.50 15142857
+ 0.43 0.36 0.50 22214286
+ 0.43 0.36 0.50 29285714
+ 0.43 0.36 0.50 36357143
+ 0.43 0.36 0.50 43428571
+ 0.43 0.36 0.50 50500000
+ 0.43 0.36 0.50 57571429
+ 0.43 0.36 0.50 64642857
+ 0.43 0.36 0.50 71714286
+ 0.43 0.36 0.50 78785714
+ 0.43 0.36 0.50 85857143
+ 0.43 0.36 0.50 92928571
+ 0.43 0.36 0.50 100000000
+ 0.43 0.36 0.57 1000000
+ 0.43 0.36 0.57 8071429
+ 0.43 0.36 0.57 15142857
+ 0.43 0.36 0.57 22214286
+ 0.43 0.36 0.57 29285714
+ 0.43 0.36 0.57 36357143
+ 0.43 0.36 0.57 43428571
+ 0.43 0.36 0.57 50500000
+ 0.43 0.36 0.57 57571429
+ 0.43 0.36 0.57 64642857
+ 0.43 0.36 0.57 71714286
+ 0.43 0.36 0.57 78785714
+ 0.43 0.36 0.57 85857143
+ 0.43 0.36 0.57 92928571
+ 0.43 0.36 0.57 100000000
+ 0.43 0.36 0.64 1000000
+ 0.43 0.36 0.64 8071429
+ 0.43 0.36 0.64 15142857
+ 0.43 0.36 0.64 22214286
+ 0.43 0.36 0.64 29285714
+ 0.43 0.36 0.64 36357143
+ 0.43 0.36 0.64 43428571
+ 0.43 0.36 0.64 50500000
+ 0.43 0.36 0.64 57571429
+ 0.43 0.36 0.64 64642857
+ 0.43 0.36 0.64 71714286
+ 0.43 0.36 0.64 78785714
+ 0.43 0.36 0.64 85857143
+ 0.43 0.36 0.64 92928571
+ 0.43 0.36 0.64 100000000
+ 0.43 0.36 0.71 1000000
+ 0.43 0.36 0.71 8071429
+ 0.43 0.36 0.71 15142857
+ 0.43 0.36 0.71 22214286
+ 0.43 0.36 0.71 29285714
+ 0.43 0.36 0.71 36357143
+ 0.43 0.36 0.71 43428571
+ 0.43 0.36 0.71 50500000
+ 0.43 0.36 0.71 57571429
+ 0.43 0.36 0.71 64642857
+ 0.43 0.36 0.71 71714286
+ 0.43 0.36 0.71 78785714
+ 0.43 0.36 0.71 85857143
+ 0.43 0.36 0.71 92928571
+ 0.43 0.36 0.71 100000000
+ 0.43 0.36 0.79 1000000
+ 0.43 0.36 0.79 8071429
+ 0.43 0.36 0.79 15142857
+ 0.43 0.36 0.79 22214286
+ 0.43 0.36 0.79 29285714
+ 0.43 0.36 0.79 36357143
+ 0.43 0.36 0.79 43428571
+ 0.43 0.36 0.79 50500000
+ 0.43 0.36 0.79 57571429
+ 0.43 0.36 0.79 64642857
+ 0.43 0.36 0.79 71714286
+ 0.43 0.36 0.79 78785714
+ 0.43 0.36 0.79 85857143
+ 0.43 0.36 0.79 92928571
+ 0.43 0.36 0.79 100000000
+ 0.43 0.36 0.86 1000000
+ 0.43 0.36 0.86 8071429
+ 0.43 0.36 0.86 15142857
+ 0.43 0.36 0.86 22214286
+ 0.43 0.36 0.86 29285714
+ 0.43 0.36 0.86 36357143
+ 0.43 0.36 0.86 43428571
+ 0.43 0.36 0.86 50500000
+ 0.43 0.36 0.86 57571429
+ 0.43 0.36 0.86 64642857
+ 0.43 0.36 0.86 71714286
+ 0.43 0.36 0.86 78785714
+ 0.43 0.36 0.86 85857143
+ 0.43 0.36 0.86 92928571
+ 0.43 0.36 0.86 100000000
+ 0.43 0.36 0.93 1000000
+ 0.43 0.36 0.93 8071429
+ 0.43 0.36 0.93 15142857
+ 0.43 0.36 0.93 22214286
+ 0.43 0.36 0.93 29285714
+ 0.43 0.36 0.93 36357143
+ 0.43 0.36 0.93 43428571
+ 0.43 0.36 0.93 50500000
+ 0.43 0.36 0.93 57571429
+ 0.43 0.36 0.93 64642857
+ 0.43 0.36 0.93 71714286
+ 0.43 0.36 0.93 78785714
+ 0.43 0.36 0.93 85857143
+ 0.43 0.36 0.93 92928571
+ 0.43 0.36 0.93 100000000
+ 0.43 0.36 1.00 1000000
+ 0.43 0.36 1.00 8071429
+ 0.43 0.36 1.00 15142857
+ 0.43 0.36 1.00 22214286
+ 0.43 0.36 1.00 29285714
+ 0.43 0.36 1.00 36357143
+ 0.43 0.36 1.00 43428571
+ 0.43 0.36 1.00 50500000
+ 0.43 0.36 1.00 57571429
+ 0.43 0.36 1.00 64642857
+ 0.43 0.36 1.00 71714286
+ 0.43 0.36 1.00 78785714
+ 0.43 0.36 1.00 85857143
+ 0.43 0.36 1.00 92928571
+ 0.43 0.36 1.00 100000000
+ 0.43 0.43 0.00 1000000
+ 0.43 0.43 0.00 8071429
+ 0.43 0.43 0.00 15142857
+ 0.43 0.43 0.00 22214286
+ 0.43 0.43 0.00 29285714
+ 0.43 0.43 0.00 36357143
+ 0.43 0.43 0.00 43428571
+ 0.43 0.43 0.00 50500000
+ 0.43 0.43 0.00 57571429
+ 0.43 0.43 0.00 64642857
+ 0.43 0.43 0.00 71714286
+ 0.43 0.43 0.00 78785714
+ 0.43 0.43 0.00 85857143
+ 0.43 0.43 0.00 92928571
+ 0.43 0.43 0.00 100000000
+ 0.43 0.43 0.07 1000000
+ 0.43 0.43 0.07 8071429
+ 0.43 0.43 0.07 15142857
+ 0.43 0.43 0.07 22214286
+ 0.43 0.43 0.07 29285714
+ 0.43 0.43 0.07 36357143
+ 0.43 0.43 0.07 43428571
+ 0.43 0.43 0.07 50500000
+ 0.43 0.43 0.07 57571429
+ 0.43 0.43 0.07 64642857
+ 0.43 0.43 0.07 71714286
+ 0.43 0.43 0.07 78785714
+ 0.43 0.43 0.07 85857143
+ 0.43 0.43 0.07 92928571
+ 0.43 0.43 0.07 100000000
+ 0.43 0.43 0.14 1000000
+ 0.43 0.43 0.14 8071429
+ 0.43 0.43 0.14 15142857
+ 0.43 0.43 0.14 22214286
+ 0.43 0.43 0.14 29285714
+ 0.43 0.43 0.14 36357143
+ 0.43 0.43 0.14 43428571
+ 0.43 0.43 0.14 50500000
+ 0.43 0.43 0.14 57571429
+ 0.43 0.43 0.14 64642857
+ 0.43 0.43 0.14 71714286
+ 0.43 0.43 0.14 78785714
+ 0.43 0.43 0.14 85857143
+ 0.43 0.43 0.14 92928571
+ 0.43 0.43 0.14 100000000
+ 0.43 0.43 0.21 1000000
+ 0.43 0.43 0.21 8071429
+ 0.43 0.43 0.21 15142857
+ 0.43 0.43 0.21 22214286
+ 0.43 0.43 0.21 29285714
+ 0.43 0.43 0.21 36357143
+ 0.43 0.43 0.21 43428571
+ 0.43 0.43 0.21 50500000
+ 0.43 0.43 0.21 57571429
+ 0.43 0.43 0.21 64642857
+ 0.43 0.43 0.21 71714286
+ 0.43 0.43 0.21 78785714
+ 0.43 0.43 0.21 85857143
+ 0.43 0.43 0.21 92928571
+ 0.43 0.43 0.21 100000000
+ 0.43 0.43 0.29 1000000
+ 0.43 0.43 0.29 8071429
+ 0.43 0.43 0.29 15142857
+ 0.43 0.43 0.29 22214286
+ 0.43 0.43 0.29 29285714
+ 0.43 0.43 0.29 36357143
+ 0.43 0.43 0.29 43428571
+ 0.43 0.43 0.29 50500000
+ 0.43 0.43 0.29 57571429
+ 0.43 0.43 0.29 64642857
+ 0.43 0.43 0.29 71714286
+ 0.43 0.43 0.29 78785714
+ 0.43 0.43 0.29 85857143
+ 0.43 0.43 0.29 92928571
+ 0.43 0.43 0.29 100000000
+ 0.43 0.43 0.36 1000000
+ 0.43 0.43 0.36 8071429
+ 0.43 0.43 0.36 15142857
+ 0.43 0.43 0.36 22214286
+ 0.43 0.43 0.36 29285714
+ 0.43 0.43 0.36 36357143
+ 0.43 0.43 0.36 43428571
+ 0.43 0.43 0.36 50500000
+ 0.43 0.43 0.36 57571429
+ 0.43 0.43 0.36 64642857
+ 0.43 0.43 0.36 71714286
+ 0.43 0.43 0.36 78785714
+ 0.43 0.43 0.36 85857143
+ 0.43 0.43 0.36 92928571
+ 0.43 0.43 0.36 100000000
+ 0.43 0.43 0.43 1000000
+ 0.43 0.43 0.43 8071429
+ 0.43 0.43 0.43 15142857
+ 0.43 0.43 0.43 22214286
+ 0.43 0.43 0.43 29285714
+ 0.43 0.43 0.43 36357143
+ 0.43 0.43 0.43 43428571
+ 0.43 0.43 0.43 50500000
+ 0.43 0.43 0.43 57571429
+ 0.43 0.43 0.43 64642857
+ 0.43 0.43 0.43 71714286
+ 0.43 0.43 0.43 78785714
+ 0.43 0.43 0.43 85857143
+ 0.43 0.43 0.43 92928571
+ 0.43 0.43 0.43 100000000
+ 0.43 0.43 0.50 1000000
+ 0.43 0.43 0.50 8071429
+ 0.43 0.43 0.50 15142857
+ 0.43 0.43 0.50 22214286
+ 0.43 0.43 0.50 29285714
+ 0.43 0.43 0.50 36357143
+ 0.43 0.43 0.50 43428571
+ 0.43 0.43 0.50 50500000
+ 0.43 0.43 0.50 57571429
+ 0.43 0.43 0.50 64642857
+ 0.43 0.43 0.50 71714286
+ 0.43 0.43 0.50 78785714
+ 0.43 0.43 0.50 85857143
+ 0.43 0.43 0.50 92928571
+ 0.43 0.43 0.50 100000000
+ 0.43 0.43 0.57 1000000
+ 0.43 0.43 0.57 8071429
+ 0.43 0.43 0.57 15142857
+ 0.43 0.43 0.57 22214286
+ 0.43 0.43 0.57 29285714
+ 0.43 0.43 0.57 36357143
+ 0.43 0.43 0.57 43428571
+ 0.43 0.43 0.57 50500000
+ 0.43 0.43 0.57 57571429
+ 0.43 0.43 0.57 64642857
+ 0.43 0.43 0.57 71714286
+ 0.43 0.43 0.57 78785714
+ 0.43 0.43 0.57 85857143
+ 0.43 0.43 0.57 92928571
+ 0.43 0.43 0.57 100000000
+ 0.43 0.43 0.64 1000000
+ 0.43 0.43 0.64 8071429
+ 0.43 0.43 0.64 15142857
+ 0.43 0.43 0.64 22214286
+ 0.43 0.43 0.64 29285714
+ 0.43 0.43 0.64 36357143
+ 0.43 0.43 0.64 43428571
+ 0.43 0.43 0.64 50500000
+ 0.43 0.43 0.64 57571429
+ 0.43 0.43 0.64 64642857
+ 0.43 0.43 0.64 71714286
+ 0.43 0.43 0.64 78785714
+ 0.43 0.43 0.64 85857143
+ 0.43 0.43 0.64 92928571
+ 0.43 0.43 0.64 100000000
+ 0.43 0.43 0.71 1000000
+ 0.43 0.43 0.71 8071429
+ 0.43 0.43 0.71 15142857
+ 0.43 0.43 0.71 22214286
+ 0.43 0.43 0.71 29285714
+ 0.43 0.43 0.71 36357143
+ 0.43 0.43 0.71 43428571
+ 0.43 0.43 0.71 50500000
+ 0.43 0.43 0.71 57571429
+ 0.43 0.43 0.71 64642857
+ 0.43 0.43 0.71 71714286
+ 0.43 0.43 0.71 78785714
+ 0.43 0.43 0.71 85857143
+ 0.43 0.43 0.71 92928571
+ 0.43 0.43 0.71 100000000
+ 0.43 0.43 0.79 1000000
+ 0.43 0.43 0.79 8071429
+ 0.43 0.43 0.79 15142857
+ 0.43 0.43 0.79 22214286
+ 0.43 0.43 0.79 29285714
+ 0.43 0.43 0.79 36357143
+ 0.43 0.43 0.79 43428571
+ 0.43 0.43 0.79 50500000
+ 0.43 0.43 0.79 57571429
+ 0.43 0.43 0.79 64642857
+ 0.43 0.43 0.79 71714286
+ 0.43 0.43 0.79 78785714
+ 0.43 0.43 0.79 85857143
+ 0.43 0.43 0.79 92928571
+ 0.43 0.43 0.79 100000000
+ 0.43 0.43 0.86 1000000
+ 0.43 0.43 0.86 8071429
+ 0.43 0.43 0.86 15142857
+ 0.43 0.43 0.86 22214286
+ 0.43 0.43 0.86 29285714
+ 0.43 0.43 0.86 36357143
+ 0.43 0.43 0.86 43428571
+ 0.43 0.43 0.86 50500000
+ 0.43 0.43 0.86 57571429
+ 0.43 0.43 0.86 64642857
+ 0.43 0.43 0.86 71714286
+ 0.43 0.43 0.86 78785714
+ 0.43 0.43 0.86 85857143
+ 0.43 0.43 0.86 92928571
+ 0.43 0.43 0.86 100000000
+ 0.43 0.43 0.93 1000000
+ 0.43 0.43 0.93 8071429
+ 0.43 0.43 0.93 15142857
+ 0.43 0.43 0.93 22214286
+ 0.43 0.43 0.93 29285714
+ 0.43 0.43 0.93 36357143
+ 0.43 0.43 0.93 43428571
+ 0.43 0.43 0.93 50500000
+ 0.43 0.43 0.93 57571429
+ 0.43 0.43 0.93 64642857
+ 0.43 0.43 0.93 71714286
+ 0.43 0.43 0.93 78785714
+ 0.43 0.43 0.93 85857143
+ 0.43 0.43 0.93 92928571
+ 0.43 0.43 0.93 100000000
+ 0.43 0.43 1.00 1000000
+ 0.43 0.43 1.00 8071429
+ 0.43 0.43 1.00 15142857
+ 0.43 0.43 1.00 22214286
+ 0.43 0.43 1.00 29285714
+ 0.43 0.43 1.00 36357143
+ 0.43 0.43 1.00 43428571
+ 0.43 0.43 1.00 50500000
+ 0.43 0.43 1.00 57571429
+ 0.43 0.43 1.00 64642857
+ 0.43 0.43 1.00 71714286
+ 0.43 0.43 1.00 78785714
+ 0.43 0.43 1.00 85857143
+ 0.43 0.43 1.00 92928571
+ 0.43 0.43 1.00 100000000
+ 0.43 0.50 0.00 1000000
+ 0.43 0.50 0.00 8071429
+ 0.43 0.50 0.00 15142857
+ 0.43 0.50 0.00 22214286
+ 0.43 0.50 0.00 29285714
+ 0.43 0.50 0.00 36357143
+ 0.43 0.50 0.00 43428571
+ 0.43 0.50 0.00 50500000
+ 0.43 0.50 0.00 57571429
+ 0.43 0.50 0.00 64642857
+ 0.43 0.50 0.00 71714286
+ 0.43 0.50 0.00 78785714
+ 0.43 0.50 0.00 85857143
+ 0.43 0.50 0.00 92928571
+ 0.43 0.50 0.00 100000000
+ 0.43 0.50 0.07 1000000
+ 0.43 0.50 0.07 8071429
+ 0.43 0.50 0.07 15142857
+ 0.43 0.50 0.07 22214286
+ 0.43 0.50 0.07 29285714
+ 0.43 0.50 0.07 36357143
+ 0.43 0.50 0.07 43428571
+ 0.43 0.50 0.07 50500000
+ 0.43 0.50 0.07 57571429
+ 0.43 0.50 0.07 64642857
+ 0.43 0.50 0.07 71714286
+ 0.43 0.50 0.07 78785714
+ 0.43 0.50 0.07 85857143
+ 0.43 0.50 0.07 92928571
+ 0.43 0.50 0.07 100000000
+ 0.43 0.50 0.14 1000000
+ 0.43 0.50 0.14 8071429
+ 0.43 0.50 0.14 15142857
+ 0.43 0.50 0.14 22214286
+ 0.43 0.50 0.14 29285714
+ 0.43 0.50 0.14 36357143
+ 0.43 0.50 0.14 43428571
+ 0.43 0.50 0.14 50500000
+ 0.43 0.50 0.14 57571429
+ 0.43 0.50 0.14 64642857
+ 0.43 0.50 0.14 71714286
+ 0.43 0.50 0.14 78785714
+ 0.43 0.50 0.14 85857143
+ 0.43 0.50 0.14 92928571
+ 0.43 0.50 0.14 100000000
+ 0.43 0.50 0.21 1000000
+ 0.43 0.50 0.21 8071429
+ 0.43 0.50 0.21 15142857
+ 0.43 0.50 0.21 22214286
+ 0.43 0.50 0.21 29285714
+ 0.43 0.50 0.21 36357143
+ 0.43 0.50 0.21 43428571
+ 0.43 0.50 0.21 50500000
+ 0.43 0.50 0.21 57571429
+ 0.43 0.50 0.21 64642857
+ 0.43 0.50 0.21 71714286
+ 0.43 0.50 0.21 78785714
+ 0.43 0.50 0.21 85857143
+ 0.43 0.50 0.21 92928571
+ 0.43 0.50 0.21 100000000
+ 0.43 0.50 0.29 1000000
+ 0.43 0.50 0.29 8071429
+ 0.43 0.50 0.29 15142857
+ 0.43 0.50 0.29 22214286
+ 0.43 0.50 0.29 29285714
+ 0.43 0.50 0.29 36357143
+ 0.43 0.50 0.29 43428571
+ 0.43 0.50 0.29 50500000
+ 0.43 0.50 0.29 57571429
+ 0.43 0.50 0.29 64642857
+ 0.43 0.50 0.29 71714286
+ 0.43 0.50 0.29 78785714
+ 0.43 0.50 0.29 85857143
+ 0.43 0.50 0.29 92928571
+ 0.43 0.50 0.29 100000000
+ 0.43 0.50 0.36 1000000
+ 0.43 0.50 0.36 8071429
+ 0.43 0.50 0.36 15142857
+ 0.43 0.50 0.36 22214286
+ 0.43 0.50 0.36 29285714
+ 0.43 0.50 0.36 36357143
+ 0.43 0.50 0.36 43428571
+ 0.43 0.50 0.36 50500000
+ 0.43 0.50 0.36 57571429
+ 0.43 0.50 0.36 64642857
+ 0.43 0.50 0.36 71714286
+ 0.43 0.50 0.36 78785714
+ 0.43 0.50 0.36 85857143
+ 0.43 0.50 0.36 92928571
+ 0.43 0.50 0.36 100000000
+ 0.43 0.50 0.43 1000000
+ 0.43 0.50 0.43 8071429
+ 0.43 0.50 0.43 15142857
+ 0.43 0.50 0.43 22214286
+ 0.43 0.50 0.43 29285714
+ 0.43 0.50 0.43 36357143
+ 0.43 0.50 0.43 43428571
+ 0.43 0.50 0.43 50500000
+ 0.43 0.50 0.43 57571429
+ 0.43 0.50 0.43 64642857
+ 0.43 0.50 0.43 71714286
+ 0.43 0.50 0.43 78785714
+ 0.43 0.50 0.43 85857143
+ 0.43 0.50 0.43 92928571
+ 0.43 0.50 0.43 100000000
+ 0.43 0.50 0.50 1000000
+ 0.43 0.50 0.50 8071429
+ 0.43 0.50 0.50 15142857
+ 0.43 0.50 0.50 22214286
+ 0.43 0.50 0.50 29285714
+ 0.43 0.50 0.50 36357143
+ 0.43 0.50 0.50 43428571
+ 0.43 0.50 0.50 50500000
+ 0.43 0.50 0.50 57571429
+ 0.43 0.50 0.50 64642857
+ 0.43 0.50 0.50 71714286
+ 0.43 0.50 0.50 78785714
+ 0.43 0.50 0.50 85857143
+ 0.43 0.50 0.50 92928571
+ 0.43 0.50 0.50 100000000
+ 0.43 0.50 0.57 1000000
+ 0.43 0.50 0.57 8071429
+ 0.43 0.50 0.57 15142857
+ 0.43 0.50 0.57 22214286
+ 0.43 0.50 0.57 29285714
+ 0.43 0.50 0.57 36357143
+ 0.43 0.50 0.57 43428571
+ 0.43 0.50 0.57 50500000
+ 0.43 0.50 0.57 57571429
+ 0.43 0.50 0.57 64642857
+ 0.43 0.50 0.57 71714286
+ 0.43 0.50 0.57 78785714
+ 0.43 0.50 0.57 85857143
+ 0.43 0.50 0.57 92928571
+ 0.43 0.50 0.57 100000000
+ 0.43 0.50 0.64 1000000
+ 0.43 0.50 0.64 8071429
+ 0.43 0.50 0.64 15142857
+ 0.43 0.50 0.64 22214286
+ 0.43 0.50 0.64 29285714
+ 0.43 0.50 0.64 36357143
+ 0.43 0.50 0.64 43428571
+ 0.43 0.50 0.64 50500000
+ 0.43 0.50 0.64 57571429
+ 0.43 0.50 0.64 64642857
+ 0.43 0.50 0.64 71714286
+ 0.43 0.50 0.64 78785714
+ 0.43 0.50 0.64 85857143
+ 0.43 0.50 0.64 92928571
+ 0.43 0.50 0.64 100000000
+ 0.43 0.50 0.71 1000000
+ 0.43 0.50 0.71 8071429
+ 0.43 0.50 0.71 15142857
+ 0.43 0.50 0.71 22214286
+ 0.43 0.50 0.71 29285714
+ 0.43 0.50 0.71 36357143
+ 0.43 0.50 0.71 43428571
+ 0.43 0.50 0.71 50500000
+ 0.43 0.50 0.71 57571429
+ 0.43 0.50 0.71 64642857
+ 0.43 0.50 0.71 71714286
+ 0.43 0.50 0.71 78785714
+ 0.43 0.50 0.71 85857143
+ 0.43 0.50 0.71 92928571
+ 0.43 0.50 0.71 100000000
+ 0.43 0.50 0.79 1000000
+ 0.43 0.50 0.79 8071429
+ 0.43 0.50 0.79 15142857
+ 0.43 0.50 0.79 22214286
+ 0.43 0.50 0.79 29285714
+ 0.43 0.50 0.79 36357143
+ 0.43 0.50 0.79 43428571
+ 0.43 0.50 0.79 50500000
+ 0.43 0.50 0.79 57571429
+ 0.43 0.50 0.79 64642857
+ 0.43 0.50 0.79 71714286
+ 0.43 0.50 0.79 78785714
+ 0.43 0.50 0.79 85857143
+ 0.43 0.50 0.79 92928571
+ 0.43 0.50 0.79 100000000
+ 0.43 0.50 0.86 1000000
+ 0.43 0.50 0.86 8071429
+ 0.43 0.50 0.86 15142857
+ 0.43 0.50 0.86 22214286
+ 0.43 0.50 0.86 29285714
+ 0.43 0.50 0.86 36357143
+ 0.43 0.50 0.86 43428571
+ 0.43 0.50 0.86 50500000
+ 0.43 0.50 0.86 57571429
+ 0.43 0.50 0.86 64642857
+ 0.43 0.50 0.86 71714286
+ 0.43 0.50 0.86 78785714
+ 0.43 0.50 0.86 85857143
+ 0.43 0.50 0.86 92928571
+ 0.43 0.50 0.86 100000000
+ 0.43 0.50 0.93 1000000
+ 0.43 0.50 0.93 8071429
+ 0.43 0.50 0.93 15142857
+ 0.43 0.50 0.93 22214286
+ 0.43 0.50 0.93 29285714
+ 0.43 0.50 0.93 36357143
+ 0.43 0.50 0.93 43428571
+ 0.43 0.50 0.93 50500000
+ 0.43 0.50 0.93 57571429
+ 0.43 0.50 0.93 64642857
+ 0.43 0.50 0.93 71714286
+ 0.43 0.50 0.93 78785714
+ 0.43 0.50 0.93 85857143
+ 0.43 0.50 0.93 92928571
+ 0.43 0.50 0.93 100000000
+ 0.43 0.50 1.00 1000000
+ 0.43 0.50 1.00 8071429
+ 0.43 0.50 1.00 15142857
+ 0.43 0.50 1.00 22214286
+ 0.43 0.50 1.00 29285714
+ 0.43 0.50 1.00 36357143
+ 0.43 0.50 1.00 43428571
+ 0.43 0.50 1.00 50500000
+ 0.43 0.50 1.00 57571429
+ 0.43 0.50 1.00 64642857
+ 0.43 0.50 1.00 71714286
+ 0.43 0.50 1.00 78785714
+ 0.43 0.50 1.00 85857143
+ 0.43 0.50 1.00 92928571
+ 0.43 0.50 1.00 100000000
+ 0.43 0.57 0.00 1000000
+ 0.43 0.57 0.00 8071429
+ 0.43 0.57 0.00 15142857
+ 0.43 0.57 0.00 22214286
+ 0.43 0.57 0.00 29285714
+ 0.43 0.57 0.00 36357143
+ 0.43 0.57 0.00 43428571
+ 0.43 0.57 0.00 50500000
+ 0.43 0.57 0.00 57571429
+ 0.43 0.57 0.00 64642857
+ 0.43 0.57 0.00 71714286
+ 0.43 0.57 0.00 78785714
+ 0.43 0.57 0.00 85857143
+ 0.43 0.57 0.00 92928571
+ 0.43 0.57 0.00 100000000
+ 0.43 0.57 0.07 1000000
+ 0.43 0.57 0.07 8071429
+ 0.43 0.57 0.07 15142857
+ 0.43 0.57 0.07 22214286
+ 0.43 0.57 0.07 29285714
+ 0.43 0.57 0.07 36357143
+ 0.43 0.57 0.07 43428571
+ 0.43 0.57 0.07 50500000
+ 0.43 0.57 0.07 57571429
+ 0.43 0.57 0.07 64642857
+ 0.43 0.57 0.07 71714286
+ 0.43 0.57 0.07 78785714
+ 0.43 0.57 0.07 85857143
+ 0.43 0.57 0.07 92928571
+ 0.43 0.57 0.07 100000000
+ 0.43 0.57 0.14 1000000
+ 0.43 0.57 0.14 8071429
+ 0.43 0.57 0.14 15142857
+ 0.43 0.57 0.14 22214286
+ 0.43 0.57 0.14 29285714
+ 0.43 0.57 0.14 36357143
+ 0.43 0.57 0.14 43428571
+ 0.43 0.57 0.14 50500000
+ 0.43 0.57 0.14 57571429
+ 0.43 0.57 0.14 64642857
+ 0.43 0.57 0.14 71714286
+ 0.43 0.57 0.14 78785714
+ 0.43 0.57 0.14 85857143
+ 0.43 0.57 0.14 92928571
+ 0.43 0.57 0.14 100000000
+ 0.43 0.57 0.21 1000000
+ 0.43 0.57 0.21 8071429
+ 0.43 0.57 0.21 15142857
+ 0.43 0.57 0.21 22214286
+ 0.43 0.57 0.21 29285714
+ 0.43 0.57 0.21 36357143
+ 0.43 0.57 0.21 43428571
+ 0.43 0.57 0.21 50500000
+ 0.43 0.57 0.21 57571429
+ 0.43 0.57 0.21 64642857
+ 0.43 0.57 0.21 71714286
+ 0.43 0.57 0.21 78785714
+ 0.43 0.57 0.21 85857143
+ 0.43 0.57 0.21 92928571
+ 0.43 0.57 0.21 100000000
+ 0.43 0.57 0.29 1000000
+ 0.43 0.57 0.29 8071429
+ 0.43 0.57 0.29 15142857
+ 0.43 0.57 0.29 22214286
+ 0.43 0.57 0.29 29285714
+ 0.43 0.57 0.29 36357143
+ 0.43 0.57 0.29 43428571
+ 0.43 0.57 0.29 50500000
+ 0.43 0.57 0.29 57571429
+ 0.43 0.57 0.29 64642857
+ 0.43 0.57 0.29 71714286
+ 0.43 0.57 0.29 78785714
+ 0.43 0.57 0.29 85857143
+ 0.43 0.57 0.29 92928571
+ 0.43 0.57 0.29 100000000
+ 0.43 0.57 0.36 1000000
+ 0.43 0.57 0.36 8071429
+ 0.43 0.57 0.36 15142857
+ 0.43 0.57 0.36 22214286
+ 0.43 0.57 0.36 29285714
+ 0.43 0.57 0.36 36357143
+ 0.43 0.57 0.36 43428571
+ 0.43 0.57 0.36 50500000
+ 0.43 0.57 0.36 57571429
+ 0.43 0.57 0.36 64642857
+ 0.43 0.57 0.36 71714286
+ 0.43 0.57 0.36 78785714
+ 0.43 0.57 0.36 85857143
+ 0.43 0.57 0.36 92928571
+ 0.43 0.57 0.36 100000000
+ 0.43 0.57 0.43 1000000
+ 0.43 0.57 0.43 8071429
+ 0.43 0.57 0.43 15142857
+ 0.43 0.57 0.43 22214286
+ 0.43 0.57 0.43 29285714
+ 0.43 0.57 0.43 36357143
+ 0.43 0.57 0.43 43428571
+ 0.43 0.57 0.43 50500000
+ 0.43 0.57 0.43 57571429
+ 0.43 0.57 0.43 64642857
+ 0.43 0.57 0.43 71714286
+ 0.43 0.57 0.43 78785714
+ 0.43 0.57 0.43 85857143
+ 0.43 0.57 0.43 92928571
+ 0.43 0.57 0.43 100000000
+ 0.43 0.57 0.50 1000000
+ 0.43 0.57 0.50 8071429
+ 0.43 0.57 0.50 15142857
+ 0.43 0.57 0.50 22214286
+ 0.43 0.57 0.50 29285714
+ 0.43 0.57 0.50 36357143
+ 0.43 0.57 0.50 43428571
+ 0.43 0.57 0.50 50500000
+ 0.43 0.57 0.50 57571429
+ 0.43 0.57 0.50 64642857
+ 0.43 0.57 0.50 71714286
+ 0.43 0.57 0.50 78785714
+ 0.43 0.57 0.50 85857143
+ 0.43 0.57 0.50 92928571
+ 0.43 0.57 0.50 100000000
+ 0.43 0.57 0.57 1000000
+ 0.43 0.57 0.57 8071429
+ 0.43 0.57 0.57 15142857
+ 0.43 0.57 0.57 22214286
+ 0.43 0.57 0.57 29285714
+ 0.43 0.57 0.57 36357143
+ 0.43 0.57 0.57 43428571
+ 0.43 0.57 0.57 50500000
+ 0.43 0.57 0.57 57571429
+ 0.43 0.57 0.57 64642857
+ 0.43 0.57 0.57 71714286
+ 0.43 0.57 0.57 78785714
+ 0.43 0.57 0.57 85857143
+ 0.43 0.57 0.57 92928571
+ 0.43 0.57 0.57 100000000
+ 0.43 0.57 0.64 1000000
+ 0.43 0.57 0.64 8071429
+ 0.43 0.57 0.64 15142857
+ 0.43 0.57 0.64 22214286
+ 0.43 0.57 0.64 29285714
+ 0.43 0.57 0.64 36357143
+ 0.43 0.57 0.64 43428571
+ 0.43 0.57 0.64 50500000
+ 0.43 0.57 0.64 57571429
+ 0.43 0.57 0.64 64642857
+ 0.43 0.57 0.64 71714286
+ 0.43 0.57 0.64 78785714
+ 0.43 0.57 0.64 85857143
+ 0.43 0.57 0.64 92928571
+ 0.43 0.57 0.64 100000000
+ 0.43 0.57 0.71 1000000
+ 0.43 0.57 0.71 8071429
+ 0.43 0.57 0.71 15142857
+ 0.43 0.57 0.71 22214286
+ 0.43 0.57 0.71 29285714
+ 0.43 0.57 0.71 36357143
+ 0.43 0.57 0.71 43428571
+ 0.43 0.57 0.71 50500000
+ 0.43 0.57 0.71 57571429
+ 0.43 0.57 0.71 64642857
+ 0.43 0.57 0.71 71714286
+ 0.43 0.57 0.71 78785714
+ 0.43 0.57 0.71 85857143
+ 0.43 0.57 0.71 92928571
+ 0.43 0.57 0.71 100000000
+ 0.43 0.57 0.79 1000000
+ 0.43 0.57 0.79 8071429
+ 0.43 0.57 0.79 15142857
+ 0.43 0.57 0.79 22214286
+ 0.43 0.57 0.79 29285714
+ 0.43 0.57 0.79 36357143
+ 0.43 0.57 0.79 43428571
+ 0.43 0.57 0.79 50500000
+ 0.43 0.57 0.79 57571429
+ 0.43 0.57 0.79 64642857
+ 0.43 0.57 0.79 71714286
+ 0.43 0.57 0.79 78785714
+ 0.43 0.57 0.79 85857143
+ 0.43 0.57 0.79 92928571
+ 0.43 0.57 0.79 100000000
+ 0.43 0.57 0.86 1000000
+ 0.43 0.57 0.86 8071429
+ 0.43 0.57 0.86 15142857
+ 0.43 0.57 0.86 22214286
+ 0.43 0.57 0.86 29285714
+ 0.43 0.57 0.86 36357143
+ 0.43 0.57 0.86 43428571
+ 0.43 0.57 0.86 50500000
+ 0.43 0.57 0.86 57571429
+ 0.43 0.57 0.86 64642857
+ 0.43 0.57 0.86 71714286
+ 0.43 0.57 0.86 78785714
+ 0.43 0.57 0.86 85857143
+ 0.43 0.57 0.86 92928571
+ 0.43 0.57 0.86 100000000
+ 0.43 0.57 0.93 1000000
+ 0.43 0.57 0.93 8071429
+ 0.43 0.57 0.93 15142857
+ 0.43 0.57 0.93 22214286
+ 0.43 0.57 0.93 29285714
+ 0.43 0.57 0.93 36357143
+ 0.43 0.57 0.93 43428571
+ 0.43 0.57 0.93 50500000
+ 0.43 0.57 0.93 57571429
+ 0.43 0.57 0.93 64642857
+ 0.43 0.57 0.93 71714286
+ 0.43 0.57 0.93 78785714
+ 0.43 0.57 0.93 85857143
+ 0.43 0.57 0.93 92928571
+ 0.43 0.57 0.93 100000000
+ 0.43 0.57 1.00 1000000
+ 0.43 0.57 1.00 8071429
+ 0.43 0.57 1.00 15142857
+ 0.43 0.57 1.00 22214286
+ 0.43 0.57 1.00 29285714
+ 0.43 0.57 1.00 36357143
+ 0.43 0.57 1.00 43428571
+ 0.43 0.57 1.00 50500000
+ 0.43 0.57 1.00 57571429
+ 0.43 0.57 1.00 64642857
+ 0.43 0.57 1.00 71714286
+ 0.43 0.57 1.00 78785714
+ 0.43 0.57 1.00 85857143
+ 0.43 0.57 1.00 92928571
+ 0.43 0.57 1.00 100000000
+ 0.43 0.64 0.00 1000000
+ 0.43 0.64 0.00 8071429
+ 0.43 0.64 0.00 15142857
+ 0.43 0.64 0.00 22214286
+ 0.43 0.64 0.00 29285714
+ 0.43 0.64 0.00 36357143
+ 0.43 0.64 0.00 43428571
+ 0.43 0.64 0.00 50500000
+ 0.43 0.64 0.00 57571429
+ 0.43 0.64 0.00 64642857
+ 0.43 0.64 0.00 71714286
+ 0.43 0.64 0.00 78785714
+ 0.43 0.64 0.00 85857143
+ 0.43 0.64 0.00 92928571
+ 0.43 0.64 0.00 100000000
+ 0.43 0.64 0.07 1000000
+ 0.43 0.64 0.07 8071429
+ 0.43 0.64 0.07 15142857
+ 0.43 0.64 0.07 22214286
+ 0.43 0.64 0.07 29285714
+ 0.43 0.64 0.07 36357143
+ 0.43 0.64 0.07 43428571
+ 0.43 0.64 0.07 50500000
+ 0.43 0.64 0.07 57571429
+ 0.43 0.64 0.07 64642857
+ 0.43 0.64 0.07 71714286
+ 0.43 0.64 0.07 78785714
+ 0.43 0.64 0.07 85857143
+ 0.43 0.64 0.07 92928571
+ 0.43 0.64 0.07 100000000
+ 0.43 0.64 0.14 1000000
+ 0.43 0.64 0.14 8071429
+ 0.43 0.64 0.14 15142857
+ 0.43 0.64 0.14 22214286
+ 0.43 0.64 0.14 29285714
+ 0.43 0.64 0.14 36357143
+ 0.43 0.64 0.14 43428571
+ 0.43 0.64 0.14 50500000
+ 0.43 0.64 0.14 57571429
+ 0.43 0.64 0.14 64642857
+ 0.43 0.64 0.14 71714286
+ 0.43 0.64 0.14 78785714
+ 0.43 0.64 0.14 85857143
+ 0.43 0.64 0.14 92928571
+ 0.43 0.64 0.14 100000000
+ 0.43 0.64 0.21 1000000
+ 0.43 0.64 0.21 8071429
+ 0.43 0.64 0.21 15142857
+ 0.43 0.64 0.21 22214286
+ 0.43 0.64 0.21 29285714
+ 0.43 0.64 0.21 36357143
+ 0.43 0.64 0.21 43428571
+ 0.43 0.64 0.21 50500000
+ 0.43 0.64 0.21 57571429
+ 0.43 0.64 0.21 64642857
+ 0.43 0.64 0.21 71714286
+ 0.43 0.64 0.21 78785714
+ 0.43 0.64 0.21 85857143
+ 0.43 0.64 0.21 92928571
+ 0.43 0.64 0.21 100000000
+ 0.43 0.64 0.29 1000000
+ 0.43 0.64 0.29 8071429
+ 0.43 0.64 0.29 15142857
+ 0.43 0.64 0.29 22214286
+ 0.43 0.64 0.29 29285714
+ 0.43 0.64 0.29 36357143
+ 0.43 0.64 0.29 43428571
+ 0.43 0.64 0.29 50500000
+ 0.43 0.64 0.29 57571429
+ 0.43 0.64 0.29 64642857
+ 0.43 0.64 0.29 71714286
+ 0.43 0.64 0.29 78785714
+ 0.43 0.64 0.29 85857143
+ 0.43 0.64 0.29 92928571
+ 0.43 0.64 0.29 100000000
+ 0.43 0.64 0.36 1000000
+ 0.43 0.64 0.36 8071429
+ 0.43 0.64 0.36 15142857
+ 0.43 0.64 0.36 22214286
+ 0.43 0.64 0.36 29285714
+ 0.43 0.64 0.36 36357143
+ 0.43 0.64 0.36 43428571
+ 0.43 0.64 0.36 50500000
+ 0.43 0.64 0.36 57571429
+ 0.43 0.64 0.36 64642857
+ 0.43 0.64 0.36 71714286
+ 0.43 0.64 0.36 78785714
+ 0.43 0.64 0.36 85857143
+ 0.43 0.64 0.36 92928571
+ 0.43 0.64 0.36 100000000
+ 0.43 0.64 0.43 1000000
+ 0.43 0.64 0.43 8071429
+ 0.43 0.64 0.43 15142857
+ 0.43 0.64 0.43 22214286
+ 0.43 0.64 0.43 29285714
+ 0.43 0.64 0.43 36357143
+ 0.43 0.64 0.43 43428571
+ 0.43 0.64 0.43 50500000
+ 0.43 0.64 0.43 57571429
+ 0.43 0.64 0.43 64642857
+ 0.43 0.64 0.43 71714286
+ 0.43 0.64 0.43 78785714
+ 0.43 0.64 0.43 85857143
+ 0.43 0.64 0.43 92928571
+ 0.43 0.64 0.43 100000000
+ 0.43 0.64 0.50 1000000
+ 0.43 0.64 0.50 8071429
+ 0.43 0.64 0.50 15142857
+ 0.43 0.64 0.50 22214286
+ 0.43 0.64 0.50 29285714
+ 0.43 0.64 0.50 36357143
+ 0.43 0.64 0.50 43428571
+ 0.43 0.64 0.50 50500000
+ 0.43 0.64 0.50 57571429
+ 0.43 0.64 0.50 64642857
+ 0.43 0.64 0.50 71714286
+ 0.43 0.64 0.50 78785714
+ 0.43 0.64 0.50 85857143
+ 0.43 0.64 0.50 92928571
+ 0.43 0.64 0.50 100000000
+ 0.43 0.64 0.57 1000000
+ 0.43 0.64 0.57 8071429
+ 0.43 0.64 0.57 15142857
+ 0.43 0.64 0.57 22214286
+ 0.43 0.64 0.57 29285714
+ 0.43 0.64 0.57 36357143
+ 0.43 0.64 0.57 43428571
+ 0.43 0.64 0.57 50500000
+ 0.43 0.64 0.57 57571429
+ 0.43 0.64 0.57 64642857
+ 0.43 0.64 0.57 71714286
+ 0.43 0.64 0.57 78785714
+ 0.43 0.64 0.57 85857143
+ 0.43 0.64 0.57 92928571
+ 0.43 0.64 0.57 100000000
+ 0.43 0.64 0.64 1000000
+ 0.43 0.64 0.64 8071429
+ 0.43 0.64 0.64 15142857
+ 0.43 0.64 0.64 22214286
+ 0.43 0.64 0.64 29285714
+ 0.43 0.64 0.64 36357143
+ 0.43 0.64 0.64 43428571
+ 0.43 0.64 0.64 50500000
+ 0.43 0.64 0.64 57571429
+ 0.43 0.64 0.64 64642857
+ 0.43 0.64 0.64 71714286
+ 0.43 0.64 0.64 78785714
+ 0.43 0.64 0.64 85857143
+ 0.43 0.64 0.64 92928571
+ 0.43 0.64 0.64 100000000
+ 0.43 0.64 0.71 1000000
+ 0.43 0.64 0.71 8071429
+ 0.43 0.64 0.71 15142857
+ 0.43 0.64 0.71 22214286
+ 0.43 0.64 0.71 29285714
+ 0.43 0.64 0.71 36357143
+ 0.43 0.64 0.71 43428571
+ 0.43 0.64 0.71 50500000
+ 0.43 0.64 0.71 57571429
+ 0.43 0.64 0.71 64642857
+ 0.43 0.64 0.71 71714286
+ 0.43 0.64 0.71 78785714
+ 0.43 0.64 0.71 85857143
+ 0.43 0.64 0.71 92928571
+ 0.43 0.64 0.71 100000000
+ 0.43 0.64 0.79 1000000
+ 0.43 0.64 0.79 8071429
+ 0.43 0.64 0.79 15142857
+ 0.43 0.64 0.79 22214286
+ 0.43 0.64 0.79 29285714
+ 0.43 0.64 0.79 36357143
+ 0.43 0.64 0.79 43428571
+ 0.43 0.64 0.79 50500000
+ 0.43 0.64 0.79 57571429
+ 0.43 0.64 0.79 64642857
+ 0.43 0.64 0.79 71714286
+ 0.43 0.64 0.79 78785714
+ 0.43 0.64 0.79 85857143
+ 0.43 0.64 0.79 92928571
+ 0.43 0.64 0.79 100000000
+ 0.43 0.64 0.86 1000000
+ 0.43 0.64 0.86 8071429
+ 0.43 0.64 0.86 15142857
+ 0.43 0.64 0.86 22214286
+ 0.43 0.64 0.86 29285714
+ 0.43 0.64 0.86 36357143
+ 0.43 0.64 0.86 43428571
+ 0.43 0.64 0.86 50500000
+ 0.43 0.64 0.86 57571429
+ 0.43 0.64 0.86 64642857
+ 0.43 0.64 0.86 71714286
+ 0.43 0.64 0.86 78785714
+ 0.43 0.64 0.86 85857143
+ 0.43 0.64 0.86 92928571
+ 0.43 0.64 0.86 100000000
+ 0.43 0.64 0.93 1000000
+ 0.43 0.64 0.93 8071429
+ 0.43 0.64 0.93 15142857
+ 0.43 0.64 0.93 22214286
+ 0.43 0.64 0.93 29285714
+ 0.43 0.64 0.93 36357143
+ 0.43 0.64 0.93 43428571
+ 0.43 0.64 0.93 50500000
+ 0.43 0.64 0.93 57571429
+ 0.43 0.64 0.93 64642857
+ 0.43 0.64 0.93 71714286
+ 0.43 0.64 0.93 78785714
+ 0.43 0.64 0.93 85857143
+ 0.43 0.64 0.93 92928571
+ 0.43 0.64 0.93 100000000
+ 0.43 0.64 1.00 1000000
+ 0.43 0.64 1.00 8071429
+ 0.43 0.64 1.00 15142857
+ 0.43 0.64 1.00 22214286
+ 0.43 0.64 1.00 29285714
+ 0.43 0.64 1.00 36357143
+ 0.43 0.64 1.00 43428571
+ 0.43 0.64 1.00 50500000
+ 0.43 0.64 1.00 57571429
+ 0.43 0.64 1.00 64642857
+ 0.43 0.64 1.00 71714286
+ 0.43 0.64 1.00 78785714
+ 0.43 0.64 1.00 85857143
+ 0.43 0.64 1.00 92928571
+ 0.43 0.64 1.00 100000000
+ 0.43 0.71 0.00 1000000
+ 0.43 0.71 0.00 8071429
+ 0.43 0.71 0.00 15142857
+ 0.43 0.71 0.00 22214286
+ 0.43 0.71 0.00 29285714
+ 0.43 0.71 0.00 36357143
+ 0.43 0.71 0.00 43428571
+ 0.43 0.71 0.00 50500000
+ 0.43 0.71 0.00 57571429
+ 0.43 0.71 0.00 64642857
+ 0.43 0.71 0.00 71714286
+ 0.43 0.71 0.00 78785714
+ 0.43 0.71 0.00 85857143
+ 0.43 0.71 0.00 92928571
+ 0.43 0.71 0.00 100000000
+ 0.43 0.71 0.07 1000000
+ 0.43 0.71 0.07 8071429
+ 0.43 0.71 0.07 15142857
+ 0.43 0.71 0.07 22214286
+ 0.43 0.71 0.07 29285714
+ 0.43 0.71 0.07 36357143
+ 0.43 0.71 0.07 43428571
+ 0.43 0.71 0.07 50500000
+ 0.43 0.71 0.07 57571429
+ 0.43 0.71 0.07 64642857
+ 0.43 0.71 0.07 71714286
+ 0.43 0.71 0.07 78785714
+ 0.43 0.71 0.07 85857143
+ 0.43 0.71 0.07 92928571
+ 0.43 0.71 0.07 100000000
+ 0.43 0.71 0.14 1000000
+ 0.43 0.71 0.14 8071429
+ 0.43 0.71 0.14 15142857
+ 0.43 0.71 0.14 22214286
+ 0.43 0.71 0.14 29285714
+ 0.43 0.71 0.14 36357143
+ 0.43 0.71 0.14 43428571
+ 0.43 0.71 0.14 50500000
+ 0.43 0.71 0.14 57571429
+ 0.43 0.71 0.14 64642857
+ 0.43 0.71 0.14 71714286
+ 0.43 0.71 0.14 78785714
+ 0.43 0.71 0.14 85857143
+ 0.43 0.71 0.14 92928571
+ 0.43 0.71 0.14 100000000
+ 0.43 0.71 0.21 1000000
+ 0.43 0.71 0.21 8071429
+ 0.43 0.71 0.21 15142857
+ 0.43 0.71 0.21 22214286
+ 0.43 0.71 0.21 29285714
+ 0.43 0.71 0.21 36357143
+ 0.43 0.71 0.21 43428571
+ 0.43 0.71 0.21 50500000
+ 0.43 0.71 0.21 57571429
+ 0.43 0.71 0.21 64642857
+ 0.43 0.71 0.21 71714286
+ 0.43 0.71 0.21 78785714
+ 0.43 0.71 0.21 85857143
+ 0.43 0.71 0.21 92928571
+ 0.43 0.71 0.21 100000000
+ 0.43 0.71 0.29 1000000
+ 0.43 0.71 0.29 8071429
+ 0.43 0.71 0.29 15142857
+ 0.43 0.71 0.29 22214286
+ 0.43 0.71 0.29 29285714
+ 0.43 0.71 0.29 36357143
+ 0.43 0.71 0.29 43428571
+ 0.43 0.71 0.29 50500000
+ 0.43 0.71 0.29 57571429
+ 0.43 0.71 0.29 64642857
+ 0.43 0.71 0.29 71714286
+ 0.43 0.71 0.29 78785714
+ 0.43 0.71 0.29 85857143
+ 0.43 0.71 0.29 92928571
+ 0.43 0.71 0.29 100000000
+ 0.43 0.71 0.36 1000000
+ 0.43 0.71 0.36 8071429
+ 0.43 0.71 0.36 15142857
+ 0.43 0.71 0.36 22214286
+ 0.43 0.71 0.36 29285714
+ 0.43 0.71 0.36 36357143
+ 0.43 0.71 0.36 43428571
+ 0.43 0.71 0.36 50500000
+ 0.43 0.71 0.36 57571429
+ 0.43 0.71 0.36 64642857
+ 0.43 0.71 0.36 71714286
+ 0.43 0.71 0.36 78785714
+ 0.43 0.71 0.36 85857143
+ 0.43 0.71 0.36 92928571
+ 0.43 0.71 0.36 100000000
+ 0.43 0.71 0.43 1000000
+ 0.43 0.71 0.43 8071429
+ 0.43 0.71 0.43 15142857
+ 0.43 0.71 0.43 22214286
+ 0.43 0.71 0.43 29285714
+ 0.43 0.71 0.43 36357143
+ 0.43 0.71 0.43 43428571
+ 0.43 0.71 0.43 50500000
+ 0.43 0.71 0.43 57571429
+ 0.43 0.71 0.43 64642857
+ 0.43 0.71 0.43 71714286
+ 0.43 0.71 0.43 78785714
+ 0.43 0.71 0.43 85857143
+ 0.43 0.71 0.43 92928571
+ 0.43 0.71 0.43 100000000
+ 0.43 0.71 0.50 1000000
+ 0.43 0.71 0.50 8071429
+ 0.43 0.71 0.50 15142857
+ 0.43 0.71 0.50 22214286
+ 0.43 0.71 0.50 29285714
+ 0.43 0.71 0.50 36357143
+ 0.43 0.71 0.50 43428571
+ 0.43 0.71 0.50 50500000
+ 0.43 0.71 0.50 57571429
+ 0.43 0.71 0.50 64642857
+ 0.43 0.71 0.50 71714286
+ 0.43 0.71 0.50 78785714
+ 0.43 0.71 0.50 85857143
+ 0.43 0.71 0.50 92928571
+ 0.43 0.71 0.50 100000000
+ 0.43 0.71 0.57 1000000
+ 0.43 0.71 0.57 8071429
+ 0.43 0.71 0.57 15142857
+ 0.43 0.71 0.57 22214286
+ 0.43 0.71 0.57 29285714
+ 0.43 0.71 0.57 36357143
+ 0.43 0.71 0.57 43428571
+ 0.43 0.71 0.57 50500000
+ 0.43 0.71 0.57 57571429
+ 0.43 0.71 0.57 64642857
+ 0.43 0.71 0.57 71714286
+ 0.43 0.71 0.57 78785714
+ 0.43 0.71 0.57 85857143
+ 0.43 0.71 0.57 92928571
+ 0.43 0.71 0.57 100000000
+ 0.43 0.71 0.64 1000000
+ 0.43 0.71 0.64 8071429
+ 0.43 0.71 0.64 15142857
+ 0.43 0.71 0.64 22214286
+ 0.43 0.71 0.64 29285714
+ 0.43 0.71 0.64 36357143
+ 0.43 0.71 0.64 43428571
+ 0.43 0.71 0.64 50500000
+ 0.43 0.71 0.64 57571429
+ 0.43 0.71 0.64 64642857
+ 0.43 0.71 0.64 71714286
+ 0.43 0.71 0.64 78785714
+ 0.43 0.71 0.64 85857143
+ 0.43 0.71 0.64 92928571
+ 0.43 0.71 0.64 100000000
+ 0.43 0.71 0.71 1000000
+ 0.43 0.71 0.71 8071429
+ 0.43 0.71 0.71 15142857
+ 0.43 0.71 0.71 22214286
+ 0.43 0.71 0.71 29285714
+ 0.43 0.71 0.71 36357143
+ 0.43 0.71 0.71 43428571
+ 0.43 0.71 0.71 50500000
+ 0.43 0.71 0.71 57571429
+ 0.43 0.71 0.71 64642857
+ 0.43 0.71 0.71 71714286
+ 0.43 0.71 0.71 78785714
+ 0.43 0.71 0.71 85857143
+ 0.43 0.71 0.71 92928571
+ 0.43 0.71 0.71 100000000
+ 0.43 0.71 0.79 1000000
+ 0.43 0.71 0.79 8071429
+ 0.43 0.71 0.79 15142857
+ 0.43 0.71 0.79 22214286
+ 0.43 0.71 0.79 29285714
+ 0.43 0.71 0.79 36357143
+ 0.43 0.71 0.79 43428571
+ 0.43 0.71 0.79 50500000
+ 0.43 0.71 0.79 57571429
+ 0.43 0.71 0.79 64642857
+ 0.43 0.71 0.79 71714286
+ 0.43 0.71 0.79 78785714
+ 0.43 0.71 0.79 85857143
+ 0.43 0.71 0.79 92928571
+ 0.43 0.71 0.79 100000000
+ 0.43 0.71 0.86 1000000
+ 0.43 0.71 0.86 8071429
+ 0.43 0.71 0.86 15142857
+ 0.43 0.71 0.86 22214286
+ 0.43 0.71 0.86 29285714
+ 0.43 0.71 0.86 36357143
+ 0.43 0.71 0.86 43428571
+ 0.43 0.71 0.86 50500000
+ 0.43 0.71 0.86 57571429
+ 0.43 0.71 0.86 64642857
+ 0.43 0.71 0.86 71714286
+ 0.43 0.71 0.86 78785714
+ 0.43 0.71 0.86 85857143
+ 0.43 0.71 0.86 92928571
+ 0.43 0.71 0.86 100000000
+ 0.43 0.71 0.93 1000000
+ 0.43 0.71 0.93 8071429
+ 0.43 0.71 0.93 15142857
+ 0.43 0.71 0.93 22214286
+ 0.43 0.71 0.93 29285714
+ 0.43 0.71 0.93 36357143
+ 0.43 0.71 0.93 43428571
+ 0.43 0.71 0.93 50500000
+ 0.43 0.71 0.93 57571429
+ 0.43 0.71 0.93 64642857
+ 0.43 0.71 0.93 71714286
+ 0.43 0.71 0.93 78785714
+ 0.43 0.71 0.93 85857143
+ 0.43 0.71 0.93 92928571
+ 0.43 0.71 0.93 100000000
+ 0.43 0.71 1.00 1000000
+ 0.43 0.71 1.00 8071429
+ 0.43 0.71 1.00 15142857
+ 0.43 0.71 1.00 22214286
+ 0.43 0.71 1.00 29285714
+ 0.43 0.71 1.00 36357143
+ 0.43 0.71 1.00 43428571
+ 0.43 0.71 1.00 50500000
+ 0.43 0.71 1.00 57571429
+ 0.43 0.71 1.00 64642857
+ 0.43 0.71 1.00 71714286
+ 0.43 0.71 1.00 78785714
+ 0.43 0.71 1.00 85857143
+ 0.43 0.71 1.00 92928571
+ 0.43 0.71 1.00 100000000
+ 0.43 0.79 0.00 1000000
+ 0.43 0.79 0.00 8071429
+ 0.43 0.79 0.00 15142857
+ 0.43 0.79 0.00 22214286
+ 0.43 0.79 0.00 29285714
+ 0.43 0.79 0.00 36357143
+ 0.43 0.79 0.00 43428571
+ 0.43 0.79 0.00 50500000
+ 0.43 0.79 0.00 57571429
+ 0.43 0.79 0.00 64642857
+ 0.43 0.79 0.00 71714286
+ 0.43 0.79 0.00 78785714
+ 0.43 0.79 0.00 85857143
+ 0.43 0.79 0.00 92928571
+ 0.43 0.79 0.00 100000000
+ 0.43 0.79 0.07 1000000
+ 0.43 0.79 0.07 8071429
+ 0.43 0.79 0.07 15142857
+ 0.43 0.79 0.07 22214286
+ 0.43 0.79 0.07 29285714
+ 0.43 0.79 0.07 36357143
+ 0.43 0.79 0.07 43428571
+ 0.43 0.79 0.07 50500000
+ 0.43 0.79 0.07 57571429
+ 0.43 0.79 0.07 64642857
+ 0.43 0.79 0.07 71714286
+ 0.43 0.79 0.07 78785714
+ 0.43 0.79 0.07 85857143
+ 0.43 0.79 0.07 92928571
+ 0.43 0.79 0.07 100000000
+ 0.43 0.79 0.14 1000000
+ 0.43 0.79 0.14 8071429
+ 0.43 0.79 0.14 15142857
+ 0.43 0.79 0.14 22214286
+ 0.43 0.79 0.14 29285714
+ 0.43 0.79 0.14 36357143
+ 0.43 0.79 0.14 43428571
+ 0.43 0.79 0.14 50500000
+ 0.43 0.79 0.14 57571429
+ 0.43 0.79 0.14 64642857
+ 0.43 0.79 0.14 71714286
+ 0.43 0.79 0.14 78785714
+ 0.43 0.79 0.14 85857143
+ 0.43 0.79 0.14 92928571
+ 0.43 0.79 0.14 100000000
+ 0.43 0.79 0.21 1000000
+ 0.43 0.79 0.21 8071429
+ 0.43 0.79 0.21 15142857
+ 0.43 0.79 0.21 22214286
+ 0.43 0.79 0.21 29285714
+ 0.43 0.79 0.21 36357143
+ 0.43 0.79 0.21 43428571
+ 0.43 0.79 0.21 50500000
+ 0.43 0.79 0.21 57571429
+ 0.43 0.79 0.21 64642857
+ 0.43 0.79 0.21 71714286
+ 0.43 0.79 0.21 78785714
+ 0.43 0.79 0.21 85857143
+ 0.43 0.79 0.21 92928571
+ 0.43 0.79 0.21 100000000
+ 0.43 0.79 0.29 1000000
+ 0.43 0.79 0.29 8071429
+ 0.43 0.79 0.29 15142857
+ 0.43 0.79 0.29 22214286
+ 0.43 0.79 0.29 29285714
+ 0.43 0.79 0.29 36357143
+ 0.43 0.79 0.29 43428571
+ 0.43 0.79 0.29 50500000
+ 0.43 0.79 0.29 57571429
+ 0.43 0.79 0.29 64642857
+ 0.43 0.79 0.29 71714286
+ 0.43 0.79 0.29 78785714
+ 0.43 0.79 0.29 85857143
+ 0.43 0.79 0.29 92928571
+ 0.43 0.79 0.29 100000000
+ 0.43 0.79 0.36 1000000
+ 0.43 0.79 0.36 8071429
+ 0.43 0.79 0.36 15142857
+ 0.43 0.79 0.36 22214286
+ 0.43 0.79 0.36 29285714
+ 0.43 0.79 0.36 36357143
+ 0.43 0.79 0.36 43428571
+ 0.43 0.79 0.36 50500000
+ 0.43 0.79 0.36 57571429
+ 0.43 0.79 0.36 64642857
+ 0.43 0.79 0.36 71714286
+ 0.43 0.79 0.36 78785714
+ 0.43 0.79 0.36 85857143
+ 0.43 0.79 0.36 92928571
+ 0.43 0.79 0.36 100000000
+ 0.43 0.79 0.43 1000000
+ 0.43 0.79 0.43 8071429
+ 0.43 0.79 0.43 15142857
+ 0.43 0.79 0.43 22214286
+ 0.43 0.79 0.43 29285714
+ 0.43 0.79 0.43 36357143
+ 0.43 0.79 0.43 43428571
+ 0.43 0.79 0.43 50500000
+ 0.43 0.79 0.43 57571429
+ 0.43 0.79 0.43 64642857
+ 0.43 0.79 0.43 71714286
+ 0.43 0.79 0.43 78785714
+ 0.43 0.79 0.43 85857143
+ 0.43 0.79 0.43 92928571
+ 0.43 0.79 0.43 100000000
+ 0.43 0.79 0.50 1000000
+ 0.43 0.79 0.50 8071429
+ 0.43 0.79 0.50 15142857
+ 0.43 0.79 0.50 22214286
+ 0.43 0.79 0.50 29285714
+ 0.43 0.79 0.50 36357143
+ 0.43 0.79 0.50 43428571
+ 0.43 0.79 0.50 50500000
+ 0.43 0.79 0.50 57571429
+ 0.43 0.79 0.50 64642857
+ 0.43 0.79 0.50 71714286
+ 0.43 0.79 0.50 78785714
+ 0.43 0.79 0.50 85857143
+ 0.43 0.79 0.50 92928571
+ 0.43 0.79 0.50 100000000
+ 0.43 0.79 0.57 1000000
+ 0.43 0.79 0.57 8071429
+ 0.43 0.79 0.57 15142857
+ 0.43 0.79 0.57 22214286
+ 0.43 0.79 0.57 29285714
+ 0.43 0.79 0.57 36357143
+ 0.43 0.79 0.57 43428571
+ 0.43 0.79 0.57 50500000
+ 0.43 0.79 0.57 57571429
+ 0.43 0.79 0.57 64642857
+ 0.43 0.79 0.57 71714286
+ 0.43 0.79 0.57 78785714
+ 0.43 0.79 0.57 85857143
+ 0.43 0.79 0.57 92928571
+ 0.43 0.79 0.57 100000000
+ 0.43 0.79 0.64 1000000
+ 0.43 0.79 0.64 8071429
+ 0.43 0.79 0.64 15142857
+ 0.43 0.79 0.64 22214286
+ 0.43 0.79 0.64 29285714
+ 0.43 0.79 0.64 36357143
+ 0.43 0.79 0.64 43428571
+ 0.43 0.79 0.64 50500000
+ 0.43 0.79 0.64 57571429
+ 0.43 0.79 0.64 64642857
+ 0.43 0.79 0.64 71714286
+ 0.43 0.79 0.64 78785714
+ 0.43 0.79 0.64 85857143
+ 0.43 0.79 0.64 92928571
+ 0.43 0.79 0.64 100000000
+ 0.43 0.79 0.71 1000000
+ 0.43 0.79 0.71 8071429
+ 0.43 0.79 0.71 15142857
+ 0.43 0.79 0.71 22214286
+ 0.43 0.79 0.71 29285714
+ 0.43 0.79 0.71 36357143
+ 0.43 0.79 0.71 43428571
+ 0.43 0.79 0.71 50500000
+ 0.43 0.79 0.71 57571429
+ 0.43 0.79 0.71 64642857
+ 0.43 0.79 0.71 71714286
+ 0.43 0.79 0.71 78785714
+ 0.43 0.79 0.71 85857143
+ 0.43 0.79 0.71 92928571
+ 0.43 0.79 0.71 100000000
+ 0.43 0.79 0.79 1000000
+ 0.43 0.79 0.79 8071429
+ 0.43 0.79 0.79 15142857
+ 0.43 0.79 0.79 22214286
+ 0.43 0.79 0.79 29285714
+ 0.43 0.79 0.79 36357143
+ 0.43 0.79 0.79 43428571
+ 0.43 0.79 0.79 50500000
+ 0.43 0.79 0.79 57571429
+ 0.43 0.79 0.79 64642857
+ 0.43 0.79 0.79 71714286
+ 0.43 0.79 0.79 78785714
+ 0.43 0.79 0.79 85857143
+ 0.43 0.79 0.79 92928571
+ 0.43 0.79 0.79 100000000
+ 0.43 0.79 0.86 1000000
+ 0.43 0.79 0.86 8071429
+ 0.43 0.79 0.86 15142857
+ 0.43 0.79 0.86 22214286
+ 0.43 0.79 0.86 29285714
+ 0.43 0.79 0.86 36357143
+ 0.43 0.79 0.86 43428571
+ 0.43 0.79 0.86 50500000
+ 0.43 0.79 0.86 57571429
+ 0.43 0.79 0.86 64642857
+ 0.43 0.79 0.86 71714286
+ 0.43 0.79 0.86 78785714
+ 0.43 0.79 0.86 85857143
+ 0.43 0.79 0.86 92928571
+ 0.43 0.79 0.86 100000000
+ 0.43 0.79 0.93 1000000
+ 0.43 0.79 0.93 8071429
+ 0.43 0.79 0.93 15142857
+ 0.43 0.79 0.93 22214286
+ 0.43 0.79 0.93 29285714
+ 0.43 0.79 0.93 36357143
+ 0.43 0.79 0.93 43428571
+ 0.43 0.79 0.93 50500000
+ 0.43 0.79 0.93 57571429
+ 0.43 0.79 0.93 64642857
+ 0.43 0.79 0.93 71714286
+ 0.43 0.79 0.93 78785714
+ 0.43 0.79 0.93 85857143
+ 0.43 0.79 0.93 92928571
+ 0.43 0.79 0.93 100000000
+ 0.43 0.79 1.00 1000000
+ 0.43 0.79 1.00 8071429
+ 0.43 0.79 1.00 15142857
+ 0.43 0.79 1.00 22214286
+ 0.43 0.79 1.00 29285714
+ 0.43 0.79 1.00 36357143
+ 0.43 0.79 1.00 43428571
+ 0.43 0.79 1.00 50500000
+ 0.43 0.79 1.00 57571429
+ 0.43 0.79 1.00 64642857
+ 0.43 0.79 1.00 71714286
+ 0.43 0.79 1.00 78785714
+ 0.43 0.79 1.00 85857143
+ 0.43 0.79 1.00 92928571
+ 0.43 0.79 1.00 100000000
+ 0.43 0.86 0.00 1000000
+ 0.43 0.86 0.00 8071429
+ 0.43 0.86 0.00 15142857
+ 0.43 0.86 0.00 22214286
+ 0.43 0.86 0.00 29285714
+ 0.43 0.86 0.00 36357143
+ 0.43 0.86 0.00 43428571
+ 0.43 0.86 0.00 50500000
+ 0.43 0.86 0.00 57571429
+ 0.43 0.86 0.00 64642857
+ 0.43 0.86 0.00 71714286
+ 0.43 0.86 0.00 78785714
+ 0.43 0.86 0.00 85857143
+ 0.43 0.86 0.00 92928571
+ 0.43 0.86 0.00 100000000
+ 0.43 0.86 0.07 1000000
+ 0.43 0.86 0.07 8071429
+ 0.43 0.86 0.07 15142857
+ 0.43 0.86 0.07 22214286
+ 0.43 0.86 0.07 29285714
+ 0.43 0.86 0.07 36357143
+ 0.43 0.86 0.07 43428571
+ 0.43 0.86 0.07 50500000
+ 0.43 0.86 0.07 57571429
+ 0.43 0.86 0.07 64642857
+ 0.43 0.86 0.07 71714286
+ 0.43 0.86 0.07 78785714
+ 0.43 0.86 0.07 85857143
+ 0.43 0.86 0.07 92928571
+ 0.43 0.86 0.07 100000000
+ 0.43 0.86 0.14 1000000
+ 0.43 0.86 0.14 8071429
+ 0.43 0.86 0.14 15142857
+ 0.43 0.86 0.14 22214286
+ 0.43 0.86 0.14 29285714
+ 0.43 0.86 0.14 36357143
+ 0.43 0.86 0.14 43428571
+ 0.43 0.86 0.14 50500000
+ 0.43 0.86 0.14 57571429
+ 0.43 0.86 0.14 64642857
+ 0.43 0.86 0.14 71714286
+ 0.43 0.86 0.14 78785714
+ 0.43 0.86 0.14 85857143
+ 0.43 0.86 0.14 92928571
+ 0.43 0.86 0.14 100000000
+ 0.43 0.86 0.21 1000000
+ 0.43 0.86 0.21 8071429
+ 0.43 0.86 0.21 15142857
+ 0.43 0.86 0.21 22214286
+ 0.43 0.86 0.21 29285714
+ 0.43 0.86 0.21 36357143
+ 0.43 0.86 0.21 43428571
+ 0.43 0.86 0.21 50500000
+ 0.43 0.86 0.21 57571429
+ 0.43 0.86 0.21 64642857
+ 0.43 0.86 0.21 71714286
+ 0.43 0.86 0.21 78785714
+ 0.43 0.86 0.21 85857143
+ 0.43 0.86 0.21 92928571
+ 0.43 0.86 0.21 100000000
+ 0.43 0.86 0.29 1000000
+ 0.43 0.86 0.29 8071429
+ 0.43 0.86 0.29 15142857
+ 0.43 0.86 0.29 22214286
+ 0.43 0.86 0.29 29285714
+ 0.43 0.86 0.29 36357143
+ 0.43 0.86 0.29 43428571
+ 0.43 0.86 0.29 50500000
+ 0.43 0.86 0.29 57571429
+ 0.43 0.86 0.29 64642857
+ 0.43 0.86 0.29 71714286
+ 0.43 0.86 0.29 78785714
+ 0.43 0.86 0.29 85857143
+ 0.43 0.86 0.29 92928571
+ 0.43 0.86 0.29 100000000
+ 0.43 0.86 0.36 1000000
+ 0.43 0.86 0.36 8071429
+ 0.43 0.86 0.36 15142857
+ 0.43 0.86 0.36 22214286
+ 0.43 0.86 0.36 29285714
+ 0.43 0.86 0.36 36357143
+ 0.43 0.86 0.36 43428571
+ 0.43 0.86 0.36 50500000
+ 0.43 0.86 0.36 57571429
+ 0.43 0.86 0.36 64642857
+ 0.43 0.86 0.36 71714286
+ 0.43 0.86 0.36 78785714
+ 0.43 0.86 0.36 85857143
+ 0.43 0.86 0.36 92928571
+ 0.43 0.86 0.36 100000000
+ 0.43 0.86 0.43 1000000
+ 0.43 0.86 0.43 8071429
+ 0.43 0.86 0.43 15142857
+ 0.43 0.86 0.43 22214286
+ 0.43 0.86 0.43 29285714
+ 0.43 0.86 0.43 36357143
+ 0.43 0.86 0.43 43428571
+ 0.43 0.86 0.43 50500000
+ 0.43 0.86 0.43 57571429
+ 0.43 0.86 0.43 64642857
+ 0.43 0.86 0.43 71714286
+ 0.43 0.86 0.43 78785714
+ 0.43 0.86 0.43 85857143
+ 0.43 0.86 0.43 92928571
+ 0.43 0.86 0.43 100000000
+ 0.43 0.86 0.50 1000000
+ 0.43 0.86 0.50 8071429
+ 0.43 0.86 0.50 15142857
+ 0.43 0.86 0.50 22214286
+ 0.43 0.86 0.50 29285714
+ 0.43 0.86 0.50 36357143
+ 0.43 0.86 0.50 43428571
+ 0.43 0.86 0.50 50500000
+ 0.43 0.86 0.50 57571429
+ 0.43 0.86 0.50 64642857
+ 0.43 0.86 0.50 71714286
+ 0.43 0.86 0.50 78785714
+ 0.43 0.86 0.50 85857143
+ 0.43 0.86 0.50 92928571
+ 0.43 0.86 0.50 100000000
+ 0.43 0.86 0.57 1000000
+ 0.43 0.86 0.57 8071429
+ 0.43 0.86 0.57 15142857
+ 0.43 0.86 0.57 22214286
+ 0.43 0.86 0.57 29285714
+ 0.43 0.86 0.57 36357143
+ 0.43 0.86 0.57 43428571
+ 0.43 0.86 0.57 50500000
+ 0.43 0.86 0.57 57571429
+ 0.43 0.86 0.57 64642857
+ 0.43 0.86 0.57 71714286
+ 0.43 0.86 0.57 78785714
+ 0.43 0.86 0.57 85857143
+ 0.43 0.86 0.57 92928571
+ 0.43 0.86 0.57 100000000
+ 0.43 0.86 0.64 1000000
+ 0.43 0.86 0.64 8071429
+ 0.43 0.86 0.64 15142857
+ 0.43 0.86 0.64 22214286
+ 0.43 0.86 0.64 29285714
+ 0.43 0.86 0.64 36357143
+ 0.43 0.86 0.64 43428571
+ 0.43 0.86 0.64 50500000
+ 0.43 0.86 0.64 57571429
+ 0.43 0.86 0.64 64642857
+ 0.43 0.86 0.64 71714286
+ 0.43 0.86 0.64 78785714
+ 0.43 0.86 0.64 85857143
+ 0.43 0.86 0.64 92928571
+ 0.43 0.86 0.64 100000000
+ 0.43 0.86 0.71 1000000
+ 0.43 0.86 0.71 8071429
+ 0.43 0.86 0.71 15142857
+ 0.43 0.86 0.71 22214286
+ 0.43 0.86 0.71 29285714
+ 0.43 0.86 0.71 36357143
+ 0.43 0.86 0.71 43428571
+ 0.43 0.86 0.71 50500000
+ 0.43 0.86 0.71 57571429
+ 0.43 0.86 0.71 64642857
+ 0.43 0.86 0.71 71714286
+ 0.43 0.86 0.71 78785714
+ 0.43 0.86 0.71 85857143
+ 0.43 0.86 0.71 92928571
+ 0.43 0.86 0.71 100000000
+ 0.43 0.86 0.79 1000000
+ 0.43 0.86 0.79 8071429
+ 0.43 0.86 0.79 15142857
+ 0.43 0.86 0.79 22214286
+ 0.43 0.86 0.79 29285714
+ 0.43 0.86 0.79 36357143
+ 0.43 0.86 0.79 43428571
+ 0.43 0.86 0.79 50500000
+ 0.43 0.86 0.79 57571429
+ 0.43 0.86 0.79 64642857
+ 0.43 0.86 0.79 71714286
+ 0.43 0.86 0.79 78785714
+ 0.43 0.86 0.79 85857143
+ 0.43 0.86 0.79 92928571
+ 0.43 0.86 0.79 100000000
+ 0.43 0.86 0.86 1000000
+ 0.43 0.86 0.86 8071429
+ 0.43 0.86 0.86 15142857
+ 0.43 0.86 0.86 22214286
+ 0.43 0.86 0.86 29285714
+ 0.43 0.86 0.86 36357143
+ 0.43 0.86 0.86 43428571
+ 0.43 0.86 0.86 50500000
+ 0.43 0.86 0.86 57571429
+ 0.43 0.86 0.86 64642857
+ 0.43 0.86 0.86 71714286
+ 0.43 0.86 0.86 78785714
+ 0.43 0.86 0.86 85857143
+ 0.43 0.86 0.86 92928571
+ 0.43 0.86 0.86 100000000
+ 0.43 0.86 0.93 1000000
+ 0.43 0.86 0.93 8071429
+ 0.43 0.86 0.93 15142857
+ 0.43 0.86 0.93 22214286
+ 0.43 0.86 0.93 29285714
+ 0.43 0.86 0.93 36357143
+ 0.43 0.86 0.93 43428571
+ 0.43 0.86 0.93 50500000
+ 0.43 0.86 0.93 57571429
+ 0.43 0.86 0.93 64642857
+ 0.43 0.86 0.93 71714286
+ 0.43 0.86 0.93 78785714
+ 0.43 0.86 0.93 85857143
+ 0.43 0.86 0.93 92928571
+ 0.43 0.86 0.93 100000000
+ 0.43 0.86 1.00 1000000
+ 0.43 0.86 1.00 8071429
+ 0.43 0.86 1.00 15142857
+ 0.43 0.86 1.00 22214286
+ 0.43 0.86 1.00 29285714
+ 0.43 0.86 1.00 36357143
+ 0.43 0.86 1.00 43428571
+ 0.43 0.86 1.00 50500000
+ 0.43 0.86 1.00 57571429
+ 0.43 0.86 1.00 64642857
+ 0.43 0.86 1.00 71714286
+ 0.43 0.86 1.00 78785714
+ 0.43 0.86 1.00 85857143
+ 0.43 0.86 1.00 92928571
+ 0.43 0.86 1.00 100000000
+ 0.43 0.93 0.00 1000000
+ 0.43 0.93 0.00 8071429
+ 0.43 0.93 0.00 15142857
+ 0.43 0.93 0.00 22214286
+ 0.43 0.93 0.00 29285714
+ 0.43 0.93 0.00 36357143
+ 0.43 0.93 0.00 43428571
+ 0.43 0.93 0.00 50500000
+ 0.43 0.93 0.00 57571429
+ 0.43 0.93 0.00 64642857
+ 0.43 0.93 0.00 71714286
+ 0.43 0.93 0.00 78785714
+ 0.43 0.93 0.00 85857143
+ 0.43 0.93 0.00 92928571
+ 0.43 0.93 0.00 100000000
+ 0.43 0.93 0.07 1000000
+ 0.43 0.93 0.07 8071429
+ 0.43 0.93 0.07 15142857
+ 0.43 0.93 0.07 22214286
+ 0.43 0.93 0.07 29285714
+ 0.43 0.93 0.07 36357143
+ 0.43 0.93 0.07 43428571
+ 0.43 0.93 0.07 50500000
+ 0.43 0.93 0.07 57571429
+ 0.43 0.93 0.07 64642857
+ 0.43 0.93 0.07 71714286
+ 0.43 0.93 0.07 78785714
+ 0.43 0.93 0.07 85857143
+ 0.43 0.93 0.07 92928571
+ 0.43 0.93 0.07 100000000
+ 0.43 0.93 0.14 1000000
+ 0.43 0.93 0.14 8071429
+ 0.43 0.93 0.14 15142857
+ 0.43 0.93 0.14 22214286
+ 0.43 0.93 0.14 29285714
+ 0.43 0.93 0.14 36357143
+ 0.43 0.93 0.14 43428571
+ 0.43 0.93 0.14 50500000
+ 0.43 0.93 0.14 57571429
+ 0.43 0.93 0.14 64642857
+ 0.43 0.93 0.14 71714286
+ 0.43 0.93 0.14 78785714
+ 0.43 0.93 0.14 85857143
+ 0.43 0.93 0.14 92928571
+ 0.43 0.93 0.14 100000000
+ 0.43 0.93 0.21 1000000
+ 0.43 0.93 0.21 8071429
+ 0.43 0.93 0.21 15142857
+ 0.43 0.93 0.21 22214286
+ 0.43 0.93 0.21 29285714
+ 0.43 0.93 0.21 36357143
+ 0.43 0.93 0.21 43428571
+ 0.43 0.93 0.21 50500000
+ 0.43 0.93 0.21 57571429
+ 0.43 0.93 0.21 64642857
+ 0.43 0.93 0.21 71714286
+ 0.43 0.93 0.21 78785714
+ 0.43 0.93 0.21 85857143
+ 0.43 0.93 0.21 92928571
+ 0.43 0.93 0.21 100000000
+ 0.43 0.93 0.29 1000000
+ 0.43 0.93 0.29 8071429
+ 0.43 0.93 0.29 15142857
+ 0.43 0.93 0.29 22214286
+ 0.43 0.93 0.29 29285714
+ 0.43 0.93 0.29 36357143
+ 0.43 0.93 0.29 43428571
+ 0.43 0.93 0.29 50500000
+ 0.43 0.93 0.29 57571429
+ 0.43 0.93 0.29 64642857
+ 0.43 0.93 0.29 71714286
+ 0.43 0.93 0.29 78785714
+ 0.43 0.93 0.29 85857143
+ 0.43 0.93 0.29 92928571
+ 0.43 0.93 0.29 100000000
+ 0.43 0.93 0.36 1000000
+ 0.43 0.93 0.36 8071429
+ 0.43 0.93 0.36 15142857
+ 0.43 0.93 0.36 22214286
+ 0.43 0.93 0.36 29285714
+ 0.43 0.93 0.36 36357143
+ 0.43 0.93 0.36 43428571
+ 0.43 0.93 0.36 50500000
+ 0.43 0.93 0.36 57571429
+ 0.43 0.93 0.36 64642857
+ 0.43 0.93 0.36 71714286
+ 0.43 0.93 0.36 78785714
+ 0.43 0.93 0.36 85857143
+ 0.43 0.93 0.36 92928571
+ 0.43 0.93 0.36 100000000
+ 0.43 0.93 0.43 1000000
+ 0.43 0.93 0.43 8071429
+ 0.43 0.93 0.43 15142857
+ 0.43 0.93 0.43 22214286
+ 0.43 0.93 0.43 29285714
+ 0.43 0.93 0.43 36357143
+ 0.43 0.93 0.43 43428571
+ 0.43 0.93 0.43 50500000
+ 0.43 0.93 0.43 57571429
+ 0.43 0.93 0.43 64642857
+ 0.43 0.93 0.43 71714286
+ 0.43 0.93 0.43 78785714
+ 0.43 0.93 0.43 85857143
+ 0.43 0.93 0.43 92928571
+ 0.43 0.93 0.43 100000000
+ 0.43 0.93 0.50 1000000
+ 0.43 0.93 0.50 8071429
+ 0.43 0.93 0.50 15142857
+ 0.43 0.93 0.50 22214286
+ 0.43 0.93 0.50 29285714
+ 0.43 0.93 0.50 36357143
+ 0.43 0.93 0.50 43428571
+ 0.43 0.93 0.50 50500000
+ 0.43 0.93 0.50 57571429
+ 0.43 0.93 0.50 64642857
+ 0.43 0.93 0.50 71714286
+ 0.43 0.93 0.50 78785714
+ 0.43 0.93 0.50 85857143
+ 0.43 0.93 0.50 92928571
+ 0.43 0.93 0.50 100000000
+ 0.43 0.93 0.57 1000000
+ 0.43 0.93 0.57 8071429
+ 0.43 0.93 0.57 15142857
+ 0.43 0.93 0.57 22214286
+ 0.43 0.93 0.57 29285714
+ 0.43 0.93 0.57 36357143
+ 0.43 0.93 0.57 43428571
+ 0.43 0.93 0.57 50500000
+ 0.43 0.93 0.57 57571429
+ 0.43 0.93 0.57 64642857
+ 0.43 0.93 0.57 71714286
+ 0.43 0.93 0.57 78785714
+ 0.43 0.93 0.57 85857143
+ 0.43 0.93 0.57 92928571
+ 0.43 0.93 0.57 100000000
+ 0.43 0.93 0.64 1000000
+ 0.43 0.93 0.64 8071429
+ 0.43 0.93 0.64 15142857
+ 0.43 0.93 0.64 22214286
+ 0.43 0.93 0.64 29285714
+ 0.43 0.93 0.64 36357143
+ 0.43 0.93 0.64 43428571
+ 0.43 0.93 0.64 50500000
+ 0.43 0.93 0.64 57571429
+ 0.43 0.93 0.64 64642857
+ 0.43 0.93 0.64 71714286
+ 0.43 0.93 0.64 78785714
+ 0.43 0.93 0.64 85857143
+ 0.43 0.93 0.64 92928571
+ 0.43 0.93 0.64 100000000
+ 0.43 0.93 0.71 1000000
+ 0.43 0.93 0.71 8071429
+ 0.43 0.93 0.71 15142857
+ 0.43 0.93 0.71 22214286
+ 0.43 0.93 0.71 29285714
+ 0.43 0.93 0.71 36357143
+ 0.43 0.93 0.71 43428571
+ 0.43 0.93 0.71 50500000
+ 0.43 0.93 0.71 57571429
+ 0.43 0.93 0.71 64642857
+ 0.43 0.93 0.71 71714286
+ 0.43 0.93 0.71 78785714
+ 0.43 0.93 0.71 85857143
+ 0.43 0.93 0.71 92928571
+ 0.43 0.93 0.71 100000000
+ 0.43 0.93 0.79 1000000
+ 0.43 0.93 0.79 8071429
+ 0.43 0.93 0.79 15142857
+ 0.43 0.93 0.79 22214286
+ 0.43 0.93 0.79 29285714
+ 0.43 0.93 0.79 36357143
+ 0.43 0.93 0.79 43428571
+ 0.43 0.93 0.79 50500000
+ 0.43 0.93 0.79 57571429
+ 0.43 0.93 0.79 64642857
+ 0.43 0.93 0.79 71714286
+ 0.43 0.93 0.79 78785714
+ 0.43 0.93 0.79 85857143
+ 0.43 0.93 0.79 92928571
+ 0.43 0.93 0.79 100000000
+ 0.43 0.93 0.86 1000000
+ 0.43 0.93 0.86 8071429
+ 0.43 0.93 0.86 15142857
+ 0.43 0.93 0.86 22214286
+ 0.43 0.93 0.86 29285714
+ 0.43 0.93 0.86 36357143
+ 0.43 0.93 0.86 43428571
+ 0.43 0.93 0.86 50500000
+ 0.43 0.93 0.86 57571429
+ 0.43 0.93 0.86 64642857
+ 0.43 0.93 0.86 71714286
+ 0.43 0.93 0.86 78785714
+ 0.43 0.93 0.86 85857143
+ 0.43 0.93 0.86 92928571
+ 0.43 0.93 0.86 100000000
+ 0.43 0.93 0.93 1000000
+ 0.43 0.93 0.93 8071429
+ 0.43 0.93 0.93 15142857
+ 0.43 0.93 0.93 22214286
+ 0.43 0.93 0.93 29285714
+ 0.43 0.93 0.93 36357143
+ 0.43 0.93 0.93 43428571
+ 0.43 0.93 0.93 50500000
+ 0.43 0.93 0.93 57571429
+ 0.43 0.93 0.93 64642857
+ 0.43 0.93 0.93 71714286
+ 0.43 0.93 0.93 78785714
+ 0.43 0.93 0.93 85857143
+ 0.43 0.93 0.93 92928571
+ 0.43 0.93 0.93 100000000
+ 0.43 0.93 1.00 1000000
+ 0.43 0.93 1.00 8071429
+ 0.43 0.93 1.00 15142857
+ 0.43 0.93 1.00 22214286
+ 0.43 0.93 1.00 29285714
+ 0.43 0.93 1.00 36357143
+ 0.43 0.93 1.00 43428571
+ 0.43 0.93 1.00 50500000
+ 0.43 0.93 1.00 57571429
+ 0.43 0.93 1.00 64642857
+ 0.43 0.93 1.00 71714286
+ 0.43 0.93 1.00 78785714
+ 0.43 0.93 1.00 85857143
+ 0.43 0.93 1.00 92928571
+ 0.43 0.93 1.00 100000000
+ 0.43 1.00 0.00 1000000
+ 0.43 1.00 0.00 8071429
+ 0.43 1.00 0.00 15142857
+ 0.43 1.00 0.00 22214286
+ 0.43 1.00 0.00 29285714
+ 0.43 1.00 0.00 36357143
+ 0.43 1.00 0.00 43428571
+ 0.43 1.00 0.00 50500000
+ 0.43 1.00 0.00 57571429
+ 0.43 1.00 0.00 64642857
+ 0.43 1.00 0.00 71714286
+ 0.43 1.00 0.00 78785714
+ 0.43 1.00 0.00 85857143
+ 0.43 1.00 0.00 92928571
+ 0.43 1.00 0.00 100000000
+ 0.43 1.00 0.07 1000000
+ 0.43 1.00 0.07 8071429
+ 0.43 1.00 0.07 15142857
+ 0.43 1.00 0.07 22214286
+ 0.43 1.00 0.07 29285714
+ 0.43 1.00 0.07 36357143
+ 0.43 1.00 0.07 43428571
+ 0.43 1.00 0.07 50500000
+ 0.43 1.00 0.07 57571429
+ 0.43 1.00 0.07 64642857
+ 0.43 1.00 0.07 71714286
+ 0.43 1.00 0.07 78785714
+ 0.43 1.00 0.07 85857143
+ 0.43 1.00 0.07 92928571
+ 0.43 1.00 0.07 100000000
+ 0.43 1.00 0.14 1000000
+ 0.43 1.00 0.14 8071429
+ 0.43 1.00 0.14 15142857
+ 0.43 1.00 0.14 22214286
+ 0.43 1.00 0.14 29285714
+ 0.43 1.00 0.14 36357143
+ 0.43 1.00 0.14 43428571
+ 0.43 1.00 0.14 50500000
+ 0.43 1.00 0.14 57571429
+ 0.43 1.00 0.14 64642857
+ 0.43 1.00 0.14 71714286
+ 0.43 1.00 0.14 78785714
+ 0.43 1.00 0.14 85857143
+ 0.43 1.00 0.14 92928571
+ 0.43 1.00 0.14 100000000
+ 0.43 1.00 0.21 1000000
+ 0.43 1.00 0.21 8071429
+ 0.43 1.00 0.21 15142857
+ 0.43 1.00 0.21 22214286
+ 0.43 1.00 0.21 29285714
+ 0.43 1.00 0.21 36357143
+ 0.43 1.00 0.21 43428571
+ 0.43 1.00 0.21 50500000
+ 0.43 1.00 0.21 57571429
+ 0.43 1.00 0.21 64642857
+ 0.43 1.00 0.21 71714286
+ 0.43 1.00 0.21 78785714
+ 0.43 1.00 0.21 85857143
+ 0.43 1.00 0.21 92928571
+ 0.43 1.00 0.21 100000000
+ 0.43 1.00 0.29 1000000
+ 0.43 1.00 0.29 8071429
+ 0.43 1.00 0.29 15142857
+ 0.43 1.00 0.29 22214286
+ 0.43 1.00 0.29 29285714
+ 0.43 1.00 0.29 36357143
+ 0.43 1.00 0.29 43428571
+ 0.43 1.00 0.29 50500000
+ 0.43 1.00 0.29 57571429
+ 0.43 1.00 0.29 64642857
+ 0.43 1.00 0.29 71714286
+ 0.43 1.00 0.29 78785714
+ 0.43 1.00 0.29 85857143
+ 0.43 1.00 0.29 92928571
+ 0.43 1.00 0.29 100000000
+ 0.43 1.00 0.36 1000000
+ 0.43 1.00 0.36 8071429
+ 0.43 1.00 0.36 15142857
+ 0.43 1.00 0.36 22214286
+ 0.43 1.00 0.36 29285714
+ 0.43 1.00 0.36 36357143
+ 0.43 1.00 0.36 43428571
+ 0.43 1.00 0.36 50500000
+ 0.43 1.00 0.36 57571429
+ 0.43 1.00 0.36 64642857
+ 0.43 1.00 0.36 71714286
+ 0.43 1.00 0.36 78785714
+ 0.43 1.00 0.36 85857143
+ 0.43 1.00 0.36 92928571
+ 0.43 1.00 0.36 100000000
+ 0.43 1.00 0.43 1000000
+ 0.43 1.00 0.43 8071429
+ 0.43 1.00 0.43 15142857
+ 0.43 1.00 0.43 22214286
+ 0.43 1.00 0.43 29285714
+ 0.43 1.00 0.43 36357143
+ 0.43 1.00 0.43 43428571
+ 0.43 1.00 0.43 50500000
+ 0.43 1.00 0.43 57571429
+ 0.43 1.00 0.43 64642857
+ 0.43 1.00 0.43 71714286
+ 0.43 1.00 0.43 78785714
+ 0.43 1.00 0.43 85857143
+ 0.43 1.00 0.43 92928571
+ 0.43 1.00 0.43 100000000
+ 0.43 1.00 0.50 1000000
+ 0.43 1.00 0.50 8071429
+ 0.43 1.00 0.50 15142857
+ 0.43 1.00 0.50 22214286
+ 0.43 1.00 0.50 29285714
+ 0.43 1.00 0.50 36357143
+ 0.43 1.00 0.50 43428571
+ 0.43 1.00 0.50 50500000
+ 0.43 1.00 0.50 57571429
+ 0.43 1.00 0.50 64642857
+ 0.43 1.00 0.50 71714286
+ 0.43 1.00 0.50 78785714
+ 0.43 1.00 0.50 85857143
+ 0.43 1.00 0.50 92928571
+ 0.43 1.00 0.50 100000000
+ 0.43 1.00 0.57 1000000
+ 0.43 1.00 0.57 8071429
+ 0.43 1.00 0.57 15142857
+ 0.43 1.00 0.57 22214286
+ 0.43 1.00 0.57 29285714
+ 0.43 1.00 0.57 36357143
+ 0.43 1.00 0.57 43428571
+ 0.43 1.00 0.57 50500000
+ 0.43 1.00 0.57 57571429
+ 0.43 1.00 0.57 64642857
+ 0.43 1.00 0.57 71714286
+ 0.43 1.00 0.57 78785714
+ 0.43 1.00 0.57 85857143
+ 0.43 1.00 0.57 92928571
+ 0.43 1.00 0.57 100000000
+ 0.43 1.00 0.64 1000000
+ 0.43 1.00 0.64 8071429
+ 0.43 1.00 0.64 15142857
+ 0.43 1.00 0.64 22214286
+ 0.43 1.00 0.64 29285714
+ 0.43 1.00 0.64 36357143
+ 0.43 1.00 0.64 43428571
+ 0.43 1.00 0.64 50500000
+ 0.43 1.00 0.64 57571429
+ 0.43 1.00 0.64 64642857
+ 0.43 1.00 0.64 71714286
+ 0.43 1.00 0.64 78785714
+ 0.43 1.00 0.64 85857143
+ 0.43 1.00 0.64 92928571
+ 0.43 1.00 0.64 100000000
+ 0.43 1.00 0.71 1000000
+ 0.43 1.00 0.71 8071429
+ 0.43 1.00 0.71 15142857
+ 0.43 1.00 0.71 22214286
+ 0.43 1.00 0.71 29285714
+ 0.43 1.00 0.71 36357143
+ 0.43 1.00 0.71 43428571
+ 0.43 1.00 0.71 50500000
+ 0.43 1.00 0.71 57571429
+ 0.43 1.00 0.71 64642857
+ 0.43 1.00 0.71 71714286
+ 0.43 1.00 0.71 78785714
+ 0.43 1.00 0.71 85857143
+ 0.43 1.00 0.71 92928571
+ 0.43 1.00 0.71 100000000
+ 0.43 1.00 0.79 1000000
+ 0.43 1.00 0.79 8071429
+ 0.43 1.00 0.79 15142857
+ 0.43 1.00 0.79 22214286
+ 0.43 1.00 0.79 29285714
+ 0.43 1.00 0.79 36357143
+ 0.43 1.00 0.79 43428571
+ 0.43 1.00 0.79 50500000
+ 0.43 1.00 0.79 57571429
+ 0.43 1.00 0.79 64642857
+ 0.43 1.00 0.79 71714286
+ 0.43 1.00 0.79 78785714
+ 0.43 1.00 0.79 85857143
+ 0.43 1.00 0.79 92928571
+ 0.43 1.00 0.79 100000000
+ 0.43 1.00 0.86 1000000
+ 0.43 1.00 0.86 8071429
+ 0.43 1.00 0.86 15142857
+ 0.43 1.00 0.86 22214286
+ 0.43 1.00 0.86 29285714
+ 0.43 1.00 0.86 36357143
+ 0.43 1.00 0.86 43428571
+ 0.43 1.00 0.86 50500000
+ 0.43 1.00 0.86 57571429
+ 0.43 1.00 0.86 64642857
+ 0.43 1.00 0.86 71714286
+ 0.43 1.00 0.86 78785714
+ 0.43 1.00 0.86 85857143
+ 0.43 1.00 0.86 92928571
+ 0.43 1.00 0.86 100000000
+ 0.43 1.00 0.93 1000000
+ 0.43 1.00 0.93 8071429
+ 0.43 1.00 0.93 15142857
+ 0.43 1.00 0.93 22214286
+ 0.43 1.00 0.93 29285714
+ 0.43 1.00 0.93 36357143
+ 0.43 1.00 0.93 43428571
+ 0.43 1.00 0.93 50500000
+ 0.43 1.00 0.93 57571429
+ 0.43 1.00 0.93 64642857
+ 0.43 1.00 0.93 71714286
+ 0.43 1.00 0.93 78785714
+ 0.43 1.00 0.93 85857143
+ 0.43 1.00 0.93 92928571
+ 0.43 1.00 0.93 100000000
+ 0.43 1.00 1.00 1000000
+ 0.43 1.00 1.00 8071429
+ 0.43 1.00 1.00 15142857
+ 0.43 1.00 1.00 22214286
+ 0.43 1.00 1.00 29285714
+ 0.43 1.00 1.00 36357143
+ 0.43 1.00 1.00 43428571
+ 0.43 1.00 1.00 50500000
+ 0.43 1.00 1.00 57571429
+ 0.43 1.00 1.00 64642857
+ 0.43 1.00 1.00 71714286
+ 0.43 1.00 1.00 78785714
+ 0.43 1.00 1.00 85857143
+ 0.43 1.00 1.00 92928571
+ 0.43 1.00 1.00 100000000
+ 0.50 0.00 0.00 1000000
+ 0.50 0.00 0.00 8071429
+ 0.50 0.00 0.00 15142857
+ 0.50 0.00 0.00 22214286
+ 0.50 0.00 0.00 29285714
+ 0.50 0.00 0.00 36357143
+ 0.50 0.00 0.00 43428571
+ 0.50 0.00 0.00 50500000
+ 0.50 0.00 0.00 57571429
+ 0.50 0.00 0.00 64642857
+ 0.50 0.00 0.00 71714286
+ 0.50 0.00 0.00 78785714
+ 0.50 0.00 0.00 85857143
+ 0.50 0.00 0.00 92928571
+ 0.50 0.00 0.00 100000000
+ 0.50 0.00 0.07 1000000
+ 0.50 0.00 0.07 8071429
+ 0.50 0.00 0.07 15142857
+ 0.50 0.00 0.07 22214286
+ 0.50 0.00 0.07 29285714
+ 0.50 0.00 0.07 36357143
+ 0.50 0.00 0.07 43428571
+ 0.50 0.00 0.07 50500000
+ 0.50 0.00 0.07 57571429
+ 0.50 0.00 0.07 64642857
+ 0.50 0.00 0.07 71714286
+ 0.50 0.00 0.07 78785714
+ 0.50 0.00 0.07 85857143
+ 0.50 0.00 0.07 92928571
+ 0.50 0.00 0.07 100000000
+ 0.50 0.00 0.14 1000000
+ 0.50 0.00 0.14 8071429
+ 0.50 0.00 0.14 15142857
+ 0.50 0.00 0.14 22214286
+ 0.50 0.00 0.14 29285714
+ 0.50 0.00 0.14 36357143
+ 0.50 0.00 0.14 43428571
+ 0.50 0.00 0.14 50500000
+ 0.50 0.00 0.14 57571429
+ 0.50 0.00 0.14 64642857
+ 0.50 0.00 0.14 71714286
+ 0.50 0.00 0.14 78785714
+ 0.50 0.00 0.14 85857143
+ 0.50 0.00 0.14 92928571
+ 0.50 0.00 0.14 100000000
+ 0.50 0.00 0.21 1000000
+ 0.50 0.00 0.21 8071429
+ 0.50 0.00 0.21 15142857
+ 0.50 0.00 0.21 22214286
+ 0.50 0.00 0.21 29285714
+ 0.50 0.00 0.21 36357143
+ 0.50 0.00 0.21 43428571
+ 0.50 0.00 0.21 50500000
+ 0.50 0.00 0.21 57571429
+ 0.50 0.00 0.21 64642857
+ 0.50 0.00 0.21 71714286
+ 0.50 0.00 0.21 78785714
+ 0.50 0.00 0.21 85857143
+ 0.50 0.00 0.21 92928571
+ 0.50 0.00 0.21 100000000
+ 0.50 0.00 0.29 1000000
+ 0.50 0.00 0.29 8071429
+ 0.50 0.00 0.29 15142857
+ 0.50 0.00 0.29 22214286
+ 0.50 0.00 0.29 29285714
+ 0.50 0.00 0.29 36357143
+ 0.50 0.00 0.29 43428571
+ 0.50 0.00 0.29 50500000
+ 0.50 0.00 0.29 57571429
+ 0.50 0.00 0.29 64642857
+ 0.50 0.00 0.29 71714286
+ 0.50 0.00 0.29 78785714
+ 0.50 0.00 0.29 85857143
+ 0.50 0.00 0.29 92928571
+ 0.50 0.00 0.29 100000000
+ 0.50 0.00 0.36 1000000
+ 0.50 0.00 0.36 8071429
+ 0.50 0.00 0.36 15142857
+ 0.50 0.00 0.36 22214286
+ 0.50 0.00 0.36 29285714
+ 0.50 0.00 0.36 36357143
+ 0.50 0.00 0.36 43428571
+ 0.50 0.00 0.36 50500000
+ 0.50 0.00 0.36 57571429
+ 0.50 0.00 0.36 64642857
+ 0.50 0.00 0.36 71714286
+ 0.50 0.00 0.36 78785714
+ 0.50 0.00 0.36 85857143
+ 0.50 0.00 0.36 92928571
+ 0.50 0.00 0.36 100000000
+ 0.50 0.00 0.43 1000000
+ 0.50 0.00 0.43 8071429
+ 0.50 0.00 0.43 15142857
+ 0.50 0.00 0.43 22214286
+ 0.50 0.00 0.43 29285714
+ 0.50 0.00 0.43 36357143
+ 0.50 0.00 0.43 43428571
+ 0.50 0.00 0.43 50500000
+ 0.50 0.00 0.43 57571429
+ 0.50 0.00 0.43 64642857
+ 0.50 0.00 0.43 71714286
+ 0.50 0.00 0.43 78785714
+ 0.50 0.00 0.43 85857143
+ 0.50 0.00 0.43 92928571
+ 0.50 0.00 0.43 100000000
+ 0.50 0.00 0.50 1000000
+ 0.50 0.00 0.50 8071429
+ 0.50 0.00 0.50 15142857
+ 0.50 0.00 0.50 22214286
+ 0.50 0.00 0.50 29285714
+ 0.50 0.00 0.50 36357143
+ 0.50 0.00 0.50 43428571
+ 0.50 0.00 0.50 50500000
+ 0.50 0.00 0.50 57571429
+ 0.50 0.00 0.50 64642857
+ 0.50 0.00 0.50 71714286
+ 0.50 0.00 0.50 78785714
+ 0.50 0.00 0.50 85857143
+ 0.50 0.00 0.50 92928571
+ 0.50 0.00 0.50 100000000
+ 0.50 0.00 0.57 1000000
+ 0.50 0.00 0.57 8071429
+ 0.50 0.00 0.57 15142857
+ 0.50 0.00 0.57 22214286
+ 0.50 0.00 0.57 29285714
+ 0.50 0.00 0.57 36357143
+ 0.50 0.00 0.57 43428571
+ 0.50 0.00 0.57 50500000
+ 0.50 0.00 0.57 57571429
+ 0.50 0.00 0.57 64642857
+ 0.50 0.00 0.57 71714286
+ 0.50 0.00 0.57 78785714
+ 0.50 0.00 0.57 85857143
+ 0.50 0.00 0.57 92928571
+ 0.50 0.00 0.57 100000000
+ 0.50 0.00 0.64 1000000
+ 0.50 0.00 0.64 8071429
+ 0.50 0.00 0.64 15142857
+ 0.50 0.00 0.64 22214286
+ 0.50 0.00 0.64 29285714
+ 0.50 0.00 0.64 36357143
+ 0.50 0.00 0.64 43428571
+ 0.50 0.00 0.64 50500000
+ 0.50 0.00 0.64 57571429
+ 0.50 0.00 0.64 64642857
+ 0.50 0.00 0.64 71714286
+ 0.50 0.00 0.64 78785714
+ 0.50 0.00 0.64 85857143
+ 0.50 0.00 0.64 92928571
+ 0.50 0.00 0.64 100000000
+ 0.50 0.00 0.71 1000000
+ 0.50 0.00 0.71 8071429
+ 0.50 0.00 0.71 15142857
+ 0.50 0.00 0.71 22214286
+ 0.50 0.00 0.71 29285714
+ 0.50 0.00 0.71 36357143
+ 0.50 0.00 0.71 43428571
+ 0.50 0.00 0.71 50500000
+ 0.50 0.00 0.71 57571429
+ 0.50 0.00 0.71 64642857
+ 0.50 0.00 0.71 71714286
+ 0.50 0.00 0.71 78785714
+ 0.50 0.00 0.71 85857143
+ 0.50 0.00 0.71 92928571
+ 0.50 0.00 0.71 100000000
+ 0.50 0.00 0.79 1000000
+ 0.50 0.00 0.79 8071429
+ 0.50 0.00 0.79 15142857
+ 0.50 0.00 0.79 22214286
+ 0.50 0.00 0.79 29285714
+ 0.50 0.00 0.79 36357143
+ 0.50 0.00 0.79 43428571
+ 0.50 0.00 0.79 50500000
+ 0.50 0.00 0.79 57571429
+ 0.50 0.00 0.79 64642857
+ 0.50 0.00 0.79 71714286
+ 0.50 0.00 0.79 78785714
+ 0.50 0.00 0.79 85857143
+ 0.50 0.00 0.79 92928571
+ 0.50 0.00 0.79 100000000
+ 0.50 0.00 0.86 1000000
+ 0.50 0.00 0.86 8071429
+ 0.50 0.00 0.86 15142857
+ 0.50 0.00 0.86 22214286
+ 0.50 0.00 0.86 29285714
+ 0.50 0.00 0.86 36357143
+ 0.50 0.00 0.86 43428571
+ 0.50 0.00 0.86 50500000
+ 0.50 0.00 0.86 57571429
+ 0.50 0.00 0.86 64642857
+ 0.50 0.00 0.86 71714286
+ 0.50 0.00 0.86 78785714
+ 0.50 0.00 0.86 85857143
+ 0.50 0.00 0.86 92928571
+ 0.50 0.00 0.86 100000000
+ 0.50 0.00 0.93 1000000
+ 0.50 0.00 0.93 8071429
+ 0.50 0.00 0.93 15142857
+ 0.50 0.00 0.93 22214286
+ 0.50 0.00 0.93 29285714
+ 0.50 0.00 0.93 36357143
+ 0.50 0.00 0.93 43428571
+ 0.50 0.00 0.93 50500000
+ 0.50 0.00 0.93 57571429
+ 0.50 0.00 0.93 64642857
+ 0.50 0.00 0.93 71714286
+ 0.50 0.00 0.93 78785714
+ 0.50 0.00 0.93 85857143
+ 0.50 0.00 0.93 92928571
+ 0.50 0.00 0.93 100000000
+ 0.50 0.00 1.00 1000000
+ 0.50 0.00 1.00 8071429
+ 0.50 0.00 1.00 15142857
+ 0.50 0.00 1.00 22214286
+ 0.50 0.00 1.00 29285714
+ 0.50 0.00 1.00 36357143
+ 0.50 0.00 1.00 43428571
+ 0.50 0.00 1.00 50500000
+ 0.50 0.00 1.00 57571429
+ 0.50 0.00 1.00 64642857
+ 0.50 0.00 1.00 71714286
+ 0.50 0.00 1.00 78785714
+ 0.50 0.00 1.00 85857143
+ 0.50 0.00 1.00 92928571
+ 0.50 0.00 1.00 100000000
+ 0.50 0.07 0.00 1000000
+ 0.50 0.07 0.00 8071429
+ 0.50 0.07 0.00 15142857
+ 0.50 0.07 0.00 22214286
+ 0.50 0.07 0.00 29285714
+ 0.50 0.07 0.00 36357143
+ 0.50 0.07 0.00 43428571
+ 0.50 0.07 0.00 50500000
+ 0.50 0.07 0.00 57571429
+ 0.50 0.07 0.00 64642857
+ 0.50 0.07 0.00 71714286
+ 0.50 0.07 0.00 78785714
+ 0.50 0.07 0.00 85857143
+ 0.50 0.07 0.00 92928571
+ 0.50 0.07 0.00 100000000
+ 0.50 0.07 0.07 1000000
+ 0.50 0.07 0.07 8071429
+ 0.50 0.07 0.07 15142857
+ 0.50 0.07 0.07 22214286
+ 0.50 0.07 0.07 29285714
+ 0.50 0.07 0.07 36357143
+ 0.50 0.07 0.07 43428571
+ 0.50 0.07 0.07 50500000
+ 0.50 0.07 0.07 57571429
+ 0.50 0.07 0.07 64642857
+ 0.50 0.07 0.07 71714286
+ 0.50 0.07 0.07 78785714
+ 0.50 0.07 0.07 85857143
+ 0.50 0.07 0.07 92928571
+ 0.50 0.07 0.07 100000000
+ 0.50 0.07 0.14 1000000
+ 0.50 0.07 0.14 8071429
+ 0.50 0.07 0.14 15142857
+ 0.50 0.07 0.14 22214286
+ 0.50 0.07 0.14 29285714
+ 0.50 0.07 0.14 36357143
+ 0.50 0.07 0.14 43428571
+ 0.50 0.07 0.14 50500000
+ 0.50 0.07 0.14 57571429
+ 0.50 0.07 0.14 64642857
+ 0.50 0.07 0.14 71714286
+ 0.50 0.07 0.14 78785714
+ 0.50 0.07 0.14 85857143
+ 0.50 0.07 0.14 92928571
+ 0.50 0.07 0.14 100000000
+ 0.50 0.07 0.21 1000000
+ 0.50 0.07 0.21 8071429
+ 0.50 0.07 0.21 15142857
+ 0.50 0.07 0.21 22214286
+ 0.50 0.07 0.21 29285714
+ 0.50 0.07 0.21 36357143
+ 0.50 0.07 0.21 43428571
+ 0.50 0.07 0.21 50500000
+ 0.50 0.07 0.21 57571429
+ 0.50 0.07 0.21 64642857
+ 0.50 0.07 0.21 71714286
+ 0.50 0.07 0.21 78785714
+ 0.50 0.07 0.21 85857143
+ 0.50 0.07 0.21 92928571
+ 0.50 0.07 0.21 100000000
+ 0.50 0.07 0.29 1000000
+ 0.50 0.07 0.29 8071429
+ 0.50 0.07 0.29 15142857
+ 0.50 0.07 0.29 22214286
+ 0.50 0.07 0.29 29285714
+ 0.50 0.07 0.29 36357143
+ 0.50 0.07 0.29 43428571
+ 0.50 0.07 0.29 50500000
+ 0.50 0.07 0.29 57571429
+ 0.50 0.07 0.29 64642857
+ 0.50 0.07 0.29 71714286
+ 0.50 0.07 0.29 78785714
+ 0.50 0.07 0.29 85857143
+ 0.50 0.07 0.29 92928571
+ 0.50 0.07 0.29 100000000
+ 0.50 0.07 0.36 1000000
+ 0.50 0.07 0.36 8071429
+ 0.50 0.07 0.36 15142857
+ 0.50 0.07 0.36 22214286
+ 0.50 0.07 0.36 29285714
+ 0.50 0.07 0.36 36357143
+ 0.50 0.07 0.36 43428571
+ 0.50 0.07 0.36 50500000
+ 0.50 0.07 0.36 57571429
+ 0.50 0.07 0.36 64642857
+ 0.50 0.07 0.36 71714286
+ 0.50 0.07 0.36 78785714
+ 0.50 0.07 0.36 85857143
+ 0.50 0.07 0.36 92928571
+ 0.50 0.07 0.36 100000000
+ 0.50 0.07 0.43 1000000
+ 0.50 0.07 0.43 8071429
+ 0.50 0.07 0.43 15142857
+ 0.50 0.07 0.43 22214286
+ 0.50 0.07 0.43 29285714
+ 0.50 0.07 0.43 36357143
+ 0.50 0.07 0.43 43428571
+ 0.50 0.07 0.43 50500000
+ 0.50 0.07 0.43 57571429
+ 0.50 0.07 0.43 64642857
+ 0.50 0.07 0.43 71714286
+ 0.50 0.07 0.43 78785714
+ 0.50 0.07 0.43 85857143
+ 0.50 0.07 0.43 92928571
+ 0.50 0.07 0.43 100000000
+ 0.50 0.07 0.50 1000000
+ 0.50 0.07 0.50 8071429
+ 0.50 0.07 0.50 15142857
+ 0.50 0.07 0.50 22214286
+ 0.50 0.07 0.50 29285714
+ 0.50 0.07 0.50 36357143
+ 0.50 0.07 0.50 43428571
+ 0.50 0.07 0.50 50500000
+ 0.50 0.07 0.50 57571429
+ 0.50 0.07 0.50 64642857
+ 0.50 0.07 0.50 71714286
+ 0.50 0.07 0.50 78785714
+ 0.50 0.07 0.50 85857143
+ 0.50 0.07 0.50 92928571
+ 0.50 0.07 0.50 100000000
+ 0.50 0.07 0.57 1000000
+ 0.50 0.07 0.57 8071429
+ 0.50 0.07 0.57 15142857
+ 0.50 0.07 0.57 22214286
+ 0.50 0.07 0.57 29285714
+ 0.50 0.07 0.57 36357143
+ 0.50 0.07 0.57 43428571
+ 0.50 0.07 0.57 50500000
+ 0.50 0.07 0.57 57571429
+ 0.50 0.07 0.57 64642857
+ 0.50 0.07 0.57 71714286
+ 0.50 0.07 0.57 78785714
+ 0.50 0.07 0.57 85857143
+ 0.50 0.07 0.57 92928571
+ 0.50 0.07 0.57 100000000
+ 0.50 0.07 0.64 1000000
+ 0.50 0.07 0.64 8071429
+ 0.50 0.07 0.64 15142857
+ 0.50 0.07 0.64 22214286
+ 0.50 0.07 0.64 29285714
+ 0.50 0.07 0.64 36357143
+ 0.50 0.07 0.64 43428571
+ 0.50 0.07 0.64 50500000
+ 0.50 0.07 0.64 57571429
+ 0.50 0.07 0.64 64642857
+ 0.50 0.07 0.64 71714286
+ 0.50 0.07 0.64 78785714
+ 0.50 0.07 0.64 85857143
+ 0.50 0.07 0.64 92928571
+ 0.50 0.07 0.64 100000000
+ 0.50 0.07 0.71 1000000
+ 0.50 0.07 0.71 8071429
+ 0.50 0.07 0.71 15142857
+ 0.50 0.07 0.71 22214286
+ 0.50 0.07 0.71 29285714
+ 0.50 0.07 0.71 36357143
+ 0.50 0.07 0.71 43428571
+ 0.50 0.07 0.71 50500000
+ 0.50 0.07 0.71 57571429
+ 0.50 0.07 0.71 64642857
+ 0.50 0.07 0.71 71714286
+ 0.50 0.07 0.71 78785714
+ 0.50 0.07 0.71 85857143
+ 0.50 0.07 0.71 92928571
+ 0.50 0.07 0.71 100000000
+ 0.50 0.07 0.79 1000000
+ 0.50 0.07 0.79 8071429
+ 0.50 0.07 0.79 15142857
+ 0.50 0.07 0.79 22214286
+ 0.50 0.07 0.79 29285714
+ 0.50 0.07 0.79 36357143
+ 0.50 0.07 0.79 43428571
+ 0.50 0.07 0.79 50500000
+ 0.50 0.07 0.79 57571429
+ 0.50 0.07 0.79 64642857
+ 0.50 0.07 0.79 71714286
+ 0.50 0.07 0.79 78785714
+ 0.50 0.07 0.79 85857143
+ 0.50 0.07 0.79 92928571
+ 0.50 0.07 0.79 100000000
+ 0.50 0.07 0.86 1000000
+ 0.50 0.07 0.86 8071429
+ 0.50 0.07 0.86 15142857
+ 0.50 0.07 0.86 22214286
+ 0.50 0.07 0.86 29285714
+ 0.50 0.07 0.86 36357143
+ 0.50 0.07 0.86 43428571
+ 0.50 0.07 0.86 50500000
+ 0.50 0.07 0.86 57571429
+ 0.50 0.07 0.86 64642857
+ 0.50 0.07 0.86 71714286
+ 0.50 0.07 0.86 78785714
+ 0.50 0.07 0.86 85857143
+ 0.50 0.07 0.86 92928571
+ 0.50 0.07 0.86 100000000
+ 0.50 0.07 0.93 1000000
+ 0.50 0.07 0.93 8071429
+ 0.50 0.07 0.93 15142857
+ 0.50 0.07 0.93 22214286
+ 0.50 0.07 0.93 29285714
+ 0.50 0.07 0.93 36357143
+ 0.50 0.07 0.93 43428571
+ 0.50 0.07 0.93 50500000
+ 0.50 0.07 0.93 57571429
+ 0.50 0.07 0.93 64642857
+ 0.50 0.07 0.93 71714286
+ 0.50 0.07 0.93 78785714
+ 0.50 0.07 0.93 85857143
+ 0.50 0.07 0.93 92928571
+ 0.50 0.07 0.93 100000000
+ 0.50 0.07 1.00 1000000
+ 0.50 0.07 1.00 8071429
+ 0.50 0.07 1.00 15142857
+ 0.50 0.07 1.00 22214286
+ 0.50 0.07 1.00 29285714
+ 0.50 0.07 1.00 36357143
+ 0.50 0.07 1.00 43428571
+ 0.50 0.07 1.00 50500000
+ 0.50 0.07 1.00 57571429
+ 0.50 0.07 1.00 64642857
+ 0.50 0.07 1.00 71714286
+ 0.50 0.07 1.00 78785714
+ 0.50 0.07 1.00 85857143
+ 0.50 0.07 1.00 92928571
+ 0.50 0.07 1.00 100000000
+ 0.50 0.14 0.00 1000000
+ 0.50 0.14 0.00 8071429
+ 0.50 0.14 0.00 15142857
+ 0.50 0.14 0.00 22214286
+ 0.50 0.14 0.00 29285714
+ 0.50 0.14 0.00 36357143
+ 0.50 0.14 0.00 43428571
+ 0.50 0.14 0.00 50500000
+ 0.50 0.14 0.00 57571429
+ 0.50 0.14 0.00 64642857
+ 0.50 0.14 0.00 71714286
+ 0.50 0.14 0.00 78785714
+ 0.50 0.14 0.00 85857143
+ 0.50 0.14 0.00 92928571
+ 0.50 0.14 0.00 100000000
+ 0.50 0.14 0.07 1000000
+ 0.50 0.14 0.07 8071429
+ 0.50 0.14 0.07 15142857
+ 0.50 0.14 0.07 22214286
+ 0.50 0.14 0.07 29285714
+ 0.50 0.14 0.07 36357143
+ 0.50 0.14 0.07 43428571
+ 0.50 0.14 0.07 50500000
+ 0.50 0.14 0.07 57571429
+ 0.50 0.14 0.07 64642857
+ 0.50 0.14 0.07 71714286
+ 0.50 0.14 0.07 78785714
+ 0.50 0.14 0.07 85857143
+ 0.50 0.14 0.07 92928571
+ 0.50 0.14 0.07 100000000
+ 0.50 0.14 0.14 1000000
+ 0.50 0.14 0.14 8071429
+ 0.50 0.14 0.14 15142857
+ 0.50 0.14 0.14 22214286
+ 0.50 0.14 0.14 29285714
+ 0.50 0.14 0.14 36357143
+ 0.50 0.14 0.14 43428571
+ 0.50 0.14 0.14 50500000
+ 0.50 0.14 0.14 57571429
+ 0.50 0.14 0.14 64642857
+ 0.50 0.14 0.14 71714286
+ 0.50 0.14 0.14 78785714
+ 0.50 0.14 0.14 85857143
+ 0.50 0.14 0.14 92928571
+ 0.50 0.14 0.14 100000000
+ 0.50 0.14 0.21 1000000
+ 0.50 0.14 0.21 8071429
+ 0.50 0.14 0.21 15142857
+ 0.50 0.14 0.21 22214286
+ 0.50 0.14 0.21 29285714
+ 0.50 0.14 0.21 36357143
+ 0.50 0.14 0.21 43428571
+ 0.50 0.14 0.21 50500000
+ 0.50 0.14 0.21 57571429
+ 0.50 0.14 0.21 64642857
+ 0.50 0.14 0.21 71714286
+ 0.50 0.14 0.21 78785714
+ 0.50 0.14 0.21 85857143
+ 0.50 0.14 0.21 92928571
+ 0.50 0.14 0.21 100000000
+ 0.50 0.14 0.29 1000000
+ 0.50 0.14 0.29 8071429
+ 0.50 0.14 0.29 15142857
+ 0.50 0.14 0.29 22214286
+ 0.50 0.14 0.29 29285714
+ 0.50 0.14 0.29 36357143
+ 0.50 0.14 0.29 43428571
+ 0.50 0.14 0.29 50500000
+ 0.50 0.14 0.29 57571429
+ 0.50 0.14 0.29 64642857
+ 0.50 0.14 0.29 71714286
+ 0.50 0.14 0.29 78785714
+ 0.50 0.14 0.29 85857143
+ 0.50 0.14 0.29 92928571
+ 0.50 0.14 0.29 100000000
+ 0.50 0.14 0.36 1000000
+ 0.50 0.14 0.36 8071429
+ 0.50 0.14 0.36 15142857
+ 0.50 0.14 0.36 22214286
+ 0.50 0.14 0.36 29285714
+ 0.50 0.14 0.36 36357143
+ 0.50 0.14 0.36 43428571
+ 0.50 0.14 0.36 50500000
+ 0.50 0.14 0.36 57571429
+ 0.50 0.14 0.36 64642857
+ 0.50 0.14 0.36 71714286
+ 0.50 0.14 0.36 78785714
+ 0.50 0.14 0.36 85857143
+ 0.50 0.14 0.36 92928571
+ 0.50 0.14 0.36 100000000
+ 0.50 0.14 0.43 1000000
+ 0.50 0.14 0.43 8071429
+ 0.50 0.14 0.43 15142857
+ 0.50 0.14 0.43 22214286
+ 0.50 0.14 0.43 29285714
+ 0.50 0.14 0.43 36357143
+ 0.50 0.14 0.43 43428571
+ 0.50 0.14 0.43 50500000
+ 0.50 0.14 0.43 57571429
+ 0.50 0.14 0.43 64642857
+ 0.50 0.14 0.43 71714286
+ 0.50 0.14 0.43 78785714
+ 0.50 0.14 0.43 85857143
+ 0.50 0.14 0.43 92928571
+ 0.50 0.14 0.43 100000000
+ 0.50 0.14 0.50 1000000
+ 0.50 0.14 0.50 8071429
+ 0.50 0.14 0.50 15142857
+ 0.50 0.14 0.50 22214286
+ 0.50 0.14 0.50 29285714
+ 0.50 0.14 0.50 36357143
+ 0.50 0.14 0.50 43428571
+ 0.50 0.14 0.50 50500000
+ 0.50 0.14 0.50 57571429
+ 0.50 0.14 0.50 64642857
+ 0.50 0.14 0.50 71714286
+ 0.50 0.14 0.50 78785714
+ 0.50 0.14 0.50 85857143
+ 0.50 0.14 0.50 92928571
+ 0.50 0.14 0.50 100000000
+ 0.50 0.14 0.57 1000000
+ 0.50 0.14 0.57 8071429
+ 0.50 0.14 0.57 15142857
+ 0.50 0.14 0.57 22214286
+ 0.50 0.14 0.57 29285714
+ 0.50 0.14 0.57 36357143
+ 0.50 0.14 0.57 43428571
+ 0.50 0.14 0.57 50500000
+ 0.50 0.14 0.57 57571429
+ 0.50 0.14 0.57 64642857
+ 0.50 0.14 0.57 71714286
+ 0.50 0.14 0.57 78785714
+ 0.50 0.14 0.57 85857143
+ 0.50 0.14 0.57 92928571
+ 0.50 0.14 0.57 100000000
+ 0.50 0.14 0.64 1000000
+ 0.50 0.14 0.64 8071429
+ 0.50 0.14 0.64 15142857
+ 0.50 0.14 0.64 22214286
+ 0.50 0.14 0.64 29285714
+ 0.50 0.14 0.64 36357143
+ 0.50 0.14 0.64 43428571
+ 0.50 0.14 0.64 50500000
+ 0.50 0.14 0.64 57571429
+ 0.50 0.14 0.64 64642857
+ 0.50 0.14 0.64 71714286
+ 0.50 0.14 0.64 78785714
+ 0.50 0.14 0.64 85857143
+ 0.50 0.14 0.64 92928571
+ 0.50 0.14 0.64 100000000
+ 0.50 0.14 0.71 1000000
+ 0.50 0.14 0.71 8071429
+ 0.50 0.14 0.71 15142857
+ 0.50 0.14 0.71 22214286
+ 0.50 0.14 0.71 29285714
+ 0.50 0.14 0.71 36357143
+ 0.50 0.14 0.71 43428571
+ 0.50 0.14 0.71 50500000
+ 0.50 0.14 0.71 57571429
+ 0.50 0.14 0.71 64642857
+ 0.50 0.14 0.71 71714286
+ 0.50 0.14 0.71 78785714
+ 0.50 0.14 0.71 85857143
+ 0.50 0.14 0.71 92928571
+ 0.50 0.14 0.71 100000000
+ 0.50 0.14 0.79 1000000
+ 0.50 0.14 0.79 8071429
+ 0.50 0.14 0.79 15142857
+ 0.50 0.14 0.79 22214286
+ 0.50 0.14 0.79 29285714
+ 0.50 0.14 0.79 36357143
+ 0.50 0.14 0.79 43428571
+ 0.50 0.14 0.79 50500000
+ 0.50 0.14 0.79 57571429
+ 0.50 0.14 0.79 64642857
+ 0.50 0.14 0.79 71714286
+ 0.50 0.14 0.79 78785714
+ 0.50 0.14 0.79 85857143
+ 0.50 0.14 0.79 92928571
+ 0.50 0.14 0.79 100000000
+ 0.50 0.14 0.86 1000000
+ 0.50 0.14 0.86 8071429
+ 0.50 0.14 0.86 15142857
+ 0.50 0.14 0.86 22214286
+ 0.50 0.14 0.86 29285714
+ 0.50 0.14 0.86 36357143
+ 0.50 0.14 0.86 43428571
+ 0.50 0.14 0.86 50500000
+ 0.50 0.14 0.86 57571429
+ 0.50 0.14 0.86 64642857
+ 0.50 0.14 0.86 71714286
+ 0.50 0.14 0.86 78785714
+ 0.50 0.14 0.86 85857143
+ 0.50 0.14 0.86 92928571
+ 0.50 0.14 0.86 100000000
+ 0.50 0.14 0.93 1000000
+ 0.50 0.14 0.93 8071429
+ 0.50 0.14 0.93 15142857
+ 0.50 0.14 0.93 22214286
+ 0.50 0.14 0.93 29285714
+ 0.50 0.14 0.93 36357143
+ 0.50 0.14 0.93 43428571
+ 0.50 0.14 0.93 50500000
+ 0.50 0.14 0.93 57571429
+ 0.50 0.14 0.93 64642857
+ 0.50 0.14 0.93 71714286
+ 0.50 0.14 0.93 78785714
+ 0.50 0.14 0.93 85857143
+ 0.50 0.14 0.93 92928571
+ 0.50 0.14 0.93 100000000
+ 0.50 0.14 1.00 1000000
+ 0.50 0.14 1.00 8071429
+ 0.50 0.14 1.00 15142857
+ 0.50 0.14 1.00 22214286
+ 0.50 0.14 1.00 29285714
+ 0.50 0.14 1.00 36357143
+ 0.50 0.14 1.00 43428571
+ 0.50 0.14 1.00 50500000
+ 0.50 0.14 1.00 57571429
+ 0.50 0.14 1.00 64642857
+ 0.50 0.14 1.00 71714286
+ 0.50 0.14 1.00 78785714
+ 0.50 0.14 1.00 85857143
+ 0.50 0.14 1.00 92928571
+ 0.50 0.14 1.00 100000000
+ 0.50 0.21 0.00 1000000
+ 0.50 0.21 0.00 8071429
+ 0.50 0.21 0.00 15142857
+ 0.50 0.21 0.00 22214286
+ 0.50 0.21 0.00 29285714
+ 0.50 0.21 0.00 36357143
+ 0.50 0.21 0.00 43428571
+ 0.50 0.21 0.00 50500000
+ 0.50 0.21 0.00 57571429
+ 0.50 0.21 0.00 64642857
+ 0.50 0.21 0.00 71714286
+ 0.50 0.21 0.00 78785714
+ 0.50 0.21 0.00 85857143
+ 0.50 0.21 0.00 92928571
+ 0.50 0.21 0.00 100000000
+ 0.50 0.21 0.07 1000000
+ 0.50 0.21 0.07 8071429
+ 0.50 0.21 0.07 15142857
+ 0.50 0.21 0.07 22214286
+ 0.50 0.21 0.07 29285714
+ 0.50 0.21 0.07 36357143
+ 0.50 0.21 0.07 43428571
+ 0.50 0.21 0.07 50500000
+ 0.50 0.21 0.07 57571429
+ 0.50 0.21 0.07 64642857
+ 0.50 0.21 0.07 71714286
+ 0.50 0.21 0.07 78785714
+ 0.50 0.21 0.07 85857143
+ 0.50 0.21 0.07 92928571
+ 0.50 0.21 0.07 100000000
+ 0.50 0.21 0.14 1000000
+ 0.50 0.21 0.14 8071429
+ 0.50 0.21 0.14 15142857
+ 0.50 0.21 0.14 22214286
+ 0.50 0.21 0.14 29285714
+ 0.50 0.21 0.14 36357143
+ 0.50 0.21 0.14 43428571
+ 0.50 0.21 0.14 50500000
+ 0.50 0.21 0.14 57571429
+ 0.50 0.21 0.14 64642857
+ 0.50 0.21 0.14 71714286
+ 0.50 0.21 0.14 78785714
+ 0.50 0.21 0.14 85857143
+ 0.50 0.21 0.14 92928571
+ 0.50 0.21 0.14 100000000
+ 0.50 0.21 0.21 1000000
+ 0.50 0.21 0.21 8071429
+ 0.50 0.21 0.21 15142857
+ 0.50 0.21 0.21 22214286
+ 0.50 0.21 0.21 29285714
+ 0.50 0.21 0.21 36357143
+ 0.50 0.21 0.21 43428571
+ 0.50 0.21 0.21 50500000
+ 0.50 0.21 0.21 57571429
+ 0.50 0.21 0.21 64642857
+ 0.50 0.21 0.21 71714286
+ 0.50 0.21 0.21 78785714
+ 0.50 0.21 0.21 85857143
+ 0.50 0.21 0.21 92928571
+ 0.50 0.21 0.21 100000000
+ 0.50 0.21 0.29 1000000
+ 0.50 0.21 0.29 8071429
+ 0.50 0.21 0.29 15142857
+ 0.50 0.21 0.29 22214286
+ 0.50 0.21 0.29 29285714
+ 0.50 0.21 0.29 36357143
+ 0.50 0.21 0.29 43428571
+ 0.50 0.21 0.29 50500000
+ 0.50 0.21 0.29 57571429
+ 0.50 0.21 0.29 64642857
+ 0.50 0.21 0.29 71714286
+ 0.50 0.21 0.29 78785714
+ 0.50 0.21 0.29 85857143
+ 0.50 0.21 0.29 92928571
+ 0.50 0.21 0.29 100000000
+ 0.50 0.21 0.36 1000000
+ 0.50 0.21 0.36 8071429
+ 0.50 0.21 0.36 15142857
+ 0.50 0.21 0.36 22214286
+ 0.50 0.21 0.36 29285714
+ 0.50 0.21 0.36 36357143
+ 0.50 0.21 0.36 43428571
+ 0.50 0.21 0.36 50500000
+ 0.50 0.21 0.36 57571429
+ 0.50 0.21 0.36 64642857
+ 0.50 0.21 0.36 71714286
+ 0.50 0.21 0.36 78785714
+ 0.50 0.21 0.36 85857143
+ 0.50 0.21 0.36 92928571
+ 0.50 0.21 0.36 100000000
+ 0.50 0.21 0.43 1000000
+ 0.50 0.21 0.43 8071429
+ 0.50 0.21 0.43 15142857
+ 0.50 0.21 0.43 22214286
+ 0.50 0.21 0.43 29285714
+ 0.50 0.21 0.43 36357143
+ 0.50 0.21 0.43 43428571
+ 0.50 0.21 0.43 50500000
+ 0.50 0.21 0.43 57571429
+ 0.50 0.21 0.43 64642857
+ 0.50 0.21 0.43 71714286
+ 0.50 0.21 0.43 78785714
+ 0.50 0.21 0.43 85857143
+ 0.50 0.21 0.43 92928571
+ 0.50 0.21 0.43 100000000
+ 0.50 0.21 0.50 1000000
+ 0.50 0.21 0.50 8071429
+ 0.50 0.21 0.50 15142857
+ 0.50 0.21 0.50 22214286
+ 0.50 0.21 0.50 29285714
+ 0.50 0.21 0.50 36357143
+ 0.50 0.21 0.50 43428571
+ 0.50 0.21 0.50 50500000
+ 0.50 0.21 0.50 57571429
+ 0.50 0.21 0.50 64642857
+ 0.50 0.21 0.50 71714286
+ 0.50 0.21 0.50 78785714
+ 0.50 0.21 0.50 85857143
+ 0.50 0.21 0.50 92928571
+ 0.50 0.21 0.50 100000000
+ 0.50 0.21 0.57 1000000
+ 0.50 0.21 0.57 8071429
+ 0.50 0.21 0.57 15142857
+ 0.50 0.21 0.57 22214286
+ 0.50 0.21 0.57 29285714
+ 0.50 0.21 0.57 36357143
+ 0.50 0.21 0.57 43428571
+ 0.50 0.21 0.57 50500000
+ 0.50 0.21 0.57 57571429
+ 0.50 0.21 0.57 64642857
+ 0.50 0.21 0.57 71714286
+ 0.50 0.21 0.57 78785714
+ 0.50 0.21 0.57 85857143
+ 0.50 0.21 0.57 92928571
+ 0.50 0.21 0.57 100000000
+ 0.50 0.21 0.64 1000000
+ 0.50 0.21 0.64 8071429
+ 0.50 0.21 0.64 15142857
+ 0.50 0.21 0.64 22214286
+ 0.50 0.21 0.64 29285714
+ 0.50 0.21 0.64 36357143
+ 0.50 0.21 0.64 43428571
+ 0.50 0.21 0.64 50500000
+ 0.50 0.21 0.64 57571429
+ 0.50 0.21 0.64 64642857
+ 0.50 0.21 0.64 71714286
+ 0.50 0.21 0.64 78785714
+ 0.50 0.21 0.64 85857143
+ 0.50 0.21 0.64 92928571
+ 0.50 0.21 0.64 100000000
+ 0.50 0.21 0.71 1000000
+ 0.50 0.21 0.71 8071429
+ 0.50 0.21 0.71 15142857
+ 0.50 0.21 0.71 22214286
+ 0.50 0.21 0.71 29285714
+ 0.50 0.21 0.71 36357143
+ 0.50 0.21 0.71 43428571
+ 0.50 0.21 0.71 50500000
+ 0.50 0.21 0.71 57571429
+ 0.50 0.21 0.71 64642857
+ 0.50 0.21 0.71 71714286
+ 0.50 0.21 0.71 78785714
+ 0.50 0.21 0.71 85857143
+ 0.50 0.21 0.71 92928571
+ 0.50 0.21 0.71 100000000
+ 0.50 0.21 0.79 1000000
+ 0.50 0.21 0.79 8071429
+ 0.50 0.21 0.79 15142857
+ 0.50 0.21 0.79 22214286
+ 0.50 0.21 0.79 29285714
+ 0.50 0.21 0.79 36357143
+ 0.50 0.21 0.79 43428571
+ 0.50 0.21 0.79 50500000
+ 0.50 0.21 0.79 57571429
+ 0.50 0.21 0.79 64642857
+ 0.50 0.21 0.79 71714286
+ 0.50 0.21 0.79 78785714
+ 0.50 0.21 0.79 85857143
+ 0.50 0.21 0.79 92928571
+ 0.50 0.21 0.79 100000000
+ 0.50 0.21 0.86 1000000
+ 0.50 0.21 0.86 8071429
+ 0.50 0.21 0.86 15142857
+ 0.50 0.21 0.86 22214286
+ 0.50 0.21 0.86 29285714
+ 0.50 0.21 0.86 36357143
+ 0.50 0.21 0.86 43428571
+ 0.50 0.21 0.86 50500000
+ 0.50 0.21 0.86 57571429
+ 0.50 0.21 0.86 64642857
+ 0.50 0.21 0.86 71714286
+ 0.50 0.21 0.86 78785714
+ 0.50 0.21 0.86 85857143
+ 0.50 0.21 0.86 92928571
+ 0.50 0.21 0.86 100000000
+ 0.50 0.21 0.93 1000000
+ 0.50 0.21 0.93 8071429
+ 0.50 0.21 0.93 15142857
+ 0.50 0.21 0.93 22214286
+ 0.50 0.21 0.93 29285714
+ 0.50 0.21 0.93 36357143
+ 0.50 0.21 0.93 43428571
+ 0.50 0.21 0.93 50500000
+ 0.50 0.21 0.93 57571429
+ 0.50 0.21 0.93 64642857
+ 0.50 0.21 0.93 71714286
+ 0.50 0.21 0.93 78785714
+ 0.50 0.21 0.93 85857143
+ 0.50 0.21 0.93 92928571
+ 0.50 0.21 0.93 100000000
+ 0.50 0.21 1.00 1000000
+ 0.50 0.21 1.00 8071429
+ 0.50 0.21 1.00 15142857
+ 0.50 0.21 1.00 22214286
+ 0.50 0.21 1.00 29285714
+ 0.50 0.21 1.00 36357143
+ 0.50 0.21 1.00 43428571
+ 0.50 0.21 1.00 50500000
+ 0.50 0.21 1.00 57571429
+ 0.50 0.21 1.00 64642857
+ 0.50 0.21 1.00 71714286
+ 0.50 0.21 1.00 78785714
+ 0.50 0.21 1.00 85857143
+ 0.50 0.21 1.00 92928571
+ 0.50 0.21 1.00 100000000
+ 0.50 0.29 0.00 1000000
+ 0.50 0.29 0.00 8071429
+ 0.50 0.29 0.00 15142857
+ 0.50 0.29 0.00 22214286
+ 0.50 0.29 0.00 29285714
+ 0.50 0.29 0.00 36357143
+ 0.50 0.29 0.00 43428571
+ 0.50 0.29 0.00 50500000
+ 0.50 0.29 0.00 57571429
+ 0.50 0.29 0.00 64642857
+ 0.50 0.29 0.00 71714286
+ 0.50 0.29 0.00 78785714
+ 0.50 0.29 0.00 85857143
+ 0.50 0.29 0.00 92928571
+ 0.50 0.29 0.00 100000000
+ 0.50 0.29 0.07 1000000
+ 0.50 0.29 0.07 8071429
+ 0.50 0.29 0.07 15142857
+ 0.50 0.29 0.07 22214286
+ 0.50 0.29 0.07 29285714
+ 0.50 0.29 0.07 36357143
+ 0.50 0.29 0.07 43428571
+ 0.50 0.29 0.07 50500000
+ 0.50 0.29 0.07 57571429
+ 0.50 0.29 0.07 64642857
+ 0.50 0.29 0.07 71714286
+ 0.50 0.29 0.07 78785714
+ 0.50 0.29 0.07 85857143
+ 0.50 0.29 0.07 92928571
+ 0.50 0.29 0.07 100000000
+ 0.50 0.29 0.14 1000000
+ 0.50 0.29 0.14 8071429
+ 0.50 0.29 0.14 15142857
+ 0.50 0.29 0.14 22214286
+ 0.50 0.29 0.14 29285714
+ 0.50 0.29 0.14 36357143
+ 0.50 0.29 0.14 43428571
+ 0.50 0.29 0.14 50500000
+ 0.50 0.29 0.14 57571429
+ 0.50 0.29 0.14 64642857
+ 0.50 0.29 0.14 71714286
+ 0.50 0.29 0.14 78785714
+ 0.50 0.29 0.14 85857143
+ 0.50 0.29 0.14 92928571
+ 0.50 0.29 0.14 100000000
+ 0.50 0.29 0.21 1000000
+ 0.50 0.29 0.21 8071429
+ 0.50 0.29 0.21 15142857
+ 0.50 0.29 0.21 22214286
+ 0.50 0.29 0.21 29285714
+ 0.50 0.29 0.21 36357143
+ 0.50 0.29 0.21 43428571
+ 0.50 0.29 0.21 50500000
+ 0.50 0.29 0.21 57571429
+ 0.50 0.29 0.21 64642857
+ 0.50 0.29 0.21 71714286
+ 0.50 0.29 0.21 78785714
+ 0.50 0.29 0.21 85857143
+ 0.50 0.29 0.21 92928571
+ 0.50 0.29 0.21 100000000
+ 0.50 0.29 0.29 1000000
+ 0.50 0.29 0.29 8071429
+ 0.50 0.29 0.29 15142857
+ 0.50 0.29 0.29 22214286
+ 0.50 0.29 0.29 29285714
+ 0.50 0.29 0.29 36357143
+ 0.50 0.29 0.29 43428571
+ 0.50 0.29 0.29 50500000
+ 0.50 0.29 0.29 57571429
+ 0.50 0.29 0.29 64642857
+ 0.50 0.29 0.29 71714286
+ 0.50 0.29 0.29 78785714
+ 0.50 0.29 0.29 85857143
+ 0.50 0.29 0.29 92928571
+ 0.50 0.29 0.29 100000000
+ 0.50 0.29 0.36 1000000
+ 0.50 0.29 0.36 8071429
+ 0.50 0.29 0.36 15142857
+ 0.50 0.29 0.36 22214286
+ 0.50 0.29 0.36 29285714
+ 0.50 0.29 0.36 36357143
+ 0.50 0.29 0.36 43428571
+ 0.50 0.29 0.36 50500000
+ 0.50 0.29 0.36 57571429
+ 0.50 0.29 0.36 64642857
+ 0.50 0.29 0.36 71714286
+ 0.50 0.29 0.36 78785714
+ 0.50 0.29 0.36 85857143
+ 0.50 0.29 0.36 92928571
+ 0.50 0.29 0.36 100000000
+ 0.50 0.29 0.43 1000000
+ 0.50 0.29 0.43 8071429
+ 0.50 0.29 0.43 15142857
+ 0.50 0.29 0.43 22214286
+ 0.50 0.29 0.43 29285714
+ 0.50 0.29 0.43 36357143
+ 0.50 0.29 0.43 43428571
+ 0.50 0.29 0.43 50500000
+ 0.50 0.29 0.43 57571429
+ 0.50 0.29 0.43 64642857
+ 0.50 0.29 0.43 71714286
+ 0.50 0.29 0.43 78785714
+ 0.50 0.29 0.43 85857143
+ 0.50 0.29 0.43 92928571
+ 0.50 0.29 0.43 100000000
+ 0.50 0.29 0.50 1000000
+ 0.50 0.29 0.50 8071429
+ 0.50 0.29 0.50 15142857
+ 0.50 0.29 0.50 22214286
+ 0.50 0.29 0.50 29285714
+ 0.50 0.29 0.50 36357143
+ 0.50 0.29 0.50 43428571
+ 0.50 0.29 0.50 50500000
+ 0.50 0.29 0.50 57571429
+ 0.50 0.29 0.50 64642857
+ 0.50 0.29 0.50 71714286
+ 0.50 0.29 0.50 78785714
+ 0.50 0.29 0.50 85857143
+ 0.50 0.29 0.50 92928571
+ 0.50 0.29 0.50 100000000
+ 0.50 0.29 0.57 1000000
+ 0.50 0.29 0.57 8071429
+ 0.50 0.29 0.57 15142857
+ 0.50 0.29 0.57 22214286
+ 0.50 0.29 0.57 29285714
+ 0.50 0.29 0.57 36357143
+ 0.50 0.29 0.57 43428571
+ 0.50 0.29 0.57 50500000
+ 0.50 0.29 0.57 57571429
+ 0.50 0.29 0.57 64642857
+ 0.50 0.29 0.57 71714286
+ 0.50 0.29 0.57 78785714
+ 0.50 0.29 0.57 85857143
+ 0.50 0.29 0.57 92928571
+ 0.50 0.29 0.57 100000000
+ 0.50 0.29 0.64 1000000
+ 0.50 0.29 0.64 8071429
+ 0.50 0.29 0.64 15142857
+ 0.50 0.29 0.64 22214286
+ 0.50 0.29 0.64 29285714
+ 0.50 0.29 0.64 36357143
+ 0.50 0.29 0.64 43428571
+ 0.50 0.29 0.64 50500000
+ 0.50 0.29 0.64 57571429
+ 0.50 0.29 0.64 64642857
+ 0.50 0.29 0.64 71714286
+ 0.50 0.29 0.64 78785714
+ 0.50 0.29 0.64 85857143
+ 0.50 0.29 0.64 92928571
+ 0.50 0.29 0.64 100000000
+ 0.50 0.29 0.71 1000000
+ 0.50 0.29 0.71 8071429
+ 0.50 0.29 0.71 15142857
+ 0.50 0.29 0.71 22214286
+ 0.50 0.29 0.71 29285714
+ 0.50 0.29 0.71 36357143
+ 0.50 0.29 0.71 43428571
+ 0.50 0.29 0.71 50500000
+ 0.50 0.29 0.71 57571429
+ 0.50 0.29 0.71 64642857
+ 0.50 0.29 0.71 71714286
+ 0.50 0.29 0.71 78785714
+ 0.50 0.29 0.71 85857143
+ 0.50 0.29 0.71 92928571
+ 0.50 0.29 0.71 100000000
+ 0.50 0.29 0.79 1000000
+ 0.50 0.29 0.79 8071429
+ 0.50 0.29 0.79 15142857
+ 0.50 0.29 0.79 22214286
+ 0.50 0.29 0.79 29285714
+ 0.50 0.29 0.79 36357143
+ 0.50 0.29 0.79 43428571
+ 0.50 0.29 0.79 50500000
+ 0.50 0.29 0.79 57571429
+ 0.50 0.29 0.79 64642857
+ 0.50 0.29 0.79 71714286
+ 0.50 0.29 0.79 78785714
+ 0.50 0.29 0.79 85857143
+ 0.50 0.29 0.79 92928571
+ 0.50 0.29 0.79 100000000
+ 0.50 0.29 0.86 1000000
+ 0.50 0.29 0.86 8071429
+ 0.50 0.29 0.86 15142857
+ 0.50 0.29 0.86 22214286
+ 0.50 0.29 0.86 29285714
+ 0.50 0.29 0.86 36357143
+ 0.50 0.29 0.86 43428571
+ 0.50 0.29 0.86 50500000
+ 0.50 0.29 0.86 57571429
+ 0.50 0.29 0.86 64642857
+ 0.50 0.29 0.86 71714286
+ 0.50 0.29 0.86 78785714
+ 0.50 0.29 0.86 85857143
+ 0.50 0.29 0.86 92928571
+ 0.50 0.29 0.86 100000000
+ 0.50 0.29 0.93 1000000
+ 0.50 0.29 0.93 8071429
+ 0.50 0.29 0.93 15142857
+ 0.50 0.29 0.93 22214286
+ 0.50 0.29 0.93 29285714
+ 0.50 0.29 0.93 36357143
+ 0.50 0.29 0.93 43428571
+ 0.50 0.29 0.93 50500000
+ 0.50 0.29 0.93 57571429
+ 0.50 0.29 0.93 64642857
+ 0.50 0.29 0.93 71714286
+ 0.50 0.29 0.93 78785714
+ 0.50 0.29 0.93 85857143
+ 0.50 0.29 0.93 92928571
+ 0.50 0.29 0.93 100000000
+ 0.50 0.29 1.00 1000000
+ 0.50 0.29 1.00 8071429
+ 0.50 0.29 1.00 15142857
+ 0.50 0.29 1.00 22214286
+ 0.50 0.29 1.00 29285714
+ 0.50 0.29 1.00 36357143
+ 0.50 0.29 1.00 43428571
+ 0.50 0.29 1.00 50500000
+ 0.50 0.29 1.00 57571429
+ 0.50 0.29 1.00 64642857
+ 0.50 0.29 1.00 71714286
+ 0.50 0.29 1.00 78785714
+ 0.50 0.29 1.00 85857143
+ 0.50 0.29 1.00 92928571
+ 0.50 0.29 1.00 100000000
+ 0.50 0.36 0.00 1000000
+ 0.50 0.36 0.00 8071429
+ 0.50 0.36 0.00 15142857
+ 0.50 0.36 0.00 22214286
+ 0.50 0.36 0.00 29285714
+ 0.50 0.36 0.00 36357143
+ 0.50 0.36 0.00 43428571
+ 0.50 0.36 0.00 50500000
+ 0.50 0.36 0.00 57571429
+ 0.50 0.36 0.00 64642857
+ 0.50 0.36 0.00 71714286
+ 0.50 0.36 0.00 78785714
+ 0.50 0.36 0.00 85857143
+ 0.50 0.36 0.00 92928571
+ 0.50 0.36 0.00 100000000
+ 0.50 0.36 0.07 1000000
+ 0.50 0.36 0.07 8071429
+ 0.50 0.36 0.07 15142857
+ 0.50 0.36 0.07 22214286
+ 0.50 0.36 0.07 29285714
+ 0.50 0.36 0.07 36357143
+ 0.50 0.36 0.07 43428571
+ 0.50 0.36 0.07 50500000
+ 0.50 0.36 0.07 57571429
+ 0.50 0.36 0.07 64642857
+ 0.50 0.36 0.07 71714286
+ 0.50 0.36 0.07 78785714
+ 0.50 0.36 0.07 85857143
+ 0.50 0.36 0.07 92928571
+ 0.50 0.36 0.07 100000000
+ 0.50 0.36 0.14 1000000
+ 0.50 0.36 0.14 8071429
+ 0.50 0.36 0.14 15142857
+ 0.50 0.36 0.14 22214286
+ 0.50 0.36 0.14 29285714
+ 0.50 0.36 0.14 36357143
+ 0.50 0.36 0.14 43428571
+ 0.50 0.36 0.14 50500000
+ 0.50 0.36 0.14 57571429
+ 0.50 0.36 0.14 64642857
+ 0.50 0.36 0.14 71714286
+ 0.50 0.36 0.14 78785714
+ 0.50 0.36 0.14 85857143
+ 0.50 0.36 0.14 92928571
+ 0.50 0.36 0.14 100000000
+ 0.50 0.36 0.21 1000000
+ 0.50 0.36 0.21 8071429
+ 0.50 0.36 0.21 15142857
+ 0.50 0.36 0.21 22214286
+ 0.50 0.36 0.21 29285714
+ 0.50 0.36 0.21 36357143
+ 0.50 0.36 0.21 43428571
+ 0.50 0.36 0.21 50500000
+ 0.50 0.36 0.21 57571429
+ 0.50 0.36 0.21 64642857
+ 0.50 0.36 0.21 71714286
+ 0.50 0.36 0.21 78785714
+ 0.50 0.36 0.21 85857143
+ 0.50 0.36 0.21 92928571
+ 0.50 0.36 0.21 100000000
+ 0.50 0.36 0.29 1000000
+ 0.50 0.36 0.29 8071429
+ 0.50 0.36 0.29 15142857
+ 0.50 0.36 0.29 22214286
+ 0.50 0.36 0.29 29285714
+ 0.50 0.36 0.29 36357143
+ 0.50 0.36 0.29 43428571
+ 0.50 0.36 0.29 50500000
+ 0.50 0.36 0.29 57571429
+ 0.50 0.36 0.29 64642857
+ 0.50 0.36 0.29 71714286
+ 0.50 0.36 0.29 78785714
+ 0.50 0.36 0.29 85857143
+ 0.50 0.36 0.29 92928571
+ 0.50 0.36 0.29 100000000
+ 0.50 0.36 0.36 1000000
+ 0.50 0.36 0.36 8071429
+ 0.50 0.36 0.36 15142857
+ 0.50 0.36 0.36 22214286
+ 0.50 0.36 0.36 29285714
+ 0.50 0.36 0.36 36357143
+ 0.50 0.36 0.36 43428571
+ 0.50 0.36 0.36 50500000
+ 0.50 0.36 0.36 57571429
+ 0.50 0.36 0.36 64642857
+ 0.50 0.36 0.36 71714286
+ 0.50 0.36 0.36 78785714
+ 0.50 0.36 0.36 85857143
+ 0.50 0.36 0.36 92928571
+ 0.50 0.36 0.36 100000000
+ 0.50 0.36 0.43 1000000
+ 0.50 0.36 0.43 8071429
+ 0.50 0.36 0.43 15142857
+ 0.50 0.36 0.43 22214286
+ 0.50 0.36 0.43 29285714
+ 0.50 0.36 0.43 36357143
+ 0.50 0.36 0.43 43428571
+ 0.50 0.36 0.43 50500000
+ 0.50 0.36 0.43 57571429
+ 0.50 0.36 0.43 64642857
+ 0.50 0.36 0.43 71714286
+ 0.50 0.36 0.43 78785714
+ 0.50 0.36 0.43 85857143
+ 0.50 0.36 0.43 92928571
+ 0.50 0.36 0.43 100000000
+ 0.50 0.36 0.50 1000000
+ 0.50 0.36 0.50 8071429
+ 0.50 0.36 0.50 15142857
+ 0.50 0.36 0.50 22214286
+ 0.50 0.36 0.50 29285714
+ 0.50 0.36 0.50 36357143
+ 0.50 0.36 0.50 43428571
+ 0.50 0.36 0.50 50500000
+ 0.50 0.36 0.50 57571429
+ 0.50 0.36 0.50 64642857
+ 0.50 0.36 0.50 71714286
+ 0.50 0.36 0.50 78785714
+ 0.50 0.36 0.50 85857143
+ 0.50 0.36 0.50 92928571
+ 0.50 0.36 0.50 100000000
+ 0.50 0.36 0.57 1000000
+ 0.50 0.36 0.57 8071429
+ 0.50 0.36 0.57 15142857
+ 0.50 0.36 0.57 22214286
+ 0.50 0.36 0.57 29285714
+ 0.50 0.36 0.57 36357143
+ 0.50 0.36 0.57 43428571
+ 0.50 0.36 0.57 50500000
+ 0.50 0.36 0.57 57571429
+ 0.50 0.36 0.57 64642857
+ 0.50 0.36 0.57 71714286
+ 0.50 0.36 0.57 78785714
+ 0.50 0.36 0.57 85857143
+ 0.50 0.36 0.57 92928571
+ 0.50 0.36 0.57 100000000
+ 0.50 0.36 0.64 1000000
+ 0.50 0.36 0.64 8071429
+ 0.50 0.36 0.64 15142857
+ 0.50 0.36 0.64 22214286
+ 0.50 0.36 0.64 29285714
+ 0.50 0.36 0.64 36357143
+ 0.50 0.36 0.64 43428571
+ 0.50 0.36 0.64 50500000
+ 0.50 0.36 0.64 57571429
+ 0.50 0.36 0.64 64642857
+ 0.50 0.36 0.64 71714286
+ 0.50 0.36 0.64 78785714
+ 0.50 0.36 0.64 85857143
+ 0.50 0.36 0.64 92928571
+ 0.50 0.36 0.64 100000000
+ 0.50 0.36 0.71 1000000
+ 0.50 0.36 0.71 8071429
+ 0.50 0.36 0.71 15142857
+ 0.50 0.36 0.71 22214286
+ 0.50 0.36 0.71 29285714
+ 0.50 0.36 0.71 36357143
+ 0.50 0.36 0.71 43428571
+ 0.50 0.36 0.71 50500000
+ 0.50 0.36 0.71 57571429
+ 0.50 0.36 0.71 64642857
+ 0.50 0.36 0.71 71714286
+ 0.50 0.36 0.71 78785714
+ 0.50 0.36 0.71 85857143
+ 0.50 0.36 0.71 92928571
+ 0.50 0.36 0.71 100000000
+ 0.50 0.36 0.79 1000000
+ 0.50 0.36 0.79 8071429
+ 0.50 0.36 0.79 15142857
+ 0.50 0.36 0.79 22214286
+ 0.50 0.36 0.79 29285714
+ 0.50 0.36 0.79 36357143
+ 0.50 0.36 0.79 43428571
+ 0.50 0.36 0.79 50500000
+ 0.50 0.36 0.79 57571429
+ 0.50 0.36 0.79 64642857
+ 0.50 0.36 0.79 71714286
+ 0.50 0.36 0.79 78785714
+ 0.50 0.36 0.79 85857143
+ 0.50 0.36 0.79 92928571
+ 0.50 0.36 0.79 100000000
+ 0.50 0.36 0.86 1000000
+ 0.50 0.36 0.86 8071429
+ 0.50 0.36 0.86 15142857
+ 0.50 0.36 0.86 22214286
+ 0.50 0.36 0.86 29285714
+ 0.50 0.36 0.86 36357143
+ 0.50 0.36 0.86 43428571
+ 0.50 0.36 0.86 50500000
+ 0.50 0.36 0.86 57571429
+ 0.50 0.36 0.86 64642857
+ 0.50 0.36 0.86 71714286
+ 0.50 0.36 0.86 78785714
+ 0.50 0.36 0.86 85857143
+ 0.50 0.36 0.86 92928571
+ 0.50 0.36 0.86 100000000
+ 0.50 0.36 0.93 1000000
+ 0.50 0.36 0.93 8071429
+ 0.50 0.36 0.93 15142857
+ 0.50 0.36 0.93 22214286
+ 0.50 0.36 0.93 29285714
+ 0.50 0.36 0.93 36357143
+ 0.50 0.36 0.93 43428571
+ 0.50 0.36 0.93 50500000
+ 0.50 0.36 0.93 57571429
+ 0.50 0.36 0.93 64642857
+ 0.50 0.36 0.93 71714286
+ 0.50 0.36 0.93 78785714
+ 0.50 0.36 0.93 85857143
+ 0.50 0.36 0.93 92928571
+ 0.50 0.36 0.93 100000000
+ 0.50 0.36 1.00 1000000
+ 0.50 0.36 1.00 8071429
+ 0.50 0.36 1.00 15142857
+ 0.50 0.36 1.00 22214286
+ 0.50 0.36 1.00 29285714
+ 0.50 0.36 1.00 36357143
+ 0.50 0.36 1.00 43428571
+ 0.50 0.36 1.00 50500000
+ 0.50 0.36 1.00 57571429
+ 0.50 0.36 1.00 64642857
+ 0.50 0.36 1.00 71714286
+ 0.50 0.36 1.00 78785714
+ 0.50 0.36 1.00 85857143
+ 0.50 0.36 1.00 92928571
+ 0.50 0.36 1.00 100000000
+ 0.50 0.43 0.00 1000000
+ 0.50 0.43 0.00 8071429
+ 0.50 0.43 0.00 15142857
+ 0.50 0.43 0.00 22214286
+ 0.50 0.43 0.00 29285714
+ 0.50 0.43 0.00 36357143
+ 0.50 0.43 0.00 43428571
+ 0.50 0.43 0.00 50500000
+ 0.50 0.43 0.00 57571429
+ 0.50 0.43 0.00 64642857
+ 0.50 0.43 0.00 71714286
+ 0.50 0.43 0.00 78785714
+ 0.50 0.43 0.00 85857143
+ 0.50 0.43 0.00 92928571
+ 0.50 0.43 0.00 100000000
+ 0.50 0.43 0.07 1000000
+ 0.50 0.43 0.07 8071429
+ 0.50 0.43 0.07 15142857
+ 0.50 0.43 0.07 22214286
+ 0.50 0.43 0.07 29285714
+ 0.50 0.43 0.07 36357143
+ 0.50 0.43 0.07 43428571
+ 0.50 0.43 0.07 50500000
+ 0.50 0.43 0.07 57571429
+ 0.50 0.43 0.07 64642857
+ 0.50 0.43 0.07 71714286
+ 0.50 0.43 0.07 78785714
+ 0.50 0.43 0.07 85857143
+ 0.50 0.43 0.07 92928571
+ 0.50 0.43 0.07 100000000
+ 0.50 0.43 0.14 1000000
+ 0.50 0.43 0.14 8071429
+ 0.50 0.43 0.14 15142857
+ 0.50 0.43 0.14 22214286
+ 0.50 0.43 0.14 29285714
+ 0.50 0.43 0.14 36357143
+ 0.50 0.43 0.14 43428571
+ 0.50 0.43 0.14 50500000
+ 0.50 0.43 0.14 57571429
+ 0.50 0.43 0.14 64642857
+ 0.50 0.43 0.14 71714286
+ 0.50 0.43 0.14 78785714
+ 0.50 0.43 0.14 85857143
+ 0.50 0.43 0.14 92928571
+ 0.50 0.43 0.14 100000000
+ 0.50 0.43 0.21 1000000
+ 0.50 0.43 0.21 8071429
+ 0.50 0.43 0.21 15142857
+ 0.50 0.43 0.21 22214286
+ 0.50 0.43 0.21 29285714
+ 0.50 0.43 0.21 36357143
+ 0.50 0.43 0.21 43428571
+ 0.50 0.43 0.21 50500000
+ 0.50 0.43 0.21 57571429
+ 0.50 0.43 0.21 64642857
+ 0.50 0.43 0.21 71714286
+ 0.50 0.43 0.21 78785714
+ 0.50 0.43 0.21 85857143
+ 0.50 0.43 0.21 92928571
+ 0.50 0.43 0.21 100000000
+ 0.50 0.43 0.29 1000000
+ 0.50 0.43 0.29 8071429
+ 0.50 0.43 0.29 15142857
+ 0.50 0.43 0.29 22214286
+ 0.50 0.43 0.29 29285714
+ 0.50 0.43 0.29 36357143
+ 0.50 0.43 0.29 43428571
+ 0.50 0.43 0.29 50500000
+ 0.50 0.43 0.29 57571429
+ 0.50 0.43 0.29 64642857
+ 0.50 0.43 0.29 71714286
+ 0.50 0.43 0.29 78785714
+ 0.50 0.43 0.29 85857143
+ 0.50 0.43 0.29 92928571
+ 0.50 0.43 0.29 100000000
+ 0.50 0.43 0.36 1000000
+ 0.50 0.43 0.36 8071429
+ 0.50 0.43 0.36 15142857
+ 0.50 0.43 0.36 22214286
+ 0.50 0.43 0.36 29285714
+ 0.50 0.43 0.36 36357143
+ 0.50 0.43 0.36 43428571
+ 0.50 0.43 0.36 50500000
+ 0.50 0.43 0.36 57571429
+ 0.50 0.43 0.36 64642857
+ 0.50 0.43 0.36 71714286
+ 0.50 0.43 0.36 78785714
+ 0.50 0.43 0.36 85857143
+ 0.50 0.43 0.36 92928571
+ 0.50 0.43 0.36 100000000
+ 0.50 0.43 0.43 1000000
+ 0.50 0.43 0.43 8071429
+ 0.50 0.43 0.43 15142857
+ 0.50 0.43 0.43 22214286
+ 0.50 0.43 0.43 29285714
+ 0.50 0.43 0.43 36357143
+ 0.50 0.43 0.43 43428571
+ 0.50 0.43 0.43 50500000
+ 0.50 0.43 0.43 57571429
+ 0.50 0.43 0.43 64642857
+ 0.50 0.43 0.43 71714286
+ 0.50 0.43 0.43 78785714
+ 0.50 0.43 0.43 85857143
+ 0.50 0.43 0.43 92928571
+ 0.50 0.43 0.43 100000000
+ 0.50 0.43 0.50 1000000
+ 0.50 0.43 0.50 8071429
+ 0.50 0.43 0.50 15142857
+ 0.50 0.43 0.50 22214286
+ 0.50 0.43 0.50 29285714
+ 0.50 0.43 0.50 36357143
+ 0.50 0.43 0.50 43428571
+ 0.50 0.43 0.50 50500000
+ 0.50 0.43 0.50 57571429
+ 0.50 0.43 0.50 64642857
+ 0.50 0.43 0.50 71714286
+ 0.50 0.43 0.50 78785714
+ 0.50 0.43 0.50 85857143
+ 0.50 0.43 0.50 92928571
+ 0.50 0.43 0.50 100000000
+ 0.50 0.43 0.57 1000000
+ 0.50 0.43 0.57 8071429
+ 0.50 0.43 0.57 15142857
+ 0.50 0.43 0.57 22214286
+ 0.50 0.43 0.57 29285714
+ 0.50 0.43 0.57 36357143
+ 0.50 0.43 0.57 43428571
+ 0.50 0.43 0.57 50500000
+ 0.50 0.43 0.57 57571429
+ 0.50 0.43 0.57 64642857
+ 0.50 0.43 0.57 71714286
+ 0.50 0.43 0.57 78785714
+ 0.50 0.43 0.57 85857143
+ 0.50 0.43 0.57 92928571
+ 0.50 0.43 0.57 100000000
+ 0.50 0.43 0.64 1000000
+ 0.50 0.43 0.64 8071429
+ 0.50 0.43 0.64 15142857
+ 0.50 0.43 0.64 22214286
+ 0.50 0.43 0.64 29285714
+ 0.50 0.43 0.64 36357143
+ 0.50 0.43 0.64 43428571
+ 0.50 0.43 0.64 50500000
+ 0.50 0.43 0.64 57571429
+ 0.50 0.43 0.64 64642857
+ 0.50 0.43 0.64 71714286
+ 0.50 0.43 0.64 78785714
+ 0.50 0.43 0.64 85857143
+ 0.50 0.43 0.64 92928571
+ 0.50 0.43 0.64 100000000
+ 0.50 0.43 0.71 1000000
+ 0.50 0.43 0.71 8071429
+ 0.50 0.43 0.71 15142857
+ 0.50 0.43 0.71 22214286
+ 0.50 0.43 0.71 29285714
+ 0.50 0.43 0.71 36357143
+ 0.50 0.43 0.71 43428571
+ 0.50 0.43 0.71 50500000
+ 0.50 0.43 0.71 57571429
+ 0.50 0.43 0.71 64642857
+ 0.50 0.43 0.71 71714286
+ 0.50 0.43 0.71 78785714
+ 0.50 0.43 0.71 85857143
+ 0.50 0.43 0.71 92928571
+ 0.50 0.43 0.71 100000000
+ 0.50 0.43 0.79 1000000
+ 0.50 0.43 0.79 8071429
+ 0.50 0.43 0.79 15142857
+ 0.50 0.43 0.79 22214286
+ 0.50 0.43 0.79 29285714
+ 0.50 0.43 0.79 36357143
+ 0.50 0.43 0.79 43428571
+ 0.50 0.43 0.79 50500000
+ 0.50 0.43 0.79 57571429
+ 0.50 0.43 0.79 64642857
+ 0.50 0.43 0.79 71714286
+ 0.50 0.43 0.79 78785714
+ 0.50 0.43 0.79 85857143
+ 0.50 0.43 0.79 92928571
+ 0.50 0.43 0.79 100000000
+ 0.50 0.43 0.86 1000000
+ 0.50 0.43 0.86 8071429
+ 0.50 0.43 0.86 15142857
+ 0.50 0.43 0.86 22214286
+ 0.50 0.43 0.86 29285714
+ 0.50 0.43 0.86 36357143
+ 0.50 0.43 0.86 43428571
+ 0.50 0.43 0.86 50500000
+ 0.50 0.43 0.86 57571429
+ 0.50 0.43 0.86 64642857
+ 0.50 0.43 0.86 71714286
+ 0.50 0.43 0.86 78785714
+ 0.50 0.43 0.86 85857143
+ 0.50 0.43 0.86 92928571
+ 0.50 0.43 0.86 100000000
+ 0.50 0.43 0.93 1000000
+ 0.50 0.43 0.93 8071429
+ 0.50 0.43 0.93 15142857
+ 0.50 0.43 0.93 22214286
+ 0.50 0.43 0.93 29285714
+ 0.50 0.43 0.93 36357143
+ 0.50 0.43 0.93 43428571
+ 0.50 0.43 0.93 50500000
+ 0.50 0.43 0.93 57571429
+ 0.50 0.43 0.93 64642857
+ 0.50 0.43 0.93 71714286
+ 0.50 0.43 0.93 78785714
+ 0.50 0.43 0.93 85857143
+ 0.50 0.43 0.93 92928571
+ 0.50 0.43 0.93 100000000
+ 0.50 0.43 1.00 1000000
+ 0.50 0.43 1.00 8071429
+ 0.50 0.43 1.00 15142857
+ 0.50 0.43 1.00 22214286
+ 0.50 0.43 1.00 29285714
+ 0.50 0.43 1.00 36357143
+ 0.50 0.43 1.00 43428571
+ 0.50 0.43 1.00 50500000
+ 0.50 0.43 1.00 57571429
+ 0.50 0.43 1.00 64642857
+ 0.50 0.43 1.00 71714286
+ 0.50 0.43 1.00 78785714
+ 0.50 0.43 1.00 85857143
+ 0.50 0.43 1.00 92928571
+ 0.50 0.43 1.00 100000000
+ 0.50 0.50 0.00 1000000
+ 0.50 0.50 0.00 8071429
+ 0.50 0.50 0.00 15142857
+ 0.50 0.50 0.00 22214286
+ 0.50 0.50 0.00 29285714
+ 0.50 0.50 0.00 36357143
+ 0.50 0.50 0.00 43428571
+ 0.50 0.50 0.00 50500000
+ 0.50 0.50 0.00 57571429
+ 0.50 0.50 0.00 64642857
+ 0.50 0.50 0.00 71714286
+ 0.50 0.50 0.00 78785714
+ 0.50 0.50 0.00 85857143
+ 0.50 0.50 0.00 92928571
+ 0.50 0.50 0.00 100000000
+ 0.50 0.50 0.07 1000000
+ 0.50 0.50 0.07 8071429
+ 0.50 0.50 0.07 15142857
+ 0.50 0.50 0.07 22214286
+ 0.50 0.50 0.07 29285714
+ 0.50 0.50 0.07 36357143
+ 0.50 0.50 0.07 43428571
+ 0.50 0.50 0.07 50500000
+ 0.50 0.50 0.07 57571429
+ 0.50 0.50 0.07 64642857
+ 0.50 0.50 0.07 71714286
+ 0.50 0.50 0.07 78785714
+ 0.50 0.50 0.07 85857143
+ 0.50 0.50 0.07 92928571
+ 0.50 0.50 0.07 100000000
+ 0.50 0.50 0.14 1000000
+ 0.50 0.50 0.14 8071429
+ 0.50 0.50 0.14 15142857
+ 0.50 0.50 0.14 22214286
+ 0.50 0.50 0.14 29285714
+ 0.50 0.50 0.14 36357143
+ 0.50 0.50 0.14 43428571
+ 0.50 0.50 0.14 50500000
+ 0.50 0.50 0.14 57571429
+ 0.50 0.50 0.14 64642857
+ 0.50 0.50 0.14 71714286
+ 0.50 0.50 0.14 78785714
+ 0.50 0.50 0.14 85857143
+ 0.50 0.50 0.14 92928571
+ 0.50 0.50 0.14 100000000
+ 0.50 0.50 0.21 1000000
+ 0.50 0.50 0.21 8071429
+ 0.50 0.50 0.21 15142857
+ 0.50 0.50 0.21 22214286
+ 0.50 0.50 0.21 29285714
+ 0.50 0.50 0.21 36357143
+ 0.50 0.50 0.21 43428571
+ 0.50 0.50 0.21 50500000
+ 0.50 0.50 0.21 57571429
+ 0.50 0.50 0.21 64642857
+ 0.50 0.50 0.21 71714286
+ 0.50 0.50 0.21 78785714
+ 0.50 0.50 0.21 85857143
+ 0.50 0.50 0.21 92928571
+ 0.50 0.50 0.21 100000000
+ 0.50 0.50 0.29 1000000
+ 0.50 0.50 0.29 8071429
+ 0.50 0.50 0.29 15142857
+ 0.50 0.50 0.29 22214286
+ 0.50 0.50 0.29 29285714
+ 0.50 0.50 0.29 36357143
+ 0.50 0.50 0.29 43428571
+ 0.50 0.50 0.29 50500000
+ 0.50 0.50 0.29 57571429
+ 0.50 0.50 0.29 64642857
+ 0.50 0.50 0.29 71714286
+ 0.50 0.50 0.29 78785714
+ 0.50 0.50 0.29 85857143
+ 0.50 0.50 0.29 92928571
+ 0.50 0.50 0.29 100000000
+ 0.50 0.50 0.36 1000000
+ 0.50 0.50 0.36 8071429
+ 0.50 0.50 0.36 15142857
+ 0.50 0.50 0.36 22214286
+ 0.50 0.50 0.36 29285714
+ 0.50 0.50 0.36 36357143
+ 0.50 0.50 0.36 43428571
+ 0.50 0.50 0.36 50500000
+ 0.50 0.50 0.36 57571429
+ 0.50 0.50 0.36 64642857
+ 0.50 0.50 0.36 71714286
+ 0.50 0.50 0.36 78785714
+ 0.50 0.50 0.36 85857143
+ 0.50 0.50 0.36 92928571
+ 0.50 0.50 0.36 100000000
+ 0.50 0.50 0.43 1000000
+ 0.50 0.50 0.43 8071429
+ 0.50 0.50 0.43 15142857
+ 0.50 0.50 0.43 22214286
+ 0.50 0.50 0.43 29285714
+ 0.50 0.50 0.43 36357143
+ 0.50 0.50 0.43 43428571
+ 0.50 0.50 0.43 50500000
+ 0.50 0.50 0.43 57571429
+ 0.50 0.50 0.43 64642857
+ 0.50 0.50 0.43 71714286
+ 0.50 0.50 0.43 78785714
+ 0.50 0.50 0.43 85857143
+ 0.50 0.50 0.43 92928571
+ 0.50 0.50 0.43 100000000
+ 0.50 0.50 0.50 1000000
+ 0.50 0.50 0.50 8071429
+ 0.50 0.50 0.50 15142857
+ 0.50 0.50 0.50 22214286
+ 0.50 0.50 0.50 29285714
+ 0.50 0.50 0.50 36357143
+ 0.50 0.50 0.50 43428571
+ 0.50 0.50 0.50 50500000
+ 0.50 0.50 0.50 57571429
+ 0.50 0.50 0.50 64642857
+ 0.50 0.50 0.50 71714286
+ 0.50 0.50 0.50 78785714
+ 0.50 0.50 0.50 85857143
+ 0.50 0.50 0.50 92928571
+ 0.50 0.50 0.50 100000000
+ 0.50 0.50 0.57 1000000
+ 0.50 0.50 0.57 8071429
+ 0.50 0.50 0.57 15142857
+ 0.50 0.50 0.57 22214286
+ 0.50 0.50 0.57 29285714
+ 0.50 0.50 0.57 36357143
+ 0.50 0.50 0.57 43428571
+ 0.50 0.50 0.57 50500000
+ 0.50 0.50 0.57 57571429
+ 0.50 0.50 0.57 64642857
+ 0.50 0.50 0.57 71714286
+ 0.50 0.50 0.57 78785714
+ 0.50 0.50 0.57 85857143
+ 0.50 0.50 0.57 92928571
+ 0.50 0.50 0.57 100000000
+ 0.50 0.50 0.64 1000000
+ 0.50 0.50 0.64 8071429
+ 0.50 0.50 0.64 15142857
+ 0.50 0.50 0.64 22214286
+ 0.50 0.50 0.64 29285714
+ 0.50 0.50 0.64 36357143
+ 0.50 0.50 0.64 43428571
+ 0.50 0.50 0.64 50500000
+ 0.50 0.50 0.64 57571429
+ 0.50 0.50 0.64 64642857
+ 0.50 0.50 0.64 71714286
+ 0.50 0.50 0.64 78785714
+ 0.50 0.50 0.64 85857143
+ 0.50 0.50 0.64 92928571
+ 0.50 0.50 0.64 100000000
+ 0.50 0.50 0.71 1000000
+ 0.50 0.50 0.71 8071429
+ 0.50 0.50 0.71 15142857
+ 0.50 0.50 0.71 22214286
+ 0.50 0.50 0.71 29285714
+ 0.50 0.50 0.71 36357143
+ 0.50 0.50 0.71 43428571
+ 0.50 0.50 0.71 50500000
+ 0.50 0.50 0.71 57571429
+ 0.50 0.50 0.71 64642857
+ 0.50 0.50 0.71 71714286
+ 0.50 0.50 0.71 78785714
+ 0.50 0.50 0.71 85857143
+ 0.50 0.50 0.71 92928571
+ 0.50 0.50 0.71 100000000
+ 0.50 0.50 0.79 1000000
+ 0.50 0.50 0.79 8071429
+ 0.50 0.50 0.79 15142857
+ 0.50 0.50 0.79 22214286
+ 0.50 0.50 0.79 29285714
+ 0.50 0.50 0.79 36357143
+ 0.50 0.50 0.79 43428571
+ 0.50 0.50 0.79 50500000
+ 0.50 0.50 0.79 57571429
+ 0.50 0.50 0.79 64642857
+ 0.50 0.50 0.79 71714286
+ 0.50 0.50 0.79 78785714
+ 0.50 0.50 0.79 85857143
+ 0.50 0.50 0.79 92928571
+ 0.50 0.50 0.79 100000000
+ 0.50 0.50 0.86 1000000
+ 0.50 0.50 0.86 8071429
+ 0.50 0.50 0.86 15142857
+ 0.50 0.50 0.86 22214286
+ 0.50 0.50 0.86 29285714
+ 0.50 0.50 0.86 36357143
+ 0.50 0.50 0.86 43428571
+ 0.50 0.50 0.86 50500000
+ 0.50 0.50 0.86 57571429
+ 0.50 0.50 0.86 64642857
+ 0.50 0.50 0.86 71714286
+ 0.50 0.50 0.86 78785714
+ 0.50 0.50 0.86 85857143
+ 0.50 0.50 0.86 92928571
+ 0.50 0.50 0.86 100000000
+ 0.50 0.50 0.93 1000000
+ 0.50 0.50 0.93 8071429
+ 0.50 0.50 0.93 15142857
+ 0.50 0.50 0.93 22214286
+ 0.50 0.50 0.93 29285714
+ 0.50 0.50 0.93 36357143
+ 0.50 0.50 0.93 43428571
+ 0.50 0.50 0.93 50500000
+ 0.50 0.50 0.93 57571429
+ 0.50 0.50 0.93 64642857
+ 0.50 0.50 0.93 71714286
+ 0.50 0.50 0.93 78785714
+ 0.50 0.50 0.93 85857143
+ 0.50 0.50 0.93 92928571
+ 0.50 0.50 0.93 100000000
+ 0.50 0.50 1.00 1000000
+ 0.50 0.50 1.00 8071429
+ 0.50 0.50 1.00 15142857
+ 0.50 0.50 1.00 22214286
+ 0.50 0.50 1.00 29285714
+ 0.50 0.50 1.00 36357143
+ 0.50 0.50 1.00 43428571
+ 0.50 0.50 1.00 50500000
+ 0.50 0.50 1.00 57571429
+ 0.50 0.50 1.00 64642857
+ 0.50 0.50 1.00 71714286
+ 0.50 0.50 1.00 78785714
+ 0.50 0.50 1.00 85857143
+ 0.50 0.50 1.00 92928571
+ 0.50 0.50 1.00 100000000
+ 0.50 0.57 0.00 1000000
+ 0.50 0.57 0.00 8071429
+ 0.50 0.57 0.00 15142857
+ 0.50 0.57 0.00 22214286
+ 0.50 0.57 0.00 29285714
+ 0.50 0.57 0.00 36357143
+ 0.50 0.57 0.00 43428571
+ 0.50 0.57 0.00 50500000
+ 0.50 0.57 0.00 57571429
+ 0.50 0.57 0.00 64642857
+ 0.50 0.57 0.00 71714286
+ 0.50 0.57 0.00 78785714
+ 0.50 0.57 0.00 85857143
+ 0.50 0.57 0.00 92928571
+ 0.50 0.57 0.00 100000000
+ 0.50 0.57 0.07 1000000
+ 0.50 0.57 0.07 8071429
+ 0.50 0.57 0.07 15142857
+ 0.50 0.57 0.07 22214286
+ 0.50 0.57 0.07 29285714
+ 0.50 0.57 0.07 36357143
+ 0.50 0.57 0.07 43428571
+ 0.50 0.57 0.07 50500000
+ 0.50 0.57 0.07 57571429
+ 0.50 0.57 0.07 64642857
+ 0.50 0.57 0.07 71714286
+ 0.50 0.57 0.07 78785714
+ 0.50 0.57 0.07 85857143
+ 0.50 0.57 0.07 92928571
+ 0.50 0.57 0.07 100000000
+ 0.50 0.57 0.14 1000000
+ 0.50 0.57 0.14 8071429
+ 0.50 0.57 0.14 15142857
+ 0.50 0.57 0.14 22214286
+ 0.50 0.57 0.14 29285714
+ 0.50 0.57 0.14 36357143
+ 0.50 0.57 0.14 43428571
+ 0.50 0.57 0.14 50500000
+ 0.50 0.57 0.14 57571429
+ 0.50 0.57 0.14 64642857
+ 0.50 0.57 0.14 71714286
+ 0.50 0.57 0.14 78785714
+ 0.50 0.57 0.14 85857143
+ 0.50 0.57 0.14 92928571
+ 0.50 0.57 0.14 100000000
+ 0.50 0.57 0.21 1000000
+ 0.50 0.57 0.21 8071429
+ 0.50 0.57 0.21 15142857
+ 0.50 0.57 0.21 22214286
+ 0.50 0.57 0.21 29285714
+ 0.50 0.57 0.21 36357143
+ 0.50 0.57 0.21 43428571
+ 0.50 0.57 0.21 50500000
+ 0.50 0.57 0.21 57571429
+ 0.50 0.57 0.21 64642857
+ 0.50 0.57 0.21 71714286
+ 0.50 0.57 0.21 78785714
+ 0.50 0.57 0.21 85857143
+ 0.50 0.57 0.21 92928571
+ 0.50 0.57 0.21 100000000
+ 0.50 0.57 0.29 1000000
+ 0.50 0.57 0.29 8071429
+ 0.50 0.57 0.29 15142857
+ 0.50 0.57 0.29 22214286
+ 0.50 0.57 0.29 29285714
+ 0.50 0.57 0.29 36357143
+ 0.50 0.57 0.29 43428571
+ 0.50 0.57 0.29 50500000
+ 0.50 0.57 0.29 57571429
+ 0.50 0.57 0.29 64642857
+ 0.50 0.57 0.29 71714286
+ 0.50 0.57 0.29 78785714
+ 0.50 0.57 0.29 85857143
+ 0.50 0.57 0.29 92928571
+ 0.50 0.57 0.29 100000000
+ 0.50 0.57 0.36 1000000
+ 0.50 0.57 0.36 8071429
+ 0.50 0.57 0.36 15142857
+ 0.50 0.57 0.36 22214286
+ 0.50 0.57 0.36 29285714
+ 0.50 0.57 0.36 36357143
+ 0.50 0.57 0.36 43428571
+ 0.50 0.57 0.36 50500000
+ 0.50 0.57 0.36 57571429
+ 0.50 0.57 0.36 64642857
+ 0.50 0.57 0.36 71714286
+ 0.50 0.57 0.36 78785714
+ 0.50 0.57 0.36 85857143
+ 0.50 0.57 0.36 92928571
+ 0.50 0.57 0.36 100000000
+ 0.50 0.57 0.43 1000000
+ 0.50 0.57 0.43 8071429
+ 0.50 0.57 0.43 15142857
+ 0.50 0.57 0.43 22214286
+ 0.50 0.57 0.43 29285714
+ 0.50 0.57 0.43 36357143
+ 0.50 0.57 0.43 43428571
+ 0.50 0.57 0.43 50500000
+ 0.50 0.57 0.43 57571429
+ 0.50 0.57 0.43 64642857
+ 0.50 0.57 0.43 71714286
+ 0.50 0.57 0.43 78785714
+ 0.50 0.57 0.43 85857143
+ 0.50 0.57 0.43 92928571
+ 0.50 0.57 0.43 100000000
+ 0.50 0.57 0.50 1000000
+ 0.50 0.57 0.50 8071429
+ 0.50 0.57 0.50 15142857
+ 0.50 0.57 0.50 22214286
+ 0.50 0.57 0.50 29285714
+ 0.50 0.57 0.50 36357143
+ 0.50 0.57 0.50 43428571
+ 0.50 0.57 0.50 50500000
+ 0.50 0.57 0.50 57571429
+ 0.50 0.57 0.50 64642857
+ 0.50 0.57 0.50 71714286
+ 0.50 0.57 0.50 78785714
+ 0.50 0.57 0.50 85857143
+ 0.50 0.57 0.50 92928571
+ 0.50 0.57 0.50 100000000
+ 0.50 0.57 0.57 1000000
+ 0.50 0.57 0.57 8071429
+ 0.50 0.57 0.57 15142857
+ 0.50 0.57 0.57 22214286
+ 0.50 0.57 0.57 29285714
+ 0.50 0.57 0.57 36357143
+ 0.50 0.57 0.57 43428571
+ 0.50 0.57 0.57 50500000
+ 0.50 0.57 0.57 57571429
+ 0.50 0.57 0.57 64642857
+ 0.50 0.57 0.57 71714286
+ 0.50 0.57 0.57 78785714
+ 0.50 0.57 0.57 85857143
+ 0.50 0.57 0.57 92928571
+ 0.50 0.57 0.57 100000000
+ 0.50 0.57 0.64 1000000
+ 0.50 0.57 0.64 8071429
+ 0.50 0.57 0.64 15142857
+ 0.50 0.57 0.64 22214286
+ 0.50 0.57 0.64 29285714
+ 0.50 0.57 0.64 36357143
+ 0.50 0.57 0.64 43428571
+ 0.50 0.57 0.64 50500000
+ 0.50 0.57 0.64 57571429
+ 0.50 0.57 0.64 64642857
+ 0.50 0.57 0.64 71714286
+ 0.50 0.57 0.64 78785714
+ 0.50 0.57 0.64 85857143
+ 0.50 0.57 0.64 92928571
+ 0.50 0.57 0.64 100000000
+ 0.50 0.57 0.71 1000000
+ 0.50 0.57 0.71 8071429
+ 0.50 0.57 0.71 15142857
+ 0.50 0.57 0.71 22214286
+ 0.50 0.57 0.71 29285714
+ 0.50 0.57 0.71 36357143
+ 0.50 0.57 0.71 43428571
+ 0.50 0.57 0.71 50500000
+ 0.50 0.57 0.71 57571429
+ 0.50 0.57 0.71 64642857
+ 0.50 0.57 0.71 71714286
+ 0.50 0.57 0.71 78785714
+ 0.50 0.57 0.71 85857143
+ 0.50 0.57 0.71 92928571
+ 0.50 0.57 0.71 100000000
+ 0.50 0.57 0.79 1000000
+ 0.50 0.57 0.79 8071429
+ 0.50 0.57 0.79 15142857
+ 0.50 0.57 0.79 22214286
+ 0.50 0.57 0.79 29285714
+ 0.50 0.57 0.79 36357143
+ 0.50 0.57 0.79 43428571
+ 0.50 0.57 0.79 50500000
+ 0.50 0.57 0.79 57571429
+ 0.50 0.57 0.79 64642857
+ 0.50 0.57 0.79 71714286
+ 0.50 0.57 0.79 78785714
+ 0.50 0.57 0.79 85857143
+ 0.50 0.57 0.79 92928571
+ 0.50 0.57 0.79 100000000
+ 0.50 0.57 0.86 1000000
+ 0.50 0.57 0.86 8071429
+ 0.50 0.57 0.86 15142857
+ 0.50 0.57 0.86 22214286
+ 0.50 0.57 0.86 29285714
+ 0.50 0.57 0.86 36357143
+ 0.50 0.57 0.86 43428571
+ 0.50 0.57 0.86 50500000
+ 0.50 0.57 0.86 57571429
+ 0.50 0.57 0.86 64642857
+ 0.50 0.57 0.86 71714286
+ 0.50 0.57 0.86 78785714
+ 0.50 0.57 0.86 85857143
+ 0.50 0.57 0.86 92928571
+ 0.50 0.57 0.86 100000000
+ 0.50 0.57 0.93 1000000
+ 0.50 0.57 0.93 8071429
+ 0.50 0.57 0.93 15142857
+ 0.50 0.57 0.93 22214286
+ 0.50 0.57 0.93 29285714
+ 0.50 0.57 0.93 36357143
+ 0.50 0.57 0.93 43428571
+ 0.50 0.57 0.93 50500000
+ 0.50 0.57 0.93 57571429
+ 0.50 0.57 0.93 64642857
+ 0.50 0.57 0.93 71714286
+ 0.50 0.57 0.93 78785714
+ 0.50 0.57 0.93 85857143
+ 0.50 0.57 0.93 92928571
+ 0.50 0.57 0.93 100000000
+ 0.50 0.57 1.00 1000000
+ 0.50 0.57 1.00 8071429
+ 0.50 0.57 1.00 15142857
+ 0.50 0.57 1.00 22214286
+ 0.50 0.57 1.00 29285714
+ 0.50 0.57 1.00 36357143
+ 0.50 0.57 1.00 43428571
+ 0.50 0.57 1.00 50500000
+ 0.50 0.57 1.00 57571429
+ 0.50 0.57 1.00 64642857
+ 0.50 0.57 1.00 71714286
+ 0.50 0.57 1.00 78785714
+ 0.50 0.57 1.00 85857143
+ 0.50 0.57 1.00 92928571
+ 0.50 0.57 1.00 100000000
+ 0.50 0.64 0.00 1000000
+ 0.50 0.64 0.00 8071429
+ 0.50 0.64 0.00 15142857
+ 0.50 0.64 0.00 22214286
+ 0.50 0.64 0.00 29285714
+ 0.50 0.64 0.00 36357143
+ 0.50 0.64 0.00 43428571
+ 0.50 0.64 0.00 50500000
+ 0.50 0.64 0.00 57571429
+ 0.50 0.64 0.00 64642857
+ 0.50 0.64 0.00 71714286
+ 0.50 0.64 0.00 78785714
+ 0.50 0.64 0.00 85857143
+ 0.50 0.64 0.00 92928571
+ 0.50 0.64 0.00 100000000
+ 0.50 0.64 0.07 1000000
+ 0.50 0.64 0.07 8071429
+ 0.50 0.64 0.07 15142857
+ 0.50 0.64 0.07 22214286
+ 0.50 0.64 0.07 29285714
+ 0.50 0.64 0.07 36357143
+ 0.50 0.64 0.07 43428571
+ 0.50 0.64 0.07 50500000
+ 0.50 0.64 0.07 57571429
+ 0.50 0.64 0.07 64642857
+ 0.50 0.64 0.07 71714286
+ 0.50 0.64 0.07 78785714
+ 0.50 0.64 0.07 85857143
+ 0.50 0.64 0.07 92928571
+ 0.50 0.64 0.07 100000000
+ 0.50 0.64 0.14 1000000
+ 0.50 0.64 0.14 8071429
+ 0.50 0.64 0.14 15142857
+ 0.50 0.64 0.14 22214286
+ 0.50 0.64 0.14 29285714
+ 0.50 0.64 0.14 36357143
+ 0.50 0.64 0.14 43428571
+ 0.50 0.64 0.14 50500000
+ 0.50 0.64 0.14 57571429
+ 0.50 0.64 0.14 64642857
+ 0.50 0.64 0.14 71714286
+ 0.50 0.64 0.14 78785714
+ 0.50 0.64 0.14 85857143
+ 0.50 0.64 0.14 92928571
+ 0.50 0.64 0.14 100000000
+ 0.50 0.64 0.21 1000000
+ 0.50 0.64 0.21 8071429
+ 0.50 0.64 0.21 15142857
+ 0.50 0.64 0.21 22214286
+ 0.50 0.64 0.21 29285714
+ 0.50 0.64 0.21 36357143
+ 0.50 0.64 0.21 43428571
+ 0.50 0.64 0.21 50500000
+ 0.50 0.64 0.21 57571429
+ 0.50 0.64 0.21 64642857
+ 0.50 0.64 0.21 71714286
+ 0.50 0.64 0.21 78785714
+ 0.50 0.64 0.21 85857143
+ 0.50 0.64 0.21 92928571
+ 0.50 0.64 0.21 100000000
+ 0.50 0.64 0.29 1000000
+ 0.50 0.64 0.29 8071429
+ 0.50 0.64 0.29 15142857
+ 0.50 0.64 0.29 22214286
+ 0.50 0.64 0.29 29285714
+ 0.50 0.64 0.29 36357143
+ 0.50 0.64 0.29 43428571
+ 0.50 0.64 0.29 50500000
+ 0.50 0.64 0.29 57571429
+ 0.50 0.64 0.29 64642857
+ 0.50 0.64 0.29 71714286
+ 0.50 0.64 0.29 78785714
+ 0.50 0.64 0.29 85857143
+ 0.50 0.64 0.29 92928571
+ 0.50 0.64 0.29 100000000
+ 0.50 0.64 0.36 1000000
+ 0.50 0.64 0.36 8071429
+ 0.50 0.64 0.36 15142857
+ 0.50 0.64 0.36 22214286
+ 0.50 0.64 0.36 29285714
+ 0.50 0.64 0.36 36357143
+ 0.50 0.64 0.36 43428571
+ 0.50 0.64 0.36 50500000
+ 0.50 0.64 0.36 57571429
+ 0.50 0.64 0.36 64642857
+ 0.50 0.64 0.36 71714286
+ 0.50 0.64 0.36 78785714
+ 0.50 0.64 0.36 85857143
+ 0.50 0.64 0.36 92928571
+ 0.50 0.64 0.36 100000000
+ 0.50 0.64 0.43 1000000
+ 0.50 0.64 0.43 8071429
+ 0.50 0.64 0.43 15142857
+ 0.50 0.64 0.43 22214286
+ 0.50 0.64 0.43 29285714
+ 0.50 0.64 0.43 36357143
+ 0.50 0.64 0.43 43428571
+ 0.50 0.64 0.43 50500000
+ 0.50 0.64 0.43 57571429
+ 0.50 0.64 0.43 64642857
+ 0.50 0.64 0.43 71714286
+ 0.50 0.64 0.43 78785714
+ 0.50 0.64 0.43 85857143
+ 0.50 0.64 0.43 92928571
+ 0.50 0.64 0.43 100000000
+ 0.50 0.64 0.50 1000000
+ 0.50 0.64 0.50 8071429
+ 0.50 0.64 0.50 15142857
+ 0.50 0.64 0.50 22214286
+ 0.50 0.64 0.50 29285714
+ 0.50 0.64 0.50 36357143
+ 0.50 0.64 0.50 43428571
+ 0.50 0.64 0.50 50500000
+ 0.50 0.64 0.50 57571429
+ 0.50 0.64 0.50 64642857
+ 0.50 0.64 0.50 71714286
+ 0.50 0.64 0.50 78785714
+ 0.50 0.64 0.50 85857143
+ 0.50 0.64 0.50 92928571
+ 0.50 0.64 0.50 100000000
+ 0.50 0.64 0.57 1000000
+ 0.50 0.64 0.57 8071429
+ 0.50 0.64 0.57 15142857
+ 0.50 0.64 0.57 22214286
+ 0.50 0.64 0.57 29285714
+ 0.50 0.64 0.57 36357143
+ 0.50 0.64 0.57 43428571
+ 0.50 0.64 0.57 50500000
+ 0.50 0.64 0.57 57571429
+ 0.50 0.64 0.57 64642857
+ 0.50 0.64 0.57 71714286
+ 0.50 0.64 0.57 78785714
+ 0.50 0.64 0.57 85857143
+ 0.50 0.64 0.57 92928571
+ 0.50 0.64 0.57 100000000
+ 0.50 0.64 0.64 1000000
+ 0.50 0.64 0.64 8071429
+ 0.50 0.64 0.64 15142857
+ 0.50 0.64 0.64 22214286
+ 0.50 0.64 0.64 29285714
+ 0.50 0.64 0.64 36357143
+ 0.50 0.64 0.64 43428571
+ 0.50 0.64 0.64 50500000
+ 0.50 0.64 0.64 57571429
+ 0.50 0.64 0.64 64642857
+ 0.50 0.64 0.64 71714286
+ 0.50 0.64 0.64 78785714
+ 0.50 0.64 0.64 85857143
+ 0.50 0.64 0.64 92928571
+ 0.50 0.64 0.64 100000000
+ 0.50 0.64 0.71 1000000
+ 0.50 0.64 0.71 8071429
+ 0.50 0.64 0.71 15142857
+ 0.50 0.64 0.71 22214286
+ 0.50 0.64 0.71 29285714
+ 0.50 0.64 0.71 36357143
+ 0.50 0.64 0.71 43428571
+ 0.50 0.64 0.71 50500000
+ 0.50 0.64 0.71 57571429
+ 0.50 0.64 0.71 64642857
+ 0.50 0.64 0.71 71714286
+ 0.50 0.64 0.71 78785714
+ 0.50 0.64 0.71 85857143
+ 0.50 0.64 0.71 92928571
+ 0.50 0.64 0.71 100000000
+ 0.50 0.64 0.79 1000000
+ 0.50 0.64 0.79 8071429
+ 0.50 0.64 0.79 15142857
+ 0.50 0.64 0.79 22214286
+ 0.50 0.64 0.79 29285714
+ 0.50 0.64 0.79 36357143
+ 0.50 0.64 0.79 43428571
+ 0.50 0.64 0.79 50500000
+ 0.50 0.64 0.79 57571429
+ 0.50 0.64 0.79 64642857
+ 0.50 0.64 0.79 71714286
+ 0.50 0.64 0.79 78785714
+ 0.50 0.64 0.79 85857143
+ 0.50 0.64 0.79 92928571
+ 0.50 0.64 0.79 100000000
+ 0.50 0.64 0.86 1000000
+ 0.50 0.64 0.86 8071429
+ 0.50 0.64 0.86 15142857
+ 0.50 0.64 0.86 22214286
+ 0.50 0.64 0.86 29285714
+ 0.50 0.64 0.86 36357143
+ 0.50 0.64 0.86 43428571
+ 0.50 0.64 0.86 50500000
+ 0.50 0.64 0.86 57571429
+ 0.50 0.64 0.86 64642857
+ 0.50 0.64 0.86 71714286
+ 0.50 0.64 0.86 78785714
+ 0.50 0.64 0.86 85857143
+ 0.50 0.64 0.86 92928571
+ 0.50 0.64 0.86 100000000
+ 0.50 0.64 0.93 1000000
+ 0.50 0.64 0.93 8071429
+ 0.50 0.64 0.93 15142857
+ 0.50 0.64 0.93 22214286
+ 0.50 0.64 0.93 29285714
+ 0.50 0.64 0.93 36357143
+ 0.50 0.64 0.93 43428571
+ 0.50 0.64 0.93 50500000
+ 0.50 0.64 0.93 57571429
+ 0.50 0.64 0.93 64642857
+ 0.50 0.64 0.93 71714286
+ 0.50 0.64 0.93 78785714
+ 0.50 0.64 0.93 85857143
+ 0.50 0.64 0.93 92928571
+ 0.50 0.64 0.93 100000000
+ 0.50 0.64 1.00 1000000
+ 0.50 0.64 1.00 8071429
+ 0.50 0.64 1.00 15142857
+ 0.50 0.64 1.00 22214286
+ 0.50 0.64 1.00 29285714
+ 0.50 0.64 1.00 36357143
+ 0.50 0.64 1.00 43428571
+ 0.50 0.64 1.00 50500000
+ 0.50 0.64 1.00 57571429
+ 0.50 0.64 1.00 64642857
+ 0.50 0.64 1.00 71714286
+ 0.50 0.64 1.00 78785714
+ 0.50 0.64 1.00 85857143
+ 0.50 0.64 1.00 92928571
+ 0.50 0.64 1.00 100000000
+ 0.50 0.71 0.00 1000000
+ 0.50 0.71 0.00 8071429
+ 0.50 0.71 0.00 15142857
+ 0.50 0.71 0.00 22214286
+ 0.50 0.71 0.00 29285714
+ 0.50 0.71 0.00 36357143
+ 0.50 0.71 0.00 43428571
+ 0.50 0.71 0.00 50500000
+ 0.50 0.71 0.00 57571429
+ 0.50 0.71 0.00 64642857
+ 0.50 0.71 0.00 71714286
+ 0.50 0.71 0.00 78785714
+ 0.50 0.71 0.00 85857143
+ 0.50 0.71 0.00 92928571
+ 0.50 0.71 0.00 100000000
+ 0.50 0.71 0.07 1000000
+ 0.50 0.71 0.07 8071429
+ 0.50 0.71 0.07 15142857
+ 0.50 0.71 0.07 22214286
+ 0.50 0.71 0.07 29285714
+ 0.50 0.71 0.07 36357143
+ 0.50 0.71 0.07 43428571
+ 0.50 0.71 0.07 50500000
+ 0.50 0.71 0.07 57571429
+ 0.50 0.71 0.07 64642857
+ 0.50 0.71 0.07 71714286
+ 0.50 0.71 0.07 78785714
+ 0.50 0.71 0.07 85857143
+ 0.50 0.71 0.07 92928571
+ 0.50 0.71 0.07 100000000
+ 0.50 0.71 0.14 1000000
+ 0.50 0.71 0.14 8071429
+ 0.50 0.71 0.14 15142857
+ 0.50 0.71 0.14 22214286
+ 0.50 0.71 0.14 29285714
+ 0.50 0.71 0.14 36357143
+ 0.50 0.71 0.14 43428571
+ 0.50 0.71 0.14 50500000
+ 0.50 0.71 0.14 57571429
+ 0.50 0.71 0.14 64642857
+ 0.50 0.71 0.14 71714286
+ 0.50 0.71 0.14 78785714
+ 0.50 0.71 0.14 85857143
+ 0.50 0.71 0.14 92928571
+ 0.50 0.71 0.14 100000000
+ 0.50 0.71 0.21 1000000
+ 0.50 0.71 0.21 8071429
+ 0.50 0.71 0.21 15142857
+ 0.50 0.71 0.21 22214286
+ 0.50 0.71 0.21 29285714
+ 0.50 0.71 0.21 36357143
+ 0.50 0.71 0.21 43428571
+ 0.50 0.71 0.21 50500000
+ 0.50 0.71 0.21 57571429
+ 0.50 0.71 0.21 64642857
+ 0.50 0.71 0.21 71714286
+ 0.50 0.71 0.21 78785714
+ 0.50 0.71 0.21 85857143
+ 0.50 0.71 0.21 92928571
+ 0.50 0.71 0.21 100000000
+ 0.50 0.71 0.29 1000000
+ 0.50 0.71 0.29 8071429
+ 0.50 0.71 0.29 15142857
+ 0.50 0.71 0.29 22214286
+ 0.50 0.71 0.29 29285714
+ 0.50 0.71 0.29 36357143
+ 0.50 0.71 0.29 43428571
+ 0.50 0.71 0.29 50500000
+ 0.50 0.71 0.29 57571429
+ 0.50 0.71 0.29 64642857
+ 0.50 0.71 0.29 71714286
+ 0.50 0.71 0.29 78785714
+ 0.50 0.71 0.29 85857143
+ 0.50 0.71 0.29 92928571
+ 0.50 0.71 0.29 100000000
+ 0.50 0.71 0.36 1000000
+ 0.50 0.71 0.36 8071429
+ 0.50 0.71 0.36 15142857
+ 0.50 0.71 0.36 22214286
+ 0.50 0.71 0.36 29285714
+ 0.50 0.71 0.36 36357143
+ 0.50 0.71 0.36 43428571
+ 0.50 0.71 0.36 50500000
+ 0.50 0.71 0.36 57571429
+ 0.50 0.71 0.36 64642857
+ 0.50 0.71 0.36 71714286
+ 0.50 0.71 0.36 78785714
+ 0.50 0.71 0.36 85857143
+ 0.50 0.71 0.36 92928571
+ 0.50 0.71 0.36 100000000
+ 0.50 0.71 0.43 1000000
+ 0.50 0.71 0.43 8071429
+ 0.50 0.71 0.43 15142857
+ 0.50 0.71 0.43 22214286
+ 0.50 0.71 0.43 29285714
+ 0.50 0.71 0.43 36357143
+ 0.50 0.71 0.43 43428571
+ 0.50 0.71 0.43 50500000
+ 0.50 0.71 0.43 57571429
+ 0.50 0.71 0.43 64642857
+ 0.50 0.71 0.43 71714286
+ 0.50 0.71 0.43 78785714
+ 0.50 0.71 0.43 85857143
+ 0.50 0.71 0.43 92928571
+ 0.50 0.71 0.43 100000000
+ 0.50 0.71 0.50 1000000
+ 0.50 0.71 0.50 8071429
+ 0.50 0.71 0.50 15142857
+ 0.50 0.71 0.50 22214286
+ 0.50 0.71 0.50 29285714
+ 0.50 0.71 0.50 36357143
+ 0.50 0.71 0.50 43428571
+ 0.50 0.71 0.50 50500000
+ 0.50 0.71 0.50 57571429
+ 0.50 0.71 0.50 64642857
+ 0.50 0.71 0.50 71714286
+ 0.50 0.71 0.50 78785714
+ 0.50 0.71 0.50 85857143
+ 0.50 0.71 0.50 92928571
+ 0.50 0.71 0.50 100000000
+ 0.50 0.71 0.57 1000000
+ 0.50 0.71 0.57 8071429
+ 0.50 0.71 0.57 15142857
+ 0.50 0.71 0.57 22214286
+ 0.50 0.71 0.57 29285714
+ 0.50 0.71 0.57 36357143
+ 0.50 0.71 0.57 43428571
+ 0.50 0.71 0.57 50500000
+ 0.50 0.71 0.57 57571429
+ 0.50 0.71 0.57 64642857
+ 0.50 0.71 0.57 71714286
+ 0.50 0.71 0.57 78785714
+ 0.50 0.71 0.57 85857143
+ 0.50 0.71 0.57 92928571
+ 0.50 0.71 0.57 100000000
+ 0.50 0.71 0.64 1000000
+ 0.50 0.71 0.64 8071429
+ 0.50 0.71 0.64 15142857
+ 0.50 0.71 0.64 22214286
+ 0.50 0.71 0.64 29285714
+ 0.50 0.71 0.64 36357143
+ 0.50 0.71 0.64 43428571
+ 0.50 0.71 0.64 50500000
+ 0.50 0.71 0.64 57571429
+ 0.50 0.71 0.64 64642857
+ 0.50 0.71 0.64 71714286
+ 0.50 0.71 0.64 78785714
+ 0.50 0.71 0.64 85857143
+ 0.50 0.71 0.64 92928571
+ 0.50 0.71 0.64 100000000
+ 0.50 0.71 0.71 1000000
+ 0.50 0.71 0.71 8071429
+ 0.50 0.71 0.71 15142857
+ 0.50 0.71 0.71 22214286
+ 0.50 0.71 0.71 29285714
+ 0.50 0.71 0.71 36357143
+ 0.50 0.71 0.71 43428571
+ 0.50 0.71 0.71 50500000
+ 0.50 0.71 0.71 57571429
+ 0.50 0.71 0.71 64642857
+ 0.50 0.71 0.71 71714286
+ 0.50 0.71 0.71 78785714
+ 0.50 0.71 0.71 85857143
+ 0.50 0.71 0.71 92928571
+ 0.50 0.71 0.71 100000000
+ 0.50 0.71 0.79 1000000
+ 0.50 0.71 0.79 8071429
+ 0.50 0.71 0.79 15142857
+ 0.50 0.71 0.79 22214286
+ 0.50 0.71 0.79 29285714
+ 0.50 0.71 0.79 36357143
+ 0.50 0.71 0.79 43428571
+ 0.50 0.71 0.79 50500000
+ 0.50 0.71 0.79 57571429
+ 0.50 0.71 0.79 64642857
+ 0.50 0.71 0.79 71714286
+ 0.50 0.71 0.79 78785714
+ 0.50 0.71 0.79 85857143
+ 0.50 0.71 0.79 92928571
+ 0.50 0.71 0.79 100000000
+ 0.50 0.71 0.86 1000000
+ 0.50 0.71 0.86 8071429
+ 0.50 0.71 0.86 15142857
+ 0.50 0.71 0.86 22214286
+ 0.50 0.71 0.86 29285714
+ 0.50 0.71 0.86 36357143
+ 0.50 0.71 0.86 43428571
+ 0.50 0.71 0.86 50500000
+ 0.50 0.71 0.86 57571429
+ 0.50 0.71 0.86 64642857
+ 0.50 0.71 0.86 71714286
+ 0.50 0.71 0.86 78785714
+ 0.50 0.71 0.86 85857143
+ 0.50 0.71 0.86 92928571
+ 0.50 0.71 0.86 100000000
+ 0.50 0.71 0.93 1000000
+ 0.50 0.71 0.93 8071429
+ 0.50 0.71 0.93 15142857
+ 0.50 0.71 0.93 22214286
+ 0.50 0.71 0.93 29285714
+ 0.50 0.71 0.93 36357143
+ 0.50 0.71 0.93 43428571
+ 0.50 0.71 0.93 50500000
+ 0.50 0.71 0.93 57571429
+ 0.50 0.71 0.93 64642857
+ 0.50 0.71 0.93 71714286
+ 0.50 0.71 0.93 78785714
+ 0.50 0.71 0.93 85857143
+ 0.50 0.71 0.93 92928571
+ 0.50 0.71 0.93 100000000
+ 0.50 0.71 1.00 1000000
+ 0.50 0.71 1.00 8071429
+ 0.50 0.71 1.00 15142857
+ 0.50 0.71 1.00 22214286
+ 0.50 0.71 1.00 29285714
+ 0.50 0.71 1.00 36357143
+ 0.50 0.71 1.00 43428571
+ 0.50 0.71 1.00 50500000
+ 0.50 0.71 1.00 57571429
+ 0.50 0.71 1.00 64642857
+ 0.50 0.71 1.00 71714286
+ 0.50 0.71 1.00 78785714
+ 0.50 0.71 1.00 85857143
+ 0.50 0.71 1.00 92928571
+ 0.50 0.71 1.00 100000000
+ 0.50 0.79 0.00 1000000
+ 0.50 0.79 0.00 8071429
+ 0.50 0.79 0.00 15142857
+ 0.50 0.79 0.00 22214286
+ 0.50 0.79 0.00 29285714
+ 0.50 0.79 0.00 36357143
+ 0.50 0.79 0.00 43428571
+ 0.50 0.79 0.00 50500000
+ 0.50 0.79 0.00 57571429
+ 0.50 0.79 0.00 64642857
+ 0.50 0.79 0.00 71714286
+ 0.50 0.79 0.00 78785714
+ 0.50 0.79 0.00 85857143
+ 0.50 0.79 0.00 92928571
+ 0.50 0.79 0.00 100000000
+ 0.50 0.79 0.07 1000000
+ 0.50 0.79 0.07 8071429
+ 0.50 0.79 0.07 15142857
+ 0.50 0.79 0.07 22214286
+ 0.50 0.79 0.07 29285714
+ 0.50 0.79 0.07 36357143
+ 0.50 0.79 0.07 43428571
+ 0.50 0.79 0.07 50500000
+ 0.50 0.79 0.07 57571429
+ 0.50 0.79 0.07 64642857
+ 0.50 0.79 0.07 71714286
+ 0.50 0.79 0.07 78785714
+ 0.50 0.79 0.07 85857143
+ 0.50 0.79 0.07 92928571
+ 0.50 0.79 0.07 100000000
+ 0.50 0.79 0.14 1000000
+ 0.50 0.79 0.14 8071429
+ 0.50 0.79 0.14 15142857
+ 0.50 0.79 0.14 22214286
+ 0.50 0.79 0.14 29285714
+ 0.50 0.79 0.14 36357143
+ 0.50 0.79 0.14 43428571
+ 0.50 0.79 0.14 50500000
+ 0.50 0.79 0.14 57571429
+ 0.50 0.79 0.14 64642857
+ 0.50 0.79 0.14 71714286
+ 0.50 0.79 0.14 78785714
+ 0.50 0.79 0.14 85857143
+ 0.50 0.79 0.14 92928571
+ 0.50 0.79 0.14 100000000
+ 0.50 0.79 0.21 1000000
+ 0.50 0.79 0.21 8071429
+ 0.50 0.79 0.21 15142857
+ 0.50 0.79 0.21 22214286
+ 0.50 0.79 0.21 29285714
+ 0.50 0.79 0.21 36357143
+ 0.50 0.79 0.21 43428571
+ 0.50 0.79 0.21 50500000
+ 0.50 0.79 0.21 57571429
+ 0.50 0.79 0.21 64642857
+ 0.50 0.79 0.21 71714286
+ 0.50 0.79 0.21 78785714
+ 0.50 0.79 0.21 85857143
+ 0.50 0.79 0.21 92928571
+ 0.50 0.79 0.21 100000000
+ 0.50 0.79 0.29 1000000
+ 0.50 0.79 0.29 8071429
+ 0.50 0.79 0.29 15142857
+ 0.50 0.79 0.29 22214286
+ 0.50 0.79 0.29 29285714
+ 0.50 0.79 0.29 36357143
+ 0.50 0.79 0.29 43428571
+ 0.50 0.79 0.29 50500000
+ 0.50 0.79 0.29 57571429
+ 0.50 0.79 0.29 64642857
+ 0.50 0.79 0.29 71714286
+ 0.50 0.79 0.29 78785714
+ 0.50 0.79 0.29 85857143
+ 0.50 0.79 0.29 92928571
+ 0.50 0.79 0.29 100000000
+ 0.50 0.79 0.36 1000000
+ 0.50 0.79 0.36 8071429
+ 0.50 0.79 0.36 15142857
+ 0.50 0.79 0.36 22214286
+ 0.50 0.79 0.36 29285714
+ 0.50 0.79 0.36 36357143
+ 0.50 0.79 0.36 43428571
+ 0.50 0.79 0.36 50500000
+ 0.50 0.79 0.36 57571429
+ 0.50 0.79 0.36 64642857
+ 0.50 0.79 0.36 71714286
+ 0.50 0.79 0.36 78785714
+ 0.50 0.79 0.36 85857143
+ 0.50 0.79 0.36 92928571
+ 0.50 0.79 0.36 100000000
+ 0.50 0.79 0.43 1000000
+ 0.50 0.79 0.43 8071429
+ 0.50 0.79 0.43 15142857
+ 0.50 0.79 0.43 22214286
+ 0.50 0.79 0.43 29285714
+ 0.50 0.79 0.43 36357143
+ 0.50 0.79 0.43 43428571
+ 0.50 0.79 0.43 50500000
+ 0.50 0.79 0.43 57571429
+ 0.50 0.79 0.43 64642857
+ 0.50 0.79 0.43 71714286
+ 0.50 0.79 0.43 78785714
+ 0.50 0.79 0.43 85857143
+ 0.50 0.79 0.43 92928571
+ 0.50 0.79 0.43 100000000
+ 0.50 0.79 0.50 1000000
+ 0.50 0.79 0.50 8071429
+ 0.50 0.79 0.50 15142857
+ 0.50 0.79 0.50 22214286
+ 0.50 0.79 0.50 29285714
+ 0.50 0.79 0.50 36357143
+ 0.50 0.79 0.50 43428571
+ 0.50 0.79 0.50 50500000
+ 0.50 0.79 0.50 57571429
+ 0.50 0.79 0.50 64642857
+ 0.50 0.79 0.50 71714286
+ 0.50 0.79 0.50 78785714
+ 0.50 0.79 0.50 85857143
+ 0.50 0.79 0.50 92928571
+ 0.50 0.79 0.50 100000000
+ 0.50 0.79 0.57 1000000
+ 0.50 0.79 0.57 8071429
+ 0.50 0.79 0.57 15142857
+ 0.50 0.79 0.57 22214286
+ 0.50 0.79 0.57 29285714
+ 0.50 0.79 0.57 36357143
+ 0.50 0.79 0.57 43428571
+ 0.50 0.79 0.57 50500000
+ 0.50 0.79 0.57 57571429
+ 0.50 0.79 0.57 64642857
+ 0.50 0.79 0.57 71714286
+ 0.50 0.79 0.57 78785714
+ 0.50 0.79 0.57 85857143
+ 0.50 0.79 0.57 92928571
+ 0.50 0.79 0.57 100000000
+ 0.50 0.79 0.64 1000000
+ 0.50 0.79 0.64 8071429
+ 0.50 0.79 0.64 15142857
+ 0.50 0.79 0.64 22214286
+ 0.50 0.79 0.64 29285714
+ 0.50 0.79 0.64 36357143
+ 0.50 0.79 0.64 43428571
+ 0.50 0.79 0.64 50500000
+ 0.50 0.79 0.64 57571429
+ 0.50 0.79 0.64 64642857
+ 0.50 0.79 0.64 71714286
+ 0.50 0.79 0.64 78785714
+ 0.50 0.79 0.64 85857143
+ 0.50 0.79 0.64 92928571
+ 0.50 0.79 0.64 100000000
+ 0.50 0.79 0.71 1000000
+ 0.50 0.79 0.71 8071429
+ 0.50 0.79 0.71 15142857
+ 0.50 0.79 0.71 22214286
+ 0.50 0.79 0.71 29285714
+ 0.50 0.79 0.71 36357143
+ 0.50 0.79 0.71 43428571
+ 0.50 0.79 0.71 50500000
+ 0.50 0.79 0.71 57571429
+ 0.50 0.79 0.71 64642857
+ 0.50 0.79 0.71 71714286
+ 0.50 0.79 0.71 78785714
+ 0.50 0.79 0.71 85857143
+ 0.50 0.79 0.71 92928571
+ 0.50 0.79 0.71 100000000
+ 0.50 0.79 0.79 1000000
+ 0.50 0.79 0.79 8071429
+ 0.50 0.79 0.79 15142857
+ 0.50 0.79 0.79 22214286
+ 0.50 0.79 0.79 29285714
+ 0.50 0.79 0.79 36357143
+ 0.50 0.79 0.79 43428571
+ 0.50 0.79 0.79 50500000
+ 0.50 0.79 0.79 57571429
+ 0.50 0.79 0.79 64642857
+ 0.50 0.79 0.79 71714286
+ 0.50 0.79 0.79 78785714
+ 0.50 0.79 0.79 85857143
+ 0.50 0.79 0.79 92928571
+ 0.50 0.79 0.79 100000000
+ 0.50 0.79 0.86 1000000
+ 0.50 0.79 0.86 8071429
+ 0.50 0.79 0.86 15142857
+ 0.50 0.79 0.86 22214286
+ 0.50 0.79 0.86 29285714
+ 0.50 0.79 0.86 36357143
+ 0.50 0.79 0.86 43428571
+ 0.50 0.79 0.86 50500000
+ 0.50 0.79 0.86 57571429
+ 0.50 0.79 0.86 64642857
+ 0.50 0.79 0.86 71714286
+ 0.50 0.79 0.86 78785714
+ 0.50 0.79 0.86 85857143
+ 0.50 0.79 0.86 92928571
+ 0.50 0.79 0.86 100000000
+ 0.50 0.79 0.93 1000000
+ 0.50 0.79 0.93 8071429
+ 0.50 0.79 0.93 15142857
+ 0.50 0.79 0.93 22214286
+ 0.50 0.79 0.93 29285714
+ 0.50 0.79 0.93 36357143
+ 0.50 0.79 0.93 43428571
+ 0.50 0.79 0.93 50500000
+ 0.50 0.79 0.93 57571429
+ 0.50 0.79 0.93 64642857
+ 0.50 0.79 0.93 71714286
+ 0.50 0.79 0.93 78785714
+ 0.50 0.79 0.93 85857143
+ 0.50 0.79 0.93 92928571
+ 0.50 0.79 0.93 100000000
+ 0.50 0.79 1.00 1000000
+ 0.50 0.79 1.00 8071429
+ 0.50 0.79 1.00 15142857
+ 0.50 0.79 1.00 22214286
+ 0.50 0.79 1.00 29285714
+ 0.50 0.79 1.00 36357143
+ 0.50 0.79 1.00 43428571
+ 0.50 0.79 1.00 50500000
+ 0.50 0.79 1.00 57571429
+ 0.50 0.79 1.00 64642857
+ 0.50 0.79 1.00 71714286
+ 0.50 0.79 1.00 78785714
+ 0.50 0.79 1.00 85857143
+ 0.50 0.79 1.00 92928571
+ 0.50 0.79 1.00 100000000
+ 0.50 0.86 0.00 1000000
+ 0.50 0.86 0.00 8071429
+ 0.50 0.86 0.00 15142857
+ 0.50 0.86 0.00 22214286
+ 0.50 0.86 0.00 29285714
+ 0.50 0.86 0.00 36357143
+ 0.50 0.86 0.00 43428571
+ 0.50 0.86 0.00 50500000
+ 0.50 0.86 0.00 57571429
+ 0.50 0.86 0.00 64642857
+ 0.50 0.86 0.00 71714286
+ 0.50 0.86 0.00 78785714
+ 0.50 0.86 0.00 85857143
+ 0.50 0.86 0.00 92928571
+ 0.50 0.86 0.00 100000000
+ 0.50 0.86 0.07 1000000
+ 0.50 0.86 0.07 8071429
+ 0.50 0.86 0.07 15142857
+ 0.50 0.86 0.07 22214286
+ 0.50 0.86 0.07 29285714
+ 0.50 0.86 0.07 36357143
+ 0.50 0.86 0.07 43428571
+ 0.50 0.86 0.07 50500000
+ 0.50 0.86 0.07 57571429
+ 0.50 0.86 0.07 64642857
+ 0.50 0.86 0.07 71714286
+ 0.50 0.86 0.07 78785714
+ 0.50 0.86 0.07 85857143
+ 0.50 0.86 0.07 92928571
+ 0.50 0.86 0.07 100000000
+ 0.50 0.86 0.14 1000000
+ 0.50 0.86 0.14 8071429
+ 0.50 0.86 0.14 15142857
+ 0.50 0.86 0.14 22214286
+ 0.50 0.86 0.14 29285714
+ 0.50 0.86 0.14 36357143
+ 0.50 0.86 0.14 43428571
+ 0.50 0.86 0.14 50500000
+ 0.50 0.86 0.14 57571429
+ 0.50 0.86 0.14 64642857
+ 0.50 0.86 0.14 71714286
+ 0.50 0.86 0.14 78785714
+ 0.50 0.86 0.14 85857143
+ 0.50 0.86 0.14 92928571
+ 0.50 0.86 0.14 100000000
+ 0.50 0.86 0.21 1000000
+ 0.50 0.86 0.21 8071429
+ 0.50 0.86 0.21 15142857
+ 0.50 0.86 0.21 22214286
+ 0.50 0.86 0.21 29285714
+ 0.50 0.86 0.21 36357143
+ 0.50 0.86 0.21 43428571
+ 0.50 0.86 0.21 50500000
+ 0.50 0.86 0.21 57571429
+ 0.50 0.86 0.21 64642857
+ 0.50 0.86 0.21 71714286
+ 0.50 0.86 0.21 78785714
+ 0.50 0.86 0.21 85857143
+ 0.50 0.86 0.21 92928571
+ 0.50 0.86 0.21 100000000
+ 0.50 0.86 0.29 1000000
+ 0.50 0.86 0.29 8071429
+ 0.50 0.86 0.29 15142857
+ 0.50 0.86 0.29 22214286
+ 0.50 0.86 0.29 29285714
+ 0.50 0.86 0.29 36357143
+ 0.50 0.86 0.29 43428571
+ 0.50 0.86 0.29 50500000
+ 0.50 0.86 0.29 57571429
+ 0.50 0.86 0.29 64642857
+ 0.50 0.86 0.29 71714286
+ 0.50 0.86 0.29 78785714
+ 0.50 0.86 0.29 85857143
+ 0.50 0.86 0.29 92928571
+ 0.50 0.86 0.29 100000000
+ 0.50 0.86 0.36 1000000
+ 0.50 0.86 0.36 8071429
+ 0.50 0.86 0.36 15142857
+ 0.50 0.86 0.36 22214286
+ 0.50 0.86 0.36 29285714
+ 0.50 0.86 0.36 36357143
+ 0.50 0.86 0.36 43428571
+ 0.50 0.86 0.36 50500000
+ 0.50 0.86 0.36 57571429
+ 0.50 0.86 0.36 64642857
+ 0.50 0.86 0.36 71714286
+ 0.50 0.86 0.36 78785714
+ 0.50 0.86 0.36 85857143
+ 0.50 0.86 0.36 92928571
+ 0.50 0.86 0.36 100000000
+ 0.50 0.86 0.43 1000000
+ 0.50 0.86 0.43 8071429
+ 0.50 0.86 0.43 15142857
+ 0.50 0.86 0.43 22214286
+ 0.50 0.86 0.43 29285714
+ 0.50 0.86 0.43 36357143
+ 0.50 0.86 0.43 43428571
+ 0.50 0.86 0.43 50500000
+ 0.50 0.86 0.43 57571429
+ 0.50 0.86 0.43 64642857
+ 0.50 0.86 0.43 71714286
+ 0.50 0.86 0.43 78785714
+ 0.50 0.86 0.43 85857143
+ 0.50 0.86 0.43 92928571
+ 0.50 0.86 0.43 100000000
+ 0.50 0.86 0.50 1000000
+ 0.50 0.86 0.50 8071429
+ 0.50 0.86 0.50 15142857
+ 0.50 0.86 0.50 22214286
+ 0.50 0.86 0.50 29285714
+ 0.50 0.86 0.50 36357143
+ 0.50 0.86 0.50 43428571
+ 0.50 0.86 0.50 50500000
+ 0.50 0.86 0.50 57571429
+ 0.50 0.86 0.50 64642857
+ 0.50 0.86 0.50 71714286
+ 0.50 0.86 0.50 78785714
+ 0.50 0.86 0.50 85857143
+ 0.50 0.86 0.50 92928571
+ 0.50 0.86 0.50 100000000
+ 0.50 0.86 0.57 1000000
+ 0.50 0.86 0.57 8071429
+ 0.50 0.86 0.57 15142857
+ 0.50 0.86 0.57 22214286
+ 0.50 0.86 0.57 29285714
+ 0.50 0.86 0.57 36357143
+ 0.50 0.86 0.57 43428571
+ 0.50 0.86 0.57 50500000
+ 0.50 0.86 0.57 57571429
+ 0.50 0.86 0.57 64642857
+ 0.50 0.86 0.57 71714286
+ 0.50 0.86 0.57 78785714
+ 0.50 0.86 0.57 85857143
+ 0.50 0.86 0.57 92928571
+ 0.50 0.86 0.57 100000000
+ 0.50 0.86 0.64 1000000
+ 0.50 0.86 0.64 8071429
+ 0.50 0.86 0.64 15142857
+ 0.50 0.86 0.64 22214286
+ 0.50 0.86 0.64 29285714
+ 0.50 0.86 0.64 36357143
+ 0.50 0.86 0.64 43428571
+ 0.50 0.86 0.64 50500000
+ 0.50 0.86 0.64 57571429
+ 0.50 0.86 0.64 64642857
+ 0.50 0.86 0.64 71714286
+ 0.50 0.86 0.64 78785714
+ 0.50 0.86 0.64 85857143
+ 0.50 0.86 0.64 92928571
+ 0.50 0.86 0.64 100000000
+ 0.50 0.86 0.71 1000000
+ 0.50 0.86 0.71 8071429
+ 0.50 0.86 0.71 15142857
+ 0.50 0.86 0.71 22214286
+ 0.50 0.86 0.71 29285714
+ 0.50 0.86 0.71 36357143
+ 0.50 0.86 0.71 43428571
+ 0.50 0.86 0.71 50500000
+ 0.50 0.86 0.71 57571429
+ 0.50 0.86 0.71 64642857
+ 0.50 0.86 0.71 71714286
+ 0.50 0.86 0.71 78785714
+ 0.50 0.86 0.71 85857143
+ 0.50 0.86 0.71 92928571
+ 0.50 0.86 0.71 100000000
+ 0.50 0.86 0.79 1000000
+ 0.50 0.86 0.79 8071429
+ 0.50 0.86 0.79 15142857
+ 0.50 0.86 0.79 22214286
+ 0.50 0.86 0.79 29285714
+ 0.50 0.86 0.79 36357143
+ 0.50 0.86 0.79 43428571
+ 0.50 0.86 0.79 50500000
+ 0.50 0.86 0.79 57571429
+ 0.50 0.86 0.79 64642857
+ 0.50 0.86 0.79 71714286
+ 0.50 0.86 0.79 78785714
+ 0.50 0.86 0.79 85857143
+ 0.50 0.86 0.79 92928571
+ 0.50 0.86 0.79 100000000
+ 0.50 0.86 0.86 1000000
+ 0.50 0.86 0.86 8071429
+ 0.50 0.86 0.86 15142857
+ 0.50 0.86 0.86 22214286
+ 0.50 0.86 0.86 29285714
+ 0.50 0.86 0.86 36357143
+ 0.50 0.86 0.86 43428571
+ 0.50 0.86 0.86 50500000
+ 0.50 0.86 0.86 57571429
+ 0.50 0.86 0.86 64642857
+ 0.50 0.86 0.86 71714286
+ 0.50 0.86 0.86 78785714
+ 0.50 0.86 0.86 85857143
+ 0.50 0.86 0.86 92928571
+ 0.50 0.86 0.86 100000000
+ 0.50 0.86 0.93 1000000
+ 0.50 0.86 0.93 8071429
+ 0.50 0.86 0.93 15142857
+ 0.50 0.86 0.93 22214286
+ 0.50 0.86 0.93 29285714
+ 0.50 0.86 0.93 36357143
+ 0.50 0.86 0.93 43428571
+ 0.50 0.86 0.93 50500000
+ 0.50 0.86 0.93 57571429
+ 0.50 0.86 0.93 64642857
+ 0.50 0.86 0.93 71714286
+ 0.50 0.86 0.93 78785714
+ 0.50 0.86 0.93 85857143
+ 0.50 0.86 0.93 92928571
+ 0.50 0.86 0.93 100000000
+ 0.50 0.86 1.00 1000000
+ 0.50 0.86 1.00 8071429
+ 0.50 0.86 1.00 15142857
+ 0.50 0.86 1.00 22214286
+ 0.50 0.86 1.00 29285714
+ 0.50 0.86 1.00 36357143
+ 0.50 0.86 1.00 43428571
+ 0.50 0.86 1.00 50500000
+ 0.50 0.86 1.00 57571429
+ 0.50 0.86 1.00 64642857
+ 0.50 0.86 1.00 71714286
+ 0.50 0.86 1.00 78785714
+ 0.50 0.86 1.00 85857143
+ 0.50 0.86 1.00 92928571
+ 0.50 0.86 1.00 100000000
+ 0.50 0.93 0.00 1000000
+ 0.50 0.93 0.00 8071429
+ 0.50 0.93 0.00 15142857
+ 0.50 0.93 0.00 22214286
+ 0.50 0.93 0.00 29285714
+ 0.50 0.93 0.00 36357143
+ 0.50 0.93 0.00 43428571
+ 0.50 0.93 0.00 50500000
+ 0.50 0.93 0.00 57571429
+ 0.50 0.93 0.00 64642857
+ 0.50 0.93 0.00 71714286
+ 0.50 0.93 0.00 78785714
+ 0.50 0.93 0.00 85857143
+ 0.50 0.93 0.00 92928571
+ 0.50 0.93 0.00 100000000
+ 0.50 0.93 0.07 1000000
+ 0.50 0.93 0.07 8071429
+ 0.50 0.93 0.07 15142857
+ 0.50 0.93 0.07 22214286
+ 0.50 0.93 0.07 29285714
+ 0.50 0.93 0.07 36357143
+ 0.50 0.93 0.07 43428571
+ 0.50 0.93 0.07 50500000
+ 0.50 0.93 0.07 57571429
+ 0.50 0.93 0.07 64642857
+ 0.50 0.93 0.07 71714286
+ 0.50 0.93 0.07 78785714
+ 0.50 0.93 0.07 85857143
+ 0.50 0.93 0.07 92928571
+ 0.50 0.93 0.07 100000000
+ 0.50 0.93 0.14 1000000
+ 0.50 0.93 0.14 8071429
+ 0.50 0.93 0.14 15142857
+ 0.50 0.93 0.14 22214286
+ 0.50 0.93 0.14 29285714
+ 0.50 0.93 0.14 36357143
+ 0.50 0.93 0.14 43428571
+ 0.50 0.93 0.14 50500000
+ 0.50 0.93 0.14 57571429
+ 0.50 0.93 0.14 64642857
+ 0.50 0.93 0.14 71714286
+ 0.50 0.93 0.14 78785714
+ 0.50 0.93 0.14 85857143
+ 0.50 0.93 0.14 92928571
+ 0.50 0.93 0.14 100000000
+ 0.50 0.93 0.21 1000000
+ 0.50 0.93 0.21 8071429
+ 0.50 0.93 0.21 15142857
+ 0.50 0.93 0.21 22214286
+ 0.50 0.93 0.21 29285714
+ 0.50 0.93 0.21 36357143
+ 0.50 0.93 0.21 43428571
+ 0.50 0.93 0.21 50500000
+ 0.50 0.93 0.21 57571429
+ 0.50 0.93 0.21 64642857
+ 0.50 0.93 0.21 71714286
+ 0.50 0.93 0.21 78785714
+ 0.50 0.93 0.21 85857143
+ 0.50 0.93 0.21 92928571
+ 0.50 0.93 0.21 100000000
+ 0.50 0.93 0.29 1000000
+ 0.50 0.93 0.29 8071429
+ 0.50 0.93 0.29 15142857
+ 0.50 0.93 0.29 22214286
+ 0.50 0.93 0.29 29285714
+ 0.50 0.93 0.29 36357143
+ 0.50 0.93 0.29 43428571
+ 0.50 0.93 0.29 50500000
+ 0.50 0.93 0.29 57571429
+ 0.50 0.93 0.29 64642857
+ 0.50 0.93 0.29 71714286
+ 0.50 0.93 0.29 78785714
+ 0.50 0.93 0.29 85857143
+ 0.50 0.93 0.29 92928571
+ 0.50 0.93 0.29 100000000
+ 0.50 0.93 0.36 1000000
+ 0.50 0.93 0.36 8071429
+ 0.50 0.93 0.36 15142857
+ 0.50 0.93 0.36 22214286
+ 0.50 0.93 0.36 29285714
+ 0.50 0.93 0.36 36357143
+ 0.50 0.93 0.36 43428571
+ 0.50 0.93 0.36 50500000
+ 0.50 0.93 0.36 57571429
+ 0.50 0.93 0.36 64642857
+ 0.50 0.93 0.36 71714286
+ 0.50 0.93 0.36 78785714
+ 0.50 0.93 0.36 85857143
+ 0.50 0.93 0.36 92928571
+ 0.50 0.93 0.36 100000000
+ 0.50 0.93 0.43 1000000
+ 0.50 0.93 0.43 8071429
+ 0.50 0.93 0.43 15142857
+ 0.50 0.93 0.43 22214286
+ 0.50 0.93 0.43 29285714
+ 0.50 0.93 0.43 36357143
+ 0.50 0.93 0.43 43428571
+ 0.50 0.93 0.43 50500000
+ 0.50 0.93 0.43 57571429
+ 0.50 0.93 0.43 64642857
+ 0.50 0.93 0.43 71714286
+ 0.50 0.93 0.43 78785714
+ 0.50 0.93 0.43 85857143
+ 0.50 0.93 0.43 92928571
+ 0.50 0.93 0.43 100000000
+ 0.50 0.93 0.50 1000000
+ 0.50 0.93 0.50 8071429
+ 0.50 0.93 0.50 15142857
+ 0.50 0.93 0.50 22214286
+ 0.50 0.93 0.50 29285714
+ 0.50 0.93 0.50 36357143
+ 0.50 0.93 0.50 43428571
+ 0.50 0.93 0.50 50500000
+ 0.50 0.93 0.50 57571429
+ 0.50 0.93 0.50 64642857
+ 0.50 0.93 0.50 71714286
+ 0.50 0.93 0.50 78785714
+ 0.50 0.93 0.50 85857143
+ 0.50 0.93 0.50 92928571
+ 0.50 0.93 0.50 100000000
+ 0.50 0.93 0.57 1000000
+ 0.50 0.93 0.57 8071429
+ 0.50 0.93 0.57 15142857
+ 0.50 0.93 0.57 22214286
+ 0.50 0.93 0.57 29285714
+ 0.50 0.93 0.57 36357143
+ 0.50 0.93 0.57 43428571
+ 0.50 0.93 0.57 50500000
+ 0.50 0.93 0.57 57571429
+ 0.50 0.93 0.57 64642857
+ 0.50 0.93 0.57 71714286
+ 0.50 0.93 0.57 78785714
+ 0.50 0.93 0.57 85857143
+ 0.50 0.93 0.57 92928571
+ 0.50 0.93 0.57 100000000
+ 0.50 0.93 0.64 1000000
+ 0.50 0.93 0.64 8071429
+ 0.50 0.93 0.64 15142857
+ 0.50 0.93 0.64 22214286
+ 0.50 0.93 0.64 29285714
+ 0.50 0.93 0.64 36357143
+ 0.50 0.93 0.64 43428571
+ 0.50 0.93 0.64 50500000
+ 0.50 0.93 0.64 57571429
+ 0.50 0.93 0.64 64642857
+ 0.50 0.93 0.64 71714286
+ 0.50 0.93 0.64 78785714
+ 0.50 0.93 0.64 85857143
+ 0.50 0.93 0.64 92928571
+ 0.50 0.93 0.64 100000000
+ 0.50 0.93 0.71 1000000
+ 0.50 0.93 0.71 8071429
+ 0.50 0.93 0.71 15142857
+ 0.50 0.93 0.71 22214286
+ 0.50 0.93 0.71 29285714
+ 0.50 0.93 0.71 36357143
+ 0.50 0.93 0.71 43428571
+ 0.50 0.93 0.71 50500000
+ 0.50 0.93 0.71 57571429
+ 0.50 0.93 0.71 64642857
+ 0.50 0.93 0.71 71714286
+ 0.50 0.93 0.71 78785714
+ 0.50 0.93 0.71 85857143
+ 0.50 0.93 0.71 92928571
+ 0.50 0.93 0.71 100000000
+ 0.50 0.93 0.79 1000000
+ 0.50 0.93 0.79 8071429
+ 0.50 0.93 0.79 15142857
+ 0.50 0.93 0.79 22214286
+ 0.50 0.93 0.79 29285714
+ 0.50 0.93 0.79 36357143
+ 0.50 0.93 0.79 43428571
+ 0.50 0.93 0.79 50500000
+ 0.50 0.93 0.79 57571429
+ 0.50 0.93 0.79 64642857
+ 0.50 0.93 0.79 71714286
+ 0.50 0.93 0.79 78785714
+ 0.50 0.93 0.79 85857143
+ 0.50 0.93 0.79 92928571
+ 0.50 0.93 0.79 100000000
+ 0.50 0.93 0.86 1000000
+ 0.50 0.93 0.86 8071429
+ 0.50 0.93 0.86 15142857
+ 0.50 0.93 0.86 22214286
+ 0.50 0.93 0.86 29285714
+ 0.50 0.93 0.86 36357143
+ 0.50 0.93 0.86 43428571
+ 0.50 0.93 0.86 50500000
+ 0.50 0.93 0.86 57571429
+ 0.50 0.93 0.86 64642857
+ 0.50 0.93 0.86 71714286
+ 0.50 0.93 0.86 78785714
+ 0.50 0.93 0.86 85857143
+ 0.50 0.93 0.86 92928571
+ 0.50 0.93 0.86 100000000
+ 0.50 0.93 0.93 1000000
+ 0.50 0.93 0.93 8071429
+ 0.50 0.93 0.93 15142857
+ 0.50 0.93 0.93 22214286
+ 0.50 0.93 0.93 29285714
+ 0.50 0.93 0.93 36357143
+ 0.50 0.93 0.93 43428571
+ 0.50 0.93 0.93 50500000
+ 0.50 0.93 0.93 57571429
+ 0.50 0.93 0.93 64642857
+ 0.50 0.93 0.93 71714286
+ 0.50 0.93 0.93 78785714
+ 0.50 0.93 0.93 85857143
+ 0.50 0.93 0.93 92928571
+ 0.50 0.93 0.93 100000000
+ 0.50 0.93 1.00 1000000
+ 0.50 0.93 1.00 8071429
+ 0.50 0.93 1.00 15142857
+ 0.50 0.93 1.00 22214286
+ 0.50 0.93 1.00 29285714
+ 0.50 0.93 1.00 36357143
+ 0.50 0.93 1.00 43428571
+ 0.50 0.93 1.00 50500000
+ 0.50 0.93 1.00 57571429
+ 0.50 0.93 1.00 64642857
+ 0.50 0.93 1.00 71714286
+ 0.50 0.93 1.00 78785714
+ 0.50 0.93 1.00 85857143
+ 0.50 0.93 1.00 92928571
+ 0.50 0.93 1.00 100000000
+ 0.50 1.00 0.00 1000000
+ 0.50 1.00 0.00 8071429
+ 0.50 1.00 0.00 15142857
+ 0.50 1.00 0.00 22214286
+ 0.50 1.00 0.00 29285714
+ 0.50 1.00 0.00 36357143
+ 0.50 1.00 0.00 43428571
+ 0.50 1.00 0.00 50500000
+ 0.50 1.00 0.00 57571429
+ 0.50 1.00 0.00 64642857
+ 0.50 1.00 0.00 71714286
+ 0.50 1.00 0.00 78785714
+ 0.50 1.00 0.00 85857143
+ 0.50 1.00 0.00 92928571
+ 0.50 1.00 0.00 100000000
+ 0.50 1.00 0.07 1000000
+ 0.50 1.00 0.07 8071429
+ 0.50 1.00 0.07 15142857
+ 0.50 1.00 0.07 22214286
+ 0.50 1.00 0.07 29285714
+ 0.50 1.00 0.07 36357143
+ 0.50 1.00 0.07 43428571
+ 0.50 1.00 0.07 50500000
+ 0.50 1.00 0.07 57571429
+ 0.50 1.00 0.07 64642857
+ 0.50 1.00 0.07 71714286
+ 0.50 1.00 0.07 78785714
+ 0.50 1.00 0.07 85857143
+ 0.50 1.00 0.07 92928571
+ 0.50 1.00 0.07 100000000
+ 0.50 1.00 0.14 1000000
+ 0.50 1.00 0.14 8071429
+ 0.50 1.00 0.14 15142857
+ 0.50 1.00 0.14 22214286
+ 0.50 1.00 0.14 29285714
+ 0.50 1.00 0.14 36357143
+ 0.50 1.00 0.14 43428571
+ 0.50 1.00 0.14 50500000
+ 0.50 1.00 0.14 57571429
+ 0.50 1.00 0.14 64642857
+ 0.50 1.00 0.14 71714286
+ 0.50 1.00 0.14 78785714
+ 0.50 1.00 0.14 85857143
+ 0.50 1.00 0.14 92928571
+ 0.50 1.00 0.14 100000000
+ 0.50 1.00 0.21 1000000
+ 0.50 1.00 0.21 8071429
+ 0.50 1.00 0.21 15142857
+ 0.50 1.00 0.21 22214286
+ 0.50 1.00 0.21 29285714
+ 0.50 1.00 0.21 36357143
+ 0.50 1.00 0.21 43428571
+ 0.50 1.00 0.21 50500000
+ 0.50 1.00 0.21 57571429
+ 0.50 1.00 0.21 64642857
+ 0.50 1.00 0.21 71714286
+ 0.50 1.00 0.21 78785714
+ 0.50 1.00 0.21 85857143
+ 0.50 1.00 0.21 92928571
+ 0.50 1.00 0.21 100000000
+ 0.50 1.00 0.29 1000000
+ 0.50 1.00 0.29 8071429
+ 0.50 1.00 0.29 15142857
+ 0.50 1.00 0.29 22214286
+ 0.50 1.00 0.29 29285714
+ 0.50 1.00 0.29 36357143
+ 0.50 1.00 0.29 43428571
+ 0.50 1.00 0.29 50500000
+ 0.50 1.00 0.29 57571429
+ 0.50 1.00 0.29 64642857
+ 0.50 1.00 0.29 71714286
+ 0.50 1.00 0.29 78785714
+ 0.50 1.00 0.29 85857143
+ 0.50 1.00 0.29 92928571
+ 0.50 1.00 0.29 100000000
+ 0.50 1.00 0.36 1000000
+ 0.50 1.00 0.36 8071429
+ 0.50 1.00 0.36 15142857
+ 0.50 1.00 0.36 22214286
+ 0.50 1.00 0.36 29285714
+ 0.50 1.00 0.36 36357143
+ 0.50 1.00 0.36 43428571
+ 0.50 1.00 0.36 50500000
+ 0.50 1.00 0.36 57571429
+ 0.50 1.00 0.36 64642857
+ 0.50 1.00 0.36 71714286
+ 0.50 1.00 0.36 78785714
+ 0.50 1.00 0.36 85857143
+ 0.50 1.00 0.36 92928571
+ 0.50 1.00 0.36 100000000
+ 0.50 1.00 0.43 1000000
+ 0.50 1.00 0.43 8071429
+ 0.50 1.00 0.43 15142857
+ 0.50 1.00 0.43 22214286
+ 0.50 1.00 0.43 29285714
+ 0.50 1.00 0.43 36357143
+ 0.50 1.00 0.43 43428571
+ 0.50 1.00 0.43 50500000
+ 0.50 1.00 0.43 57571429
+ 0.50 1.00 0.43 64642857
+ 0.50 1.00 0.43 71714286
+ 0.50 1.00 0.43 78785714
+ 0.50 1.00 0.43 85857143
+ 0.50 1.00 0.43 92928571
+ 0.50 1.00 0.43 100000000
+ 0.50 1.00 0.50 1000000
+ 0.50 1.00 0.50 8071429
+ 0.50 1.00 0.50 15142857
+ 0.50 1.00 0.50 22214286
+ 0.50 1.00 0.50 29285714
+ 0.50 1.00 0.50 36357143
+ 0.50 1.00 0.50 43428571
+ 0.50 1.00 0.50 50500000
+ 0.50 1.00 0.50 57571429
+ 0.50 1.00 0.50 64642857
+ 0.50 1.00 0.50 71714286
+ 0.50 1.00 0.50 78785714
+ 0.50 1.00 0.50 85857143
+ 0.50 1.00 0.50 92928571
+ 0.50 1.00 0.50 100000000
+ 0.50 1.00 0.57 1000000
+ 0.50 1.00 0.57 8071429
+ 0.50 1.00 0.57 15142857
+ 0.50 1.00 0.57 22214286
+ 0.50 1.00 0.57 29285714
+ 0.50 1.00 0.57 36357143
+ 0.50 1.00 0.57 43428571
+ 0.50 1.00 0.57 50500000
+ 0.50 1.00 0.57 57571429
+ 0.50 1.00 0.57 64642857
+ 0.50 1.00 0.57 71714286
+ 0.50 1.00 0.57 78785714
+ 0.50 1.00 0.57 85857143
+ 0.50 1.00 0.57 92928571
+ 0.50 1.00 0.57 100000000
+ 0.50 1.00 0.64 1000000
+ 0.50 1.00 0.64 8071429
+ 0.50 1.00 0.64 15142857
+ 0.50 1.00 0.64 22214286
+ 0.50 1.00 0.64 29285714
+ 0.50 1.00 0.64 36357143
+ 0.50 1.00 0.64 43428571
+ 0.50 1.00 0.64 50500000
+ 0.50 1.00 0.64 57571429
+ 0.50 1.00 0.64 64642857
+ 0.50 1.00 0.64 71714286
+ 0.50 1.00 0.64 78785714
+ 0.50 1.00 0.64 85857143
+ 0.50 1.00 0.64 92928571
+ 0.50 1.00 0.64 100000000
+ 0.50 1.00 0.71 1000000
+ 0.50 1.00 0.71 8071429
+ 0.50 1.00 0.71 15142857
+ 0.50 1.00 0.71 22214286
+ 0.50 1.00 0.71 29285714
+ 0.50 1.00 0.71 36357143
+ 0.50 1.00 0.71 43428571
+ 0.50 1.00 0.71 50500000
+ 0.50 1.00 0.71 57571429
+ 0.50 1.00 0.71 64642857
+ 0.50 1.00 0.71 71714286
+ 0.50 1.00 0.71 78785714
+ 0.50 1.00 0.71 85857143
+ 0.50 1.00 0.71 92928571
+ 0.50 1.00 0.71 100000000
+ 0.50 1.00 0.79 1000000
+ 0.50 1.00 0.79 8071429
+ 0.50 1.00 0.79 15142857
+ 0.50 1.00 0.79 22214286
+ 0.50 1.00 0.79 29285714
+ 0.50 1.00 0.79 36357143
+ 0.50 1.00 0.79 43428571
+ 0.50 1.00 0.79 50500000
+ 0.50 1.00 0.79 57571429
+ 0.50 1.00 0.79 64642857
+ 0.50 1.00 0.79 71714286
+ 0.50 1.00 0.79 78785714
+ 0.50 1.00 0.79 85857143
+ 0.50 1.00 0.79 92928571
+ 0.50 1.00 0.79 100000000
+ 0.50 1.00 0.86 1000000
+ 0.50 1.00 0.86 8071429
+ 0.50 1.00 0.86 15142857
+ 0.50 1.00 0.86 22214286
+ 0.50 1.00 0.86 29285714
+ 0.50 1.00 0.86 36357143
+ 0.50 1.00 0.86 43428571
+ 0.50 1.00 0.86 50500000
+ 0.50 1.00 0.86 57571429
+ 0.50 1.00 0.86 64642857
+ 0.50 1.00 0.86 71714286
+ 0.50 1.00 0.86 78785714
+ 0.50 1.00 0.86 85857143
+ 0.50 1.00 0.86 92928571
+ 0.50 1.00 0.86 100000000
+ 0.50 1.00 0.93 1000000
+ 0.50 1.00 0.93 8071429
+ 0.50 1.00 0.93 15142857
+ 0.50 1.00 0.93 22214286
+ 0.50 1.00 0.93 29285714
+ 0.50 1.00 0.93 36357143
+ 0.50 1.00 0.93 43428571
+ 0.50 1.00 0.93 50500000
+ 0.50 1.00 0.93 57571429
+ 0.50 1.00 0.93 64642857
+ 0.50 1.00 0.93 71714286
+ 0.50 1.00 0.93 78785714
+ 0.50 1.00 0.93 85857143
+ 0.50 1.00 0.93 92928571
+ 0.50 1.00 0.93 100000000
+ 0.50 1.00 1.00 1000000
+ 0.50 1.00 1.00 8071429
+ 0.50 1.00 1.00 15142857
+ 0.50 1.00 1.00 22214286
+ 0.50 1.00 1.00 29285714
+ 0.50 1.00 1.00 36357143
+ 0.50 1.00 1.00 43428571
+ 0.50 1.00 1.00 50500000
+ 0.50 1.00 1.00 57571429
+ 0.50 1.00 1.00 64642857
+ 0.50 1.00 1.00 71714286
+ 0.50 1.00 1.00 78785714
+ 0.50 1.00 1.00 85857143
+ 0.50 1.00 1.00 92928571
+ 0.50 1.00 1.00 100000000
+ 0.57 0.00 0.00 1000000
+ 0.57 0.00 0.00 8071429
+ 0.57 0.00 0.00 15142857
+ 0.57 0.00 0.00 22214286
+ 0.57 0.00 0.00 29285714
+ 0.57 0.00 0.00 36357143
+ 0.57 0.00 0.00 43428571
+ 0.57 0.00 0.00 50500000
+ 0.57 0.00 0.00 57571429
+ 0.57 0.00 0.00 64642857
+ 0.57 0.00 0.00 71714286
+ 0.57 0.00 0.00 78785714
+ 0.57 0.00 0.00 85857143
+ 0.57 0.00 0.00 92928571
+ 0.57 0.00 0.00 100000000
+ 0.57 0.00 0.07 1000000
+ 0.57 0.00 0.07 8071429
+ 0.57 0.00 0.07 15142857
+ 0.57 0.00 0.07 22214286
+ 0.57 0.00 0.07 29285714
+ 0.57 0.00 0.07 36357143
+ 0.57 0.00 0.07 43428571
+ 0.57 0.00 0.07 50500000
+ 0.57 0.00 0.07 57571429
+ 0.57 0.00 0.07 64642857
+ 0.57 0.00 0.07 71714286
+ 0.57 0.00 0.07 78785714
+ 0.57 0.00 0.07 85857143
+ 0.57 0.00 0.07 92928571
+ 0.57 0.00 0.07 100000000
+ 0.57 0.00 0.14 1000000
+ 0.57 0.00 0.14 8071429
+ 0.57 0.00 0.14 15142857
+ 0.57 0.00 0.14 22214286
+ 0.57 0.00 0.14 29285714
+ 0.57 0.00 0.14 36357143
+ 0.57 0.00 0.14 43428571
+ 0.57 0.00 0.14 50500000
+ 0.57 0.00 0.14 57571429
+ 0.57 0.00 0.14 64642857
+ 0.57 0.00 0.14 71714286
+ 0.57 0.00 0.14 78785714
+ 0.57 0.00 0.14 85857143
+ 0.57 0.00 0.14 92928571
+ 0.57 0.00 0.14 100000000
+ 0.57 0.00 0.21 1000000
+ 0.57 0.00 0.21 8071429
+ 0.57 0.00 0.21 15142857
+ 0.57 0.00 0.21 22214286
+ 0.57 0.00 0.21 29285714
+ 0.57 0.00 0.21 36357143
+ 0.57 0.00 0.21 43428571
+ 0.57 0.00 0.21 50500000
+ 0.57 0.00 0.21 57571429
+ 0.57 0.00 0.21 64642857
+ 0.57 0.00 0.21 71714286
+ 0.57 0.00 0.21 78785714
+ 0.57 0.00 0.21 85857143
+ 0.57 0.00 0.21 92928571
+ 0.57 0.00 0.21 100000000
+ 0.57 0.00 0.29 1000000
+ 0.57 0.00 0.29 8071429
+ 0.57 0.00 0.29 15142857
+ 0.57 0.00 0.29 22214286
+ 0.57 0.00 0.29 29285714
+ 0.57 0.00 0.29 36357143
+ 0.57 0.00 0.29 43428571
+ 0.57 0.00 0.29 50500000
+ 0.57 0.00 0.29 57571429
+ 0.57 0.00 0.29 64642857
+ 0.57 0.00 0.29 71714286
+ 0.57 0.00 0.29 78785714
+ 0.57 0.00 0.29 85857143
+ 0.57 0.00 0.29 92928571
+ 0.57 0.00 0.29 100000000
+ 0.57 0.00 0.36 1000000
+ 0.57 0.00 0.36 8071429
+ 0.57 0.00 0.36 15142857
+ 0.57 0.00 0.36 22214286
+ 0.57 0.00 0.36 29285714
+ 0.57 0.00 0.36 36357143
+ 0.57 0.00 0.36 43428571
+ 0.57 0.00 0.36 50500000
+ 0.57 0.00 0.36 57571429
+ 0.57 0.00 0.36 64642857
+ 0.57 0.00 0.36 71714286
+ 0.57 0.00 0.36 78785714
+ 0.57 0.00 0.36 85857143
+ 0.57 0.00 0.36 92928571
+ 0.57 0.00 0.36 100000000
+ 0.57 0.00 0.43 1000000
+ 0.57 0.00 0.43 8071429
+ 0.57 0.00 0.43 15142857
+ 0.57 0.00 0.43 22214286
+ 0.57 0.00 0.43 29285714
+ 0.57 0.00 0.43 36357143
+ 0.57 0.00 0.43 43428571
+ 0.57 0.00 0.43 50500000
+ 0.57 0.00 0.43 57571429
+ 0.57 0.00 0.43 64642857
+ 0.57 0.00 0.43 71714286
+ 0.57 0.00 0.43 78785714
+ 0.57 0.00 0.43 85857143
+ 0.57 0.00 0.43 92928571
+ 0.57 0.00 0.43 100000000
+ 0.57 0.00 0.50 1000000
+ 0.57 0.00 0.50 8071429
+ 0.57 0.00 0.50 15142857
+ 0.57 0.00 0.50 22214286
+ 0.57 0.00 0.50 29285714
+ 0.57 0.00 0.50 36357143
+ 0.57 0.00 0.50 43428571
+ 0.57 0.00 0.50 50500000
+ 0.57 0.00 0.50 57571429
+ 0.57 0.00 0.50 64642857
+ 0.57 0.00 0.50 71714286
+ 0.57 0.00 0.50 78785714
+ 0.57 0.00 0.50 85857143
+ 0.57 0.00 0.50 92928571
+ 0.57 0.00 0.50 100000000
+ 0.57 0.00 0.57 1000000
+ 0.57 0.00 0.57 8071429
+ 0.57 0.00 0.57 15142857
+ 0.57 0.00 0.57 22214286
+ 0.57 0.00 0.57 29285714
+ 0.57 0.00 0.57 36357143
+ 0.57 0.00 0.57 43428571
+ 0.57 0.00 0.57 50500000
+ 0.57 0.00 0.57 57571429
+ 0.57 0.00 0.57 64642857
+ 0.57 0.00 0.57 71714286
+ 0.57 0.00 0.57 78785714
+ 0.57 0.00 0.57 85857143
+ 0.57 0.00 0.57 92928571
+ 0.57 0.00 0.57 100000000
+ 0.57 0.00 0.64 1000000
+ 0.57 0.00 0.64 8071429
+ 0.57 0.00 0.64 15142857
+ 0.57 0.00 0.64 22214286
+ 0.57 0.00 0.64 29285714
+ 0.57 0.00 0.64 36357143
+ 0.57 0.00 0.64 43428571
+ 0.57 0.00 0.64 50500000
+ 0.57 0.00 0.64 57571429
+ 0.57 0.00 0.64 64642857
+ 0.57 0.00 0.64 71714286
+ 0.57 0.00 0.64 78785714
+ 0.57 0.00 0.64 85857143
+ 0.57 0.00 0.64 92928571
+ 0.57 0.00 0.64 100000000
+ 0.57 0.00 0.71 1000000
+ 0.57 0.00 0.71 8071429
+ 0.57 0.00 0.71 15142857
+ 0.57 0.00 0.71 22214286
+ 0.57 0.00 0.71 29285714
+ 0.57 0.00 0.71 36357143
+ 0.57 0.00 0.71 43428571
+ 0.57 0.00 0.71 50500000
+ 0.57 0.00 0.71 57571429
+ 0.57 0.00 0.71 64642857
+ 0.57 0.00 0.71 71714286
+ 0.57 0.00 0.71 78785714
+ 0.57 0.00 0.71 85857143
+ 0.57 0.00 0.71 92928571
+ 0.57 0.00 0.71 100000000
+ 0.57 0.00 0.79 1000000
+ 0.57 0.00 0.79 8071429
+ 0.57 0.00 0.79 15142857
+ 0.57 0.00 0.79 22214286
+ 0.57 0.00 0.79 29285714
+ 0.57 0.00 0.79 36357143
+ 0.57 0.00 0.79 43428571
+ 0.57 0.00 0.79 50500000
+ 0.57 0.00 0.79 57571429
+ 0.57 0.00 0.79 64642857
+ 0.57 0.00 0.79 71714286
+ 0.57 0.00 0.79 78785714
+ 0.57 0.00 0.79 85857143
+ 0.57 0.00 0.79 92928571
+ 0.57 0.00 0.79 100000000
+ 0.57 0.00 0.86 1000000
+ 0.57 0.00 0.86 8071429
+ 0.57 0.00 0.86 15142857
+ 0.57 0.00 0.86 22214286
+ 0.57 0.00 0.86 29285714
+ 0.57 0.00 0.86 36357143
+ 0.57 0.00 0.86 43428571
+ 0.57 0.00 0.86 50500000
+ 0.57 0.00 0.86 57571429
+ 0.57 0.00 0.86 64642857
+ 0.57 0.00 0.86 71714286
+ 0.57 0.00 0.86 78785714
+ 0.57 0.00 0.86 85857143
+ 0.57 0.00 0.86 92928571
+ 0.57 0.00 0.86 100000000
+ 0.57 0.00 0.93 1000000
+ 0.57 0.00 0.93 8071429
+ 0.57 0.00 0.93 15142857
+ 0.57 0.00 0.93 22214286
+ 0.57 0.00 0.93 29285714
+ 0.57 0.00 0.93 36357143
+ 0.57 0.00 0.93 43428571
+ 0.57 0.00 0.93 50500000
+ 0.57 0.00 0.93 57571429
+ 0.57 0.00 0.93 64642857
+ 0.57 0.00 0.93 71714286
+ 0.57 0.00 0.93 78785714
+ 0.57 0.00 0.93 85857143
+ 0.57 0.00 0.93 92928571
+ 0.57 0.00 0.93 100000000
+ 0.57 0.00 1.00 1000000
+ 0.57 0.00 1.00 8071429
+ 0.57 0.00 1.00 15142857
+ 0.57 0.00 1.00 22214286
+ 0.57 0.00 1.00 29285714
+ 0.57 0.00 1.00 36357143
+ 0.57 0.00 1.00 43428571
+ 0.57 0.00 1.00 50500000
+ 0.57 0.00 1.00 57571429
+ 0.57 0.00 1.00 64642857
+ 0.57 0.00 1.00 71714286
+ 0.57 0.00 1.00 78785714
+ 0.57 0.00 1.00 85857143
+ 0.57 0.00 1.00 92928571
+ 0.57 0.00 1.00 100000000
+ 0.57 0.07 0.00 1000000
+ 0.57 0.07 0.00 8071429
+ 0.57 0.07 0.00 15142857
+ 0.57 0.07 0.00 22214286
+ 0.57 0.07 0.00 29285714
+ 0.57 0.07 0.00 36357143
+ 0.57 0.07 0.00 43428571
+ 0.57 0.07 0.00 50500000
+ 0.57 0.07 0.00 57571429
+ 0.57 0.07 0.00 64642857
+ 0.57 0.07 0.00 71714286
+ 0.57 0.07 0.00 78785714
+ 0.57 0.07 0.00 85857143
+ 0.57 0.07 0.00 92928571
+ 0.57 0.07 0.00 100000000
+ 0.57 0.07 0.07 1000000
+ 0.57 0.07 0.07 8071429
+ 0.57 0.07 0.07 15142857
+ 0.57 0.07 0.07 22214286
+ 0.57 0.07 0.07 29285714
+ 0.57 0.07 0.07 36357143
+ 0.57 0.07 0.07 43428571
+ 0.57 0.07 0.07 50500000
+ 0.57 0.07 0.07 57571429
+ 0.57 0.07 0.07 64642857
+ 0.57 0.07 0.07 71714286
+ 0.57 0.07 0.07 78785714
+ 0.57 0.07 0.07 85857143
+ 0.57 0.07 0.07 92928571
+ 0.57 0.07 0.07 100000000
+ 0.57 0.07 0.14 1000000
+ 0.57 0.07 0.14 8071429
+ 0.57 0.07 0.14 15142857
+ 0.57 0.07 0.14 22214286
+ 0.57 0.07 0.14 29285714
+ 0.57 0.07 0.14 36357143
+ 0.57 0.07 0.14 43428571
+ 0.57 0.07 0.14 50500000
+ 0.57 0.07 0.14 57571429
+ 0.57 0.07 0.14 64642857
+ 0.57 0.07 0.14 71714286
+ 0.57 0.07 0.14 78785714
+ 0.57 0.07 0.14 85857143
+ 0.57 0.07 0.14 92928571
+ 0.57 0.07 0.14 100000000
+ 0.57 0.07 0.21 1000000
+ 0.57 0.07 0.21 8071429
+ 0.57 0.07 0.21 15142857
+ 0.57 0.07 0.21 22214286
+ 0.57 0.07 0.21 29285714
+ 0.57 0.07 0.21 36357143
+ 0.57 0.07 0.21 43428571
+ 0.57 0.07 0.21 50500000
+ 0.57 0.07 0.21 57571429
+ 0.57 0.07 0.21 64642857
+ 0.57 0.07 0.21 71714286
+ 0.57 0.07 0.21 78785714
+ 0.57 0.07 0.21 85857143
+ 0.57 0.07 0.21 92928571
+ 0.57 0.07 0.21 100000000
+ 0.57 0.07 0.29 1000000
+ 0.57 0.07 0.29 8071429
+ 0.57 0.07 0.29 15142857
+ 0.57 0.07 0.29 22214286
+ 0.57 0.07 0.29 29285714
+ 0.57 0.07 0.29 36357143
+ 0.57 0.07 0.29 43428571
+ 0.57 0.07 0.29 50500000
+ 0.57 0.07 0.29 57571429
+ 0.57 0.07 0.29 64642857
+ 0.57 0.07 0.29 71714286
+ 0.57 0.07 0.29 78785714
+ 0.57 0.07 0.29 85857143
+ 0.57 0.07 0.29 92928571
+ 0.57 0.07 0.29 100000000
+ 0.57 0.07 0.36 1000000
+ 0.57 0.07 0.36 8071429
+ 0.57 0.07 0.36 15142857
+ 0.57 0.07 0.36 22214286
+ 0.57 0.07 0.36 29285714
+ 0.57 0.07 0.36 36357143
+ 0.57 0.07 0.36 43428571
+ 0.57 0.07 0.36 50500000
+ 0.57 0.07 0.36 57571429
+ 0.57 0.07 0.36 64642857
+ 0.57 0.07 0.36 71714286
+ 0.57 0.07 0.36 78785714
+ 0.57 0.07 0.36 85857143
+ 0.57 0.07 0.36 92928571
+ 0.57 0.07 0.36 100000000
+ 0.57 0.07 0.43 1000000
+ 0.57 0.07 0.43 8071429
+ 0.57 0.07 0.43 15142857
+ 0.57 0.07 0.43 22214286
+ 0.57 0.07 0.43 29285714
+ 0.57 0.07 0.43 36357143
+ 0.57 0.07 0.43 43428571
+ 0.57 0.07 0.43 50500000
+ 0.57 0.07 0.43 57571429
+ 0.57 0.07 0.43 64642857
+ 0.57 0.07 0.43 71714286
+ 0.57 0.07 0.43 78785714
+ 0.57 0.07 0.43 85857143
+ 0.57 0.07 0.43 92928571
+ 0.57 0.07 0.43 100000000
+ 0.57 0.07 0.50 1000000
+ 0.57 0.07 0.50 8071429
+ 0.57 0.07 0.50 15142857
+ 0.57 0.07 0.50 22214286
+ 0.57 0.07 0.50 29285714
+ 0.57 0.07 0.50 36357143
+ 0.57 0.07 0.50 43428571
+ 0.57 0.07 0.50 50500000
+ 0.57 0.07 0.50 57571429
+ 0.57 0.07 0.50 64642857
+ 0.57 0.07 0.50 71714286
+ 0.57 0.07 0.50 78785714
+ 0.57 0.07 0.50 85857143
+ 0.57 0.07 0.50 92928571
+ 0.57 0.07 0.50 100000000
+ 0.57 0.07 0.57 1000000
+ 0.57 0.07 0.57 8071429
+ 0.57 0.07 0.57 15142857
+ 0.57 0.07 0.57 22214286
+ 0.57 0.07 0.57 29285714
+ 0.57 0.07 0.57 36357143
+ 0.57 0.07 0.57 43428571
+ 0.57 0.07 0.57 50500000
+ 0.57 0.07 0.57 57571429
+ 0.57 0.07 0.57 64642857
+ 0.57 0.07 0.57 71714286
+ 0.57 0.07 0.57 78785714
+ 0.57 0.07 0.57 85857143
+ 0.57 0.07 0.57 92928571
+ 0.57 0.07 0.57 100000000
+ 0.57 0.07 0.64 1000000
+ 0.57 0.07 0.64 8071429
+ 0.57 0.07 0.64 15142857
+ 0.57 0.07 0.64 22214286
+ 0.57 0.07 0.64 29285714
+ 0.57 0.07 0.64 36357143
+ 0.57 0.07 0.64 43428571
+ 0.57 0.07 0.64 50500000
+ 0.57 0.07 0.64 57571429
+ 0.57 0.07 0.64 64642857
+ 0.57 0.07 0.64 71714286
+ 0.57 0.07 0.64 78785714
+ 0.57 0.07 0.64 85857143
+ 0.57 0.07 0.64 92928571
+ 0.57 0.07 0.64 100000000
+ 0.57 0.07 0.71 1000000
+ 0.57 0.07 0.71 8071429
+ 0.57 0.07 0.71 15142857
+ 0.57 0.07 0.71 22214286
+ 0.57 0.07 0.71 29285714
+ 0.57 0.07 0.71 36357143
+ 0.57 0.07 0.71 43428571
+ 0.57 0.07 0.71 50500000
+ 0.57 0.07 0.71 57571429
+ 0.57 0.07 0.71 64642857
+ 0.57 0.07 0.71 71714286
+ 0.57 0.07 0.71 78785714
+ 0.57 0.07 0.71 85857143
+ 0.57 0.07 0.71 92928571
+ 0.57 0.07 0.71 100000000
+ 0.57 0.07 0.79 1000000
+ 0.57 0.07 0.79 8071429
+ 0.57 0.07 0.79 15142857
+ 0.57 0.07 0.79 22214286
+ 0.57 0.07 0.79 29285714
+ 0.57 0.07 0.79 36357143
+ 0.57 0.07 0.79 43428571
+ 0.57 0.07 0.79 50500000
+ 0.57 0.07 0.79 57571429
+ 0.57 0.07 0.79 64642857
+ 0.57 0.07 0.79 71714286
+ 0.57 0.07 0.79 78785714
+ 0.57 0.07 0.79 85857143
+ 0.57 0.07 0.79 92928571
+ 0.57 0.07 0.79 100000000
+ 0.57 0.07 0.86 1000000
+ 0.57 0.07 0.86 8071429
+ 0.57 0.07 0.86 15142857
+ 0.57 0.07 0.86 22214286
+ 0.57 0.07 0.86 29285714
+ 0.57 0.07 0.86 36357143
+ 0.57 0.07 0.86 43428571
+ 0.57 0.07 0.86 50500000
+ 0.57 0.07 0.86 57571429
+ 0.57 0.07 0.86 64642857
+ 0.57 0.07 0.86 71714286
+ 0.57 0.07 0.86 78785714
+ 0.57 0.07 0.86 85857143
+ 0.57 0.07 0.86 92928571
+ 0.57 0.07 0.86 100000000
+ 0.57 0.07 0.93 1000000
+ 0.57 0.07 0.93 8071429
+ 0.57 0.07 0.93 15142857
+ 0.57 0.07 0.93 22214286
+ 0.57 0.07 0.93 29285714
+ 0.57 0.07 0.93 36357143
+ 0.57 0.07 0.93 43428571
+ 0.57 0.07 0.93 50500000
+ 0.57 0.07 0.93 57571429
+ 0.57 0.07 0.93 64642857
+ 0.57 0.07 0.93 71714286
+ 0.57 0.07 0.93 78785714
+ 0.57 0.07 0.93 85857143
+ 0.57 0.07 0.93 92928571
+ 0.57 0.07 0.93 100000000
+ 0.57 0.07 1.00 1000000
+ 0.57 0.07 1.00 8071429
+ 0.57 0.07 1.00 15142857
+ 0.57 0.07 1.00 22214286
+ 0.57 0.07 1.00 29285714
+ 0.57 0.07 1.00 36357143
+ 0.57 0.07 1.00 43428571
+ 0.57 0.07 1.00 50500000
+ 0.57 0.07 1.00 57571429
+ 0.57 0.07 1.00 64642857
+ 0.57 0.07 1.00 71714286
+ 0.57 0.07 1.00 78785714
+ 0.57 0.07 1.00 85857143
+ 0.57 0.07 1.00 92928571
+ 0.57 0.07 1.00 100000000
+ 0.57 0.14 0.00 1000000
+ 0.57 0.14 0.00 8071429
+ 0.57 0.14 0.00 15142857
+ 0.57 0.14 0.00 22214286
+ 0.57 0.14 0.00 29285714
+ 0.57 0.14 0.00 36357143
+ 0.57 0.14 0.00 43428571
+ 0.57 0.14 0.00 50500000
+ 0.57 0.14 0.00 57571429
+ 0.57 0.14 0.00 64642857
+ 0.57 0.14 0.00 71714286
+ 0.57 0.14 0.00 78785714
+ 0.57 0.14 0.00 85857143
+ 0.57 0.14 0.00 92928571
+ 0.57 0.14 0.00 100000000
+ 0.57 0.14 0.07 1000000
+ 0.57 0.14 0.07 8071429
+ 0.57 0.14 0.07 15142857
+ 0.57 0.14 0.07 22214286
+ 0.57 0.14 0.07 29285714
+ 0.57 0.14 0.07 36357143
+ 0.57 0.14 0.07 43428571
+ 0.57 0.14 0.07 50500000
+ 0.57 0.14 0.07 57571429
+ 0.57 0.14 0.07 64642857
+ 0.57 0.14 0.07 71714286
+ 0.57 0.14 0.07 78785714
+ 0.57 0.14 0.07 85857143
+ 0.57 0.14 0.07 92928571
+ 0.57 0.14 0.07 100000000
+ 0.57 0.14 0.14 1000000
+ 0.57 0.14 0.14 8071429
+ 0.57 0.14 0.14 15142857
+ 0.57 0.14 0.14 22214286
+ 0.57 0.14 0.14 29285714
+ 0.57 0.14 0.14 36357143
+ 0.57 0.14 0.14 43428571
+ 0.57 0.14 0.14 50500000
+ 0.57 0.14 0.14 57571429
+ 0.57 0.14 0.14 64642857
+ 0.57 0.14 0.14 71714286
+ 0.57 0.14 0.14 78785714
+ 0.57 0.14 0.14 85857143
+ 0.57 0.14 0.14 92928571
+ 0.57 0.14 0.14 100000000
+ 0.57 0.14 0.21 1000000
+ 0.57 0.14 0.21 8071429
+ 0.57 0.14 0.21 15142857
+ 0.57 0.14 0.21 22214286
+ 0.57 0.14 0.21 29285714
+ 0.57 0.14 0.21 36357143
+ 0.57 0.14 0.21 43428571
+ 0.57 0.14 0.21 50500000
+ 0.57 0.14 0.21 57571429
+ 0.57 0.14 0.21 64642857
+ 0.57 0.14 0.21 71714286
+ 0.57 0.14 0.21 78785714
+ 0.57 0.14 0.21 85857143
+ 0.57 0.14 0.21 92928571
+ 0.57 0.14 0.21 100000000
+ 0.57 0.14 0.29 1000000
+ 0.57 0.14 0.29 8071429
+ 0.57 0.14 0.29 15142857
+ 0.57 0.14 0.29 22214286
+ 0.57 0.14 0.29 29285714
+ 0.57 0.14 0.29 36357143
+ 0.57 0.14 0.29 43428571
+ 0.57 0.14 0.29 50500000
+ 0.57 0.14 0.29 57571429
+ 0.57 0.14 0.29 64642857
+ 0.57 0.14 0.29 71714286
+ 0.57 0.14 0.29 78785714
+ 0.57 0.14 0.29 85857143
+ 0.57 0.14 0.29 92928571
+ 0.57 0.14 0.29 100000000
+ 0.57 0.14 0.36 1000000
+ 0.57 0.14 0.36 8071429
+ 0.57 0.14 0.36 15142857
+ 0.57 0.14 0.36 22214286
+ 0.57 0.14 0.36 29285714
+ 0.57 0.14 0.36 36357143
+ 0.57 0.14 0.36 43428571
+ 0.57 0.14 0.36 50500000
+ 0.57 0.14 0.36 57571429
+ 0.57 0.14 0.36 64642857
+ 0.57 0.14 0.36 71714286
+ 0.57 0.14 0.36 78785714
+ 0.57 0.14 0.36 85857143
+ 0.57 0.14 0.36 92928571
+ 0.57 0.14 0.36 100000000
+ 0.57 0.14 0.43 1000000
+ 0.57 0.14 0.43 8071429
+ 0.57 0.14 0.43 15142857
+ 0.57 0.14 0.43 22214286
+ 0.57 0.14 0.43 29285714
+ 0.57 0.14 0.43 36357143
+ 0.57 0.14 0.43 43428571
+ 0.57 0.14 0.43 50500000
+ 0.57 0.14 0.43 57571429
+ 0.57 0.14 0.43 64642857
+ 0.57 0.14 0.43 71714286
+ 0.57 0.14 0.43 78785714
+ 0.57 0.14 0.43 85857143
+ 0.57 0.14 0.43 92928571
+ 0.57 0.14 0.43 100000000
+ 0.57 0.14 0.50 1000000
+ 0.57 0.14 0.50 8071429
+ 0.57 0.14 0.50 15142857
+ 0.57 0.14 0.50 22214286
+ 0.57 0.14 0.50 29285714
+ 0.57 0.14 0.50 36357143
+ 0.57 0.14 0.50 43428571
+ 0.57 0.14 0.50 50500000
+ 0.57 0.14 0.50 57571429
+ 0.57 0.14 0.50 64642857
+ 0.57 0.14 0.50 71714286
+ 0.57 0.14 0.50 78785714
+ 0.57 0.14 0.50 85857143
+ 0.57 0.14 0.50 92928571
+ 0.57 0.14 0.50 100000000
+ 0.57 0.14 0.57 1000000
+ 0.57 0.14 0.57 8071429
+ 0.57 0.14 0.57 15142857
+ 0.57 0.14 0.57 22214286
+ 0.57 0.14 0.57 29285714
+ 0.57 0.14 0.57 36357143
+ 0.57 0.14 0.57 43428571
+ 0.57 0.14 0.57 50500000
+ 0.57 0.14 0.57 57571429
+ 0.57 0.14 0.57 64642857
+ 0.57 0.14 0.57 71714286
+ 0.57 0.14 0.57 78785714
+ 0.57 0.14 0.57 85857143
+ 0.57 0.14 0.57 92928571
+ 0.57 0.14 0.57 100000000
+ 0.57 0.14 0.64 1000000
+ 0.57 0.14 0.64 8071429
+ 0.57 0.14 0.64 15142857
+ 0.57 0.14 0.64 22214286
+ 0.57 0.14 0.64 29285714
+ 0.57 0.14 0.64 36357143
+ 0.57 0.14 0.64 43428571
+ 0.57 0.14 0.64 50500000
+ 0.57 0.14 0.64 57571429
+ 0.57 0.14 0.64 64642857
+ 0.57 0.14 0.64 71714286
+ 0.57 0.14 0.64 78785714
+ 0.57 0.14 0.64 85857143
+ 0.57 0.14 0.64 92928571
+ 0.57 0.14 0.64 100000000
+ 0.57 0.14 0.71 1000000
+ 0.57 0.14 0.71 8071429
+ 0.57 0.14 0.71 15142857
+ 0.57 0.14 0.71 22214286
+ 0.57 0.14 0.71 29285714
+ 0.57 0.14 0.71 36357143
+ 0.57 0.14 0.71 43428571
+ 0.57 0.14 0.71 50500000
+ 0.57 0.14 0.71 57571429
+ 0.57 0.14 0.71 64642857
+ 0.57 0.14 0.71 71714286
+ 0.57 0.14 0.71 78785714
+ 0.57 0.14 0.71 85857143
+ 0.57 0.14 0.71 92928571
+ 0.57 0.14 0.71 100000000
+ 0.57 0.14 0.79 1000000
+ 0.57 0.14 0.79 8071429
+ 0.57 0.14 0.79 15142857
+ 0.57 0.14 0.79 22214286
+ 0.57 0.14 0.79 29285714
+ 0.57 0.14 0.79 36357143
+ 0.57 0.14 0.79 43428571
+ 0.57 0.14 0.79 50500000
+ 0.57 0.14 0.79 57571429
+ 0.57 0.14 0.79 64642857
+ 0.57 0.14 0.79 71714286
+ 0.57 0.14 0.79 78785714
+ 0.57 0.14 0.79 85857143
+ 0.57 0.14 0.79 92928571
+ 0.57 0.14 0.79 100000000
+ 0.57 0.14 0.86 1000000
+ 0.57 0.14 0.86 8071429
+ 0.57 0.14 0.86 15142857
+ 0.57 0.14 0.86 22214286
+ 0.57 0.14 0.86 29285714
+ 0.57 0.14 0.86 36357143
+ 0.57 0.14 0.86 43428571
+ 0.57 0.14 0.86 50500000
+ 0.57 0.14 0.86 57571429
+ 0.57 0.14 0.86 64642857
+ 0.57 0.14 0.86 71714286
+ 0.57 0.14 0.86 78785714
+ 0.57 0.14 0.86 85857143
+ 0.57 0.14 0.86 92928571
+ 0.57 0.14 0.86 100000000
+ 0.57 0.14 0.93 1000000
+ 0.57 0.14 0.93 8071429
+ 0.57 0.14 0.93 15142857
+ 0.57 0.14 0.93 22214286
+ 0.57 0.14 0.93 29285714
+ 0.57 0.14 0.93 36357143
+ 0.57 0.14 0.93 43428571
+ 0.57 0.14 0.93 50500000
+ 0.57 0.14 0.93 57571429
+ 0.57 0.14 0.93 64642857
+ 0.57 0.14 0.93 71714286
+ 0.57 0.14 0.93 78785714
+ 0.57 0.14 0.93 85857143
+ 0.57 0.14 0.93 92928571
+ 0.57 0.14 0.93 100000000
+ 0.57 0.14 1.00 1000000
+ 0.57 0.14 1.00 8071429
+ 0.57 0.14 1.00 15142857
+ 0.57 0.14 1.00 22214286
+ 0.57 0.14 1.00 29285714
+ 0.57 0.14 1.00 36357143
+ 0.57 0.14 1.00 43428571
+ 0.57 0.14 1.00 50500000
+ 0.57 0.14 1.00 57571429
+ 0.57 0.14 1.00 64642857
+ 0.57 0.14 1.00 71714286
+ 0.57 0.14 1.00 78785714
+ 0.57 0.14 1.00 85857143
+ 0.57 0.14 1.00 92928571
+ 0.57 0.14 1.00 100000000
+ 0.57 0.21 0.00 1000000
+ 0.57 0.21 0.00 8071429
+ 0.57 0.21 0.00 15142857
+ 0.57 0.21 0.00 22214286
+ 0.57 0.21 0.00 29285714
+ 0.57 0.21 0.00 36357143
+ 0.57 0.21 0.00 43428571
+ 0.57 0.21 0.00 50500000
+ 0.57 0.21 0.00 57571429
+ 0.57 0.21 0.00 64642857
+ 0.57 0.21 0.00 71714286
+ 0.57 0.21 0.00 78785714
+ 0.57 0.21 0.00 85857143
+ 0.57 0.21 0.00 92928571
+ 0.57 0.21 0.00 100000000
+ 0.57 0.21 0.07 1000000
+ 0.57 0.21 0.07 8071429
+ 0.57 0.21 0.07 15142857
+ 0.57 0.21 0.07 22214286
+ 0.57 0.21 0.07 29285714
+ 0.57 0.21 0.07 36357143
+ 0.57 0.21 0.07 43428571
+ 0.57 0.21 0.07 50500000
+ 0.57 0.21 0.07 57571429
+ 0.57 0.21 0.07 64642857
+ 0.57 0.21 0.07 71714286
+ 0.57 0.21 0.07 78785714
+ 0.57 0.21 0.07 85857143
+ 0.57 0.21 0.07 92928571
+ 0.57 0.21 0.07 100000000
+ 0.57 0.21 0.14 1000000
+ 0.57 0.21 0.14 8071429
+ 0.57 0.21 0.14 15142857
+ 0.57 0.21 0.14 22214286
+ 0.57 0.21 0.14 29285714
+ 0.57 0.21 0.14 36357143
+ 0.57 0.21 0.14 43428571
+ 0.57 0.21 0.14 50500000
+ 0.57 0.21 0.14 57571429
+ 0.57 0.21 0.14 64642857
+ 0.57 0.21 0.14 71714286
+ 0.57 0.21 0.14 78785714
+ 0.57 0.21 0.14 85857143
+ 0.57 0.21 0.14 92928571
+ 0.57 0.21 0.14 100000000
+ 0.57 0.21 0.21 1000000
+ 0.57 0.21 0.21 8071429
+ 0.57 0.21 0.21 15142857
+ 0.57 0.21 0.21 22214286
+ 0.57 0.21 0.21 29285714
+ 0.57 0.21 0.21 36357143
+ 0.57 0.21 0.21 43428571
+ 0.57 0.21 0.21 50500000
+ 0.57 0.21 0.21 57571429
+ 0.57 0.21 0.21 64642857
+ 0.57 0.21 0.21 71714286
+ 0.57 0.21 0.21 78785714
+ 0.57 0.21 0.21 85857143
+ 0.57 0.21 0.21 92928571
+ 0.57 0.21 0.21 100000000
+ 0.57 0.21 0.29 1000000
+ 0.57 0.21 0.29 8071429
+ 0.57 0.21 0.29 15142857
+ 0.57 0.21 0.29 22214286
+ 0.57 0.21 0.29 29285714
+ 0.57 0.21 0.29 36357143
+ 0.57 0.21 0.29 43428571
+ 0.57 0.21 0.29 50500000
+ 0.57 0.21 0.29 57571429
+ 0.57 0.21 0.29 64642857
+ 0.57 0.21 0.29 71714286
+ 0.57 0.21 0.29 78785714
+ 0.57 0.21 0.29 85857143
+ 0.57 0.21 0.29 92928571
+ 0.57 0.21 0.29 100000000
+ 0.57 0.21 0.36 1000000
+ 0.57 0.21 0.36 8071429
+ 0.57 0.21 0.36 15142857
+ 0.57 0.21 0.36 22214286
+ 0.57 0.21 0.36 29285714
+ 0.57 0.21 0.36 36357143
+ 0.57 0.21 0.36 43428571
+ 0.57 0.21 0.36 50500000
+ 0.57 0.21 0.36 57571429
+ 0.57 0.21 0.36 64642857
+ 0.57 0.21 0.36 71714286
+ 0.57 0.21 0.36 78785714
+ 0.57 0.21 0.36 85857143
+ 0.57 0.21 0.36 92928571
+ 0.57 0.21 0.36 100000000
+ 0.57 0.21 0.43 1000000
+ 0.57 0.21 0.43 8071429
+ 0.57 0.21 0.43 15142857
+ 0.57 0.21 0.43 22214286
+ 0.57 0.21 0.43 29285714
+ 0.57 0.21 0.43 36357143
+ 0.57 0.21 0.43 43428571
+ 0.57 0.21 0.43 50500000
+ 0.57 0.21 0.43 57571429
+ 0.57 0.21 0.43 64642857
+ 0.57 0.21 0.43 71714286
+ 0.57 0.21 0.43 78785714
+ 0.57 0.21 0.43 85857143
+ 0.57 0.21 0.43 92928571
+ 0.57 0.21 0.43 100000000
+ 0.57 0.21 0.50 1000000
+ 0.57 0.21 0.50 8071429
+ 0.57 0.21 0.50 15142857
+ 0.57 0.21 0.50 22214286
+ 0.57 0.21 0.50 29285714
+ 0.57 0.21 0.50 36357143
+ 0.57 0.21 0.50 43428571
+ 0.57 0.21 0.50 50500000
+ 0.57 0.21 0.50 57571429
+ 0.57 0.21 0.50 64642857
+ 0.57 0.21 0.50 71714286
+ 0.57 0.21 0.50 78785714
+ 0.57 0.21 0.50 85857143
+ 0.57 0.21 0.50 92928571
+ 0.57 0.21 0.50 100000000
+ 0.57 0.21 0.57 1000000
+ 0.57 0.21 0.57 8071429
+ 0.57 0.21 0.57 15142857
+ 0.57 0.21 0.57 22214286
+ 0.57 0.21 0.57 29285714
+ 0.57 0.21 0.57 36357143
+ 0.57 0.21 0.57 43428571
+ 0.57 0.21 0.57 50500000
+ 0.57 0.21 0.57 57571429
+ 0.57 0.21 0.57 64642857
+ 0.57 0.21 0.57 71714286
+ 0.57 0.21 0.57 78785714
+ 0.57 0.21 0.57 85857143
+ 0.57 0.21 0.57 92928571
+ 0.57 0.21 0.57 100000000
+ 0.57 0.21 0.64 1000000
+ 0.57 0.21 0.64 8071429
+ 0.57 0.21 0.64 15142857
+ 0.57 0.21 0.64 22214286
+ 0.57 0.21 0.64 29285714
+ 0.57 0.21 0.64 36357143
+ 0.57 0.21 0.64 43428571
+ 0.57 0.21 0.64 50500000
+ 0.57 0.21 0.64 57571429
+ 0.57 0.21 0.64 64642857
+ 0.57 0.21 0.64 71714286
+ 0.57 0.21 0.64 78785714
+ 0.57 0.21 0.64 85857143
+ 0.57 0.21 0.64 92928571
+ 0.57 0.21 0.64 100000000
+ 0.57 0.21 0.71 1000000
+ 0.57 0.21 0.71 8071429
+ 0.57 0.21 0.71 15142857
+ 0.57 0.21 0.71 22214286
+ 0.57 0.21 0.71 29285714
+ 0.57 0.21 0.71 36357143
+ 0.57 0.21 0.71 43428571
+ 0.57 0.21 0.71 50500000
+ 0.57 0.21 0.71 57571429
+ 0.57 0.21 0.71 64642857
+ 0.57 0.21 0.71 71714286
+ 0.57 0.21 0.71 78785714
+ 0.57 0.21 0.71 85857143
+ 0.57 0.21 0.71 92928571
+ 0.57 0.21 0.71 100000000
+ 0.57 0.21 0.79 1000000
+ 0.57 0.21 0.79 8071429
+ 0.57 0.21 0.79 15142857
+ 0.57 0.21 0.79 22214286
+ 0.57 0.21 0.79 29285714
+ 0.57 0.21 0.79 36357143
+ 0.57 0.21 0.79 43428571
+ 0.57 0.21 0.79 50500000
+ 0.57 0.21 0.79 57571429
+ 0.57 0.21 0.79 64642857
+ 0.57 0.21 0.79 71714286
+ 0.57 0.21 0.79 78785714
+ 0.57 0.21 0.79 85857143
+ 0.57 0.21 0.79 92928571
+ 0.57 0.21 0.79 100000000
+ 0.57 0.21 0.86 1000000
+ 0.57 0.21 0.86 8071429
+ 0.57 0.21 0.86 15142857
+ 0.57 0.21 0.86 22214286
+ 0.57 0.21 0.86 29285714
+ 0.57 0.21 0.86 36357143
+ 0.57 0.21 0.86 43428571
+ 0.57 0.21 0.86 50500000
+ 0.57 0.21 0.86 57571429
+ 0.57 0.21 0.86 64642857
+ 0.57 0.21 0.86 71714286
+ 0.57 0.21 0.86 78785714
+ 0.57 0.21 0.86 85857143
+ 0.57 0.21 0.86 92928571
+ 0.57 0.21 0.86 100000000
+ 0.57 0.21 0.93 1000000
+ 0.57 0.21 0.93 8071429
+ 0.57 0.21 0.93 15142857
+ 0.57 0.21 0.93 22214286
+ 0.57 0.21 0.93 29285714
+ 0.57 0.21 0.93 36357143
+ 0.57 0.21 0.93 43428571
+ 0.57 0.21 0.93 50500000
+ 0.57 0.21 0.93 57571429
+ 0.57 0.21 0.93 64642857
+ 0.57 0.21 0.93 71714286
+ 0.57 0.21 0.93 78785714
+ 0.57 0.21 0.93 85857143
+ 0.57 0.21 0.93 92928571
+ 0.57 0.21 0.93 100000000
+ 0.57 0.21 1.00 1000000
+ 0.57 0.21 1.00 8071429
+ 0.57 0.21 1.00 15142857
+ 0.57 0.21 1.00 22214286
+ 0.57 0.21 1.00 29285714
+ 0.57 0.21 1.00 36357143
+ 0.57 0.21 1.00 43428571
+ 0.57 0.21 1.00 50500000
+ 0.57 0.21 1.00 57571429
+ 0.57 0.21 1.00 64642857
+ 0.57 0.21 1.00 71714286
+ 0.57 0.21 1.00 78785714
+ 0.57 0.21 1.00 85857143
+ 0.57 0.21 1.00 92928571
+ 0.57 0.21 1.00 100000000
+ 0.57 0.29 0.00 1000000
+ 0.57 0.29 0.00 8071429
+ 0.57 0.29 0.00 15142857
+ 0.57 0.29 0.00 22214286
+ 0.57 0.29 0.00 29285714
+ 0.57 0.29 0.00 36357143
+ 0.57 0.29 0.00 43428571
+ 0.57 0.29 0.00 50500000
+ 0.57 0.29 0.00 57571429
+ 0.57 0.29 0.00 64642857
+ 0.57 0.29 0.00 71714286
+ 0.57 0.29 0.00 78785714
+ 0.57 0.29 0.00 85857143
+ 0.57 0.29 0.00 92928571
+ 0.57 0.29 0.00 100000000
+ 0.57 0.29 0.07 1000000
+ 0.57 0.29 0.07 8071429
+ 0.57 0.29 0.07 15142857
+ 0.57 0.29 0.07 22214286
+ 0.57 0.29 0.07 29285714
+ 0.57 0.29 0.07 36357143
+ 0.57 0.29 0.07 43428571
+ 0.57 0.29 0.07 50500000
+ 0.57 0.29 0.07 57571429
+ 0.57 0.29 0.07 64642857
+ 0.57 0.29 0.07 71714286
+ 0.57 0.29 0.07 78785714
+ 0.57 0.29 0.07 85857143
+ 0.57 0.29 0.07 92928571
+ 0.57 0.29 0.07 100000000
+ 0.57 0.29 0.14 1000000
+ 0.57 0.29 0.14 8071429
+ 0.57 0.29 0.14 15142857
+ 0.57 0.29 0.14 22214286
+ 0.57 0.29 0.14 29285714
+ 0.57 0.29 0.14 36357143
+ 0.57 0.29 0.14 43428571
+ 0.57 0.29 0.14 50500000
+ 0.57 0.29 0.14 57571429
+ 0.57 0.29 0.14 64642857
+ 0.57 0.29 0.14 71714286
+ 0.57 0.29 0.14 78785714
+ 0.57 0.29 0.14 85857143
+ 0.57 0.29 0.14 92928571
+ 0.57 0.29 0.14 100000000
+ 0.57 0.29 0.21 1000000
+ 0.57 0.29 0.21 8071429
+ 0.57 0.29 0.21 15142857
+ 0.57 0.29 0.21 22214286
+ 0.57 0.29 0.21 29285714
+ 0.57 0.29 0.21 36357143
+ 0.57 0.29 0.21 43428571
+ 0.57 0.29 0.21 50500000
+ 0.57 0.29 0.21 57571429
+ 0.57 0.29 0.21 64642857
+ 0.57 0.29 0.21 71714286
+ 0.57 0.29 0.21 78785714
+ 0.57 0.29 0.21 85857143
+ 0.57 0.29 0.21 92928571
+ 0.57 0.29 0.21 100000000
+ 0.57 0.29 0.29 1000000
+ 0.57 0.29 0.29 8071429
+ 0.57 0.29 0.29 15142857
+ 0.57 0.29 0.29 22214286
+ 0.57 0.29 0.29 29285714
+ 0.57 0.29 0.29 36357143
+ 0.57 0.29 0.29 43428571
+ 0.57 0.29 0.29 50500000
+ 0.57 0.29 0.29 57571429
+ 0.57 0.29 0.29 64642857
+ 0.57 0.29 0.29 71714286
+ 0.57 0.29 0.29 78785714
+ 0.57 0.29 0.29 85857143
+ 0.57 0.29 0.29 92928571
+ 0.57 0.29 0.29 100000000
+ 0.57 0.29 0.36 1000000
+ 0.57 0.29 0.36 8071429
+ 0.57 0.29 0.36 15142857
+ 0.57 0.29 0.36 22214286
+ 0.57 0.29 0.36 29285714
+ 0.57 0.29 0.36 36357143
+ 0.57 0.29 0.36 43428571
+ 0.57 0.29 0.36 50500000
+ 0.57 0.29 0.36 57571429
+ 0.57 0.29 0.36 64642857
+ 0.57 0.29 0.36 71714286
+ 0.57 0.29 0.36 78785714
+ 0.57 0.29 0.36 85857143
+ 0.57 0.29 0.36 92928571
+ 0.57 0.29 0.36 100000000
+ 0.57 0.29 0.43 1000000
+ 0.57 0.29 0.43 8071429
+ 0.57 0.29 0.43 15142857
+ 0.57 0.29 0.43 22214286
+ 0.57 0.29 0.43 29285714
+ 0.57 0.29 0.43 36357143
+ 0.57 0.29 0.43 43428571
+ 0.57 0.29 0.43 50500000
+ 0.57 0.29 0.43 57571429
+ 0.57 0.29 0.43 64642857
+ 0.57 0.29 0.43 71714286
+ 0.57 0.29 0.43 78785714
+ 0.57 0.29 0.43 85857143
+ 0.57 0.29 0.43 92928571
+ 0.57 0.29 0.43 100000000
+ 0.57 0.29 0.50 1000000
+ 0.57 0.29 0.50 8071429
+ 0.57 0.29 0.50 15142857
+ 0.57 0.29 0.50 22214286
+ 0.57 0.29 0.50 29285714
+ 0.57 0.29 0.50 36357143
+ 0.57 0.29 0.50 43428571
+ 0.57 0.29 0.50 50500000
+ 0.57 0.29 0.50 57571429
+ 0.57 0.29 0.50 64642857
+ 0.57 0.29 0.50 71714286
+ 0.57 0.29 0.50 78785714
+ 0.57 0.29 0.50 85857143
+ 0.57 0.29 0.50 92928571
+ 0.57 0.29 0.50 100000000
+ 0.57 0.29 0.57 1000000
+ 0.57 0.29 0.57 8071429
+ 0.57 0.29 0.57 15142857
+ 0.57 0.29 0.57 22214286
+ 0.57 0.29 0.57 29285714
+ 0.57 0.29 0.57 36357143
+ 0.57 0.29 0.57 43428571
+ 0.57 0.29 0.57 50500000
+ 0.57 0.29 0.57 57571429
+ 0.57 0.29 0.57 64642857
+ 0.57 0.29 0.57 71714286
+ 0.57 0.29 0.57 78785714
+ 0.57 0.29 0.57 85857143
+ 0.57 0.29 0.57 92928571
+ 0.57 0.29 0.57 100000000
+ 0.57 0.29 0.64 1000000
+ 0.57 0.29 0.64 8071429
+ 0.57 0.29 0.64 15142857
+ 0.57 0.29 0.64 22214286
+ 0.57 0.29 0.64 29285714
+ 0.57 0.29 0.64 36357143
+ 0.57 0.29 0.64 43428571
+ 0.57 0.29 0.64 50500000
+ 0.57 0.29 0.64 57571429
+ 0.57 0.29 0.64 64642857
+ 0.57 0.29 0.64 71714286
+ 0.57 0.29 0.64 78785714
+ 0.57 0.29 0.64 85857143
+ 0.57 0.29 0.64 92928571
+ 0.57 0.29 0.64 100000000
+ 0.57 0.29 0.71 1000000
+ 0.57 0.29 0.71 8071429
+ 0.57 0.29 0.71 15142857
+ 0.57 0.29 0.71 22214286
+ 0.57 0.29 0.71 29285714
+ 0.57 0.29 0.71 36357143
+ 0.57 0.29 0.71 43428571
+ 0.57 0.29 0.71 50500000
+ 0.57 0.29 0.71 57571429
+ 0.57 0.29 0.71 64642857
+ 0.57 0.29 0.71 71714286
+ 0.57 0.29 0.71 78785714
+ 0.57 0.29 0.71 85857143
+ 0.57 0.29 0.71 92928571
+ 0.57 0.29 0.71 100000000
+ 0.57 0.29 0.79 1000000
+ 0.57 0.29 0.79 8071429
+ 0.57 0.29 0.79 15142857
+ 0.57 0.29 0.79 22214286
+ 0.57 0.29 0.79 29285714
+ 0.57 0.29 0.79 36357143
+ 0.57 0.29 0.79 43428571
+ 0.57 0.29 0.79 50500000
+ 0.57 0.29 0.79 57571429
+ 0.57 0.29 0.79 64642857
+ 0.57 0.29 0.79 71714286
+ 0.57 0.29 0.79 78785714
+ 0.57 0.29 0.79 85857143
+ 0.57 0.29 0.79 92928571
+ 0.57 0.29 0.79 100000000
+ 0.57 0.29 0.86 1000000
+ 0.57 0.29 0.86 8071429
+ 0.57 0.29 0.86 15142857
+ 0.57 0.29 0.86 22214286
+ 0.57 0.29 0.86 29285714
+ 0.57 0.29 0.86 36357143
+ 0.57 0.29 0.86 43428571
+ 0.57 0.29 0.86 50500000
+ 0.57 0.29 0.86 57571429
+ 0.57 0.29 0.86 64642857
+ 0.57 0.29 0.86 71714286
+ 0.57 0.29 0.86 78785714
+ 0.57 0.29 0.86 85857143
+ 0.57 0.29 0.86 92928571
+ 0.57 0.29 0.86 100000000
+ 0.57 0.29 0.93 1000000
+ 0.57 0.29 0.93 8071429
+ 0.57 0.29 0.93 15142857
+ 0.57 0.29 0.93 22214286
+ 0.57 0.29 0.93 29285714
+ 0.57 0.29 0.93 36357143
+ 0.57 0.29 0.93 43428571
+ 0.57 0.29 0.93 50500000
+ 0.57 0.29 0.93 57571429
+ 0.57 0.29 0.93 64642857
+ 0.57 0.29 0.93 71714286
+ 0.57 0.29 0.93 78785714
+ 0.57 0.29 0.93 85857143
+ 0.57 0.29 0.93 92928571
+ 0.57 0.29 0.93 100000000
+ 0.57 0.29 1.00 1000000
+ 0.57 0.29 1.00 8071429
+ 0.57 0.29 1.00 15142857
+ 0.57 0.29 1.00 22214286
+ 0.57 0.29 1.00 29285714
+ 0.57 0.29 1.00 36357143
+ 0.57 0.29 1.00 43428571
+ 0.57 0.29 1.00 50500000
+ 0.57 0.29 1.00 57571429
+ 0.57 0.29 1.00 64642857
+ 0.57 0.29 1.00 71714286
+ 0.57 0.29 1.00 78785714
+ 0.57 0.29 1.00 85857143
+ 0.57 0.29 1.00 92928571
+ 0.57 0.29 1.00 100000000
+ 0.57 0.36 0.00 1000000
+ 0.57 0.36 0.00 8071429
+ 0.57 0.36 0.00 15142857
+ 0.57 0.36 0.00 22214286
+ 0.57 0.36 0.00 29285714
+ 0.57 0.36 0.00 36357143
+ 0.57 0.36 0.00 43428571
+ 0.57 0.36 0.00 50500000
+ 0.57 0.36 0.00 57571429
+ 0.57 0.36 0.00 64642857
+ 0.57 0.36 0.00 71714286
+ 0.57 0.36 0.00 78785714
+ 0.57 0.36 0.00 85857143
+ 0.57 0.36 0.00 92928571
+ 0.57 0.36 0.00 100000000
+ 0.57 0.36 0.07 1000000
+ 0.57 0.36 0.07 8071429
+ 0.57 0.36 0.07 15142857
+ 0.57 0.36 0.07 22214286
+ 0.57 0.36 0.07 29285714
+ 0.57 0.36 0.07 36357143
+ 0.57 0.36 0.07 43428571
+ 0.57 0.36 0.07 50500000
+ 0.57 0.36 0.07 57571429
+ 0.57 0.36 0.07 64642857
+ 0.57 0.36 0.07 71714286
+ 0.57 0.36 0.07 78785714
+ 0.57 0.36 0.07 85857143
+ 0.57 0.36 0.07 92928571
+ 0.57 0.36 0.07 100000000
+ 0.57 0.36 0.14 1000000
+ 0.57 0.36 0.14 8071429
+ 0.57 0.36 0.14 15142857
+ 0.57 0.36 0.14 22214286
+ 0.57 0.36 0.14 29285714
+ 0.57 0.36 0.14 36357143
+ 0.57 0.36 0.14 43428571
+ 0.57 0.36 0.14 50500000
+ 0.57 0.36 0.14 57571429
+ 0.57 0.36 0.14 64642857
+ 0.57 0.36 0.14 71714286
+ 0.57 0.36 0.14 78785714
+ 0.57 0.36 0.14 85857143
+ 0.57 0.36 0.14 92928571
+ 0.57 0.36 0.14 100000000
+ 0.57 0.36 0.21 1000000
+ 0.57 0.36 0.21 8071429
+ 0.57 0.36 0.21 15142857
+ 0.57 0.36 0.21 22214286
+ 0.57 0.36 0.21 29285714
+ 0.57 0.36 0.21 36357143
+ 0.57 0.36 0.21 43428571
+ 0.57 0.36 0.21 50500000
+ 0.57 0.36 0.21 57571429
+ 0.57 0.36 0.21 64642857
+ 0.57 0.36 0.21 71714286
+ 0.57 0.36 0.21 78785714
+ 0.57 0.36 0.21 85857143
+ 0.57 0.36 0.21 92928571
+ 0.57 0.36 0.21 100000000
+ 0.57 0.36 0.29 1000000
+ 0.57 0.36 0.29 8071429
+ 0.57 0.36 0.29 15142857
+ 0.57 0.36 0.29 22214286
+ 0.57 0.36 0.29 29285714
+ 0.57 0.36 0.29 36357143
+ 0.57 0.36 0.29 43428571
+ 0.57 0.36 0.29 50500000
+ 0.57 0.36 0.29 57571429
+ 0.57 0.36 0.29 64642857
+ 0.57 0.36 0.29 71714286
+ 0.57 0.36 0.29 78785714
+ 0.57 0.36 0.29 85857143
+ 0.57 0.36 0.29 92928571
+ 0.57 0.36 0.29 100000000
+ 0.57 0.36 0.36 1000000
+ 0.57 0.36 0.36 8071429
+ 0.57 0.36 0.36 15142857
+ 0.57 0.36 0.36 22214286
+ 0.57 0.36 0.36 29285714
+ 0.57 0.36 0.36 36357143
+ 0.57 0.36 0.36 43428571
+ 0.57 0.36 0.36 50500000
+ 0.57 0.36 0.36 57571429
+ 0.57 0.36 0.36 64642857
+ 0.57 0.36 0.36 71714286
+ 0.57 0.36 0.36 78785714
+ 0.57 0.36 0.36 85857143
+ 0.57 0.36 0.36 92928571
+ 0.57 0.36 0.36 100000000
+ 0.57 0.36 0.43 1000000
+ 0.57 0.36 0.43 8071429
+ 0.57 0.36 0.43 15142857
+ 0.57 0.36 0.43 22214286
+ 0.57 0.36 0.43 29285714
+ 0.57 0.36 0.43 36357143
+ 0.57 0.36 0.43 43428571
+ 0.57 0.36 0.43 50500000
+ 0.57 0.36 0.43 57571429
+ 0.57 0.36 0.43 64642857
+ 0.57 0.36 0.43 71714286
+ 0.57 0.36 0.43 78785714
+ 0.57 0.36 0.43 85857143
+ 0.57 0.36 0.43 92928571
+ 0.57 0.36 0.43 100000000
+ 0.57 0.36 0.50 1000000
+ 0.57 0.36 0.50 8071429
+ 0.57 0.36 0.50 15142857
+ 0.57 0.36 0.50 22214286
+ 0.57 0.36 0.50 29285714
+ 0.57 0.36 0.50 36357143
+ 0.57 0.36 0.50 43428571
+ 0.57 0.36 0.50 50500000
+ 0.57 0.36 0.50 57571429
+ 0.57 0.36 0.50 64642857
+ 0.57 0.36 0.50 71714286
+ 0.57 0.36 0.50 78785714
+ 0.57 0.36 0.50 85857143
+ 0.57 0.36 0.50 92928571
+ 0.57 0.36 0.50 100000000
+ 0.57 0.36 0.57 1000000
+ 0.57 0.36 0.57 8071429
+ 0.57 0.36 0.57 15142857
+ 0.57 0.36 0.57 22214286
+ 0.57 0.36 0.57 29285714
+ 0.57 0.36 0.57 36357143
+ 0.57 0.36 0.57 43428571
+ 0.57 0.36 0.57 50500000
+ 0.57 0.36 0.57 57571429
+ 0.57 0.36 0.57 64642857
+ 0.57 0.36 0.57 71714286
+ 0.57 0.36 0.57 78785714
+ 0.57 0.36 0.57 85857143
+ 0.57 0.36 0.57 92928571
+ 0.57 0.36 0.57 100000000
+ 0.57 0.36 0.64 1000000
+ 0.57 0.36 0.64 8071429
+ 0.57 0.36 0.64 15142857
+ 0.57 0.36 0.64 22214286
+ 0.57 0.36 0.64 29285714
+ 0.57 0.36 0.64 36357143
+ 0.57 0.36 0.64 43428571
+ 0.57 0.36 0.64 50500000
+ 0.57 0.36 0.64 57571429
+ 0.57 0.36 0.64 64642857
+ 0.57 0.36 0.64 71714286
+ 0.57 0.36 0.64 78785714
+ 0.57 0.36 0.64 85857143
+ 0.57 0.36 0.64 92928571
+ 0.57 0.36 0.64 100000000
+ 0.57 0.36 0.71 1000000
+ 0.57 0.36 0.71 8071429
+ 0.57 0.36 0.71 15142857
+ 0.57 0.36 0.71 22214286
+ 0.57 0.36 0.71 29285714
+ 0.57 0.36 0.71 36357143
+ 0.57 0.36 0.71 43428571
+ 0.57 0.36 0.71 50500000
+ 0.57 0.36 0.71 57571429
+ 0.57 0.36 0.71 64642857
+ 0.57 0.36 0.71 71714286
+ 0.57 0.36 0.71 78785714
+ 0.57 0.36 0.71 85857143
+ 0.57 0.36 0.71 92928571
+ 0.57 0.36 0.71 100000000
+ 0.57 0.36 0.79 1000000
+ 0.57 0.36 0.79 8071429
+ 0.57 0.36 0.79 15142857
+ 0.57 0.36 0.79 22214286
+ 0.57 0.36 0.79 29285714
+ 0.57 0.36 0.79 36357143
+ 0.57 0.36 0.79 43428571
+ 0.57 0.36 0.79 50500000
+ 0.57 0.36 0.79 57571429
+ 0.57 0.36 0.79 64642857
+ 0.57 0.36 0.79 71714286
+ 0.57 0.36 0.79 78785714
+ 0.57 0.36 0.79 85857143
+ 0.57 0.36 0.79 92928571
+ 0.57 0.36 0.79 100000000
+ 0.57 0.36 0.86 1000000
+ 0.57 0.36 0.86 8071429
+ 0.57 0.36 0.86 15142857
+ 0.57 0.36 0.86 22214286
+ 0.57 0.36 0.86 29285714
+ 0.57 0.36 0.86 36357143
+ 0.57 0.36 0.86 43428571
+ 0.57 0.36 0.86 50500000
+ 0.57 0.36 0.86 57571429
+ 0.57 0.36 0.86 64642857
+ 0.57 0.36 0.86 71714286
+ 0.57 0.36 0.86 78785714
+ 0.57 0.36 0.86 85857143
+ 0.57 0.36 0.86 92928571
+ 0.57 0.36 0.86 100000000
+ 0.57 0.36 0.93 1000000
+ 0.57 0.36 0.93 8071429
+ 0.57 0.36 0.93 15142857
+ 0.57 0.36 0.93 22214286
+ 0.57 0.36 0.93 29285714
+ 0.57 0.36 0.93 36357143
+ 0.57 0.36 0.93 43428571
+ 0.57 0.36 0.93 50500000
+ 0.57 0.36 0.93 57571429
+ 0.57 0.36 0.93 64642857
+ 0.57 0.36 0.93 71714286
+ 0.57 0.36 0.93 78785714
+ 0.57 0.36 0.93 85857143
+ 0.57 0.36 0.93 92928571
+ 0.57 0.36 0.93 100000000
+ 0.57 0.36 1.00 1000000
+ 0.57 0.36 1.00 8071429
+ 0.57 0.36 1.00 15142857
+ 0.57 0.36 1.00 22214286
+ 0.57 0.36 1.00 29285714
+ 0.57 0.36 1.00 36357143
+ 0.57 0.36 1.00 43428571
+ 0.57 0.36 1.00 50500000
+ 0.57 0.36 1.00 57571429
+ 0.57 0.36 1.00 64642857
+ 0.57 0.36 1.00 71714286
+ 0.57 0.36 1.00 78785714
+ 0.57 0.36 1.00 85857143
+ 0.57 0.36 1.00 92928571
+ 0.57 0.36 1.00 100000000
+ 0.57 0.43 0.00 1000000
+ 0.57 0.43 0.00 8071429
+ 0.57 0.43 0.00 15142857
+ 0.57 0.43 0.00 22214286
+ 0.57 0.43 0.00 29285714
+ 0.57 0.43 0.00 36357143
+ 0.57 0.43 0.00 43428571
+ 0.57 0.43 0.00 50500000
+ 0.57 0.43 0.00 57571429
+ 0.57 0.43 0.00 64642857
+ 0.57 0.43 0.00 71714286
+ 0.57 0.43 0.00 78785714
+ 0.57 0.43 0.00 85857143
+ 0.57 0.43 0.00 92928571
+ 0.57 0.43 0.00 100000000
+ 0.57 0.43 0.07 1000000
+ 0.57 0.43 0.07 8071429
+ 0.57 0.43 0.07 15142857
+ 0.57 0.43 0.07 22214286
+ 0.57 0.43 0.07 29285714
+ 0.57 0.43 0.07 36357143
+ 0.57 0.43 0.07 43428571
+ 0.57 0.43 0.07 50500000
+ 0.57 0.43 0.07 57571429
+ 0.57 0.43 0.07 64642857
+ 0.57 0.43 0.07 71714286
+ 0.57 0.43 0.07 78785714
+ 0.57 0.43 0.07 85857143
+ 0.57 0.43 0.07 92928571
+ 0.57 0.43 0.07 100000000
+ 0.57 0.43 0.14 1000000
+ 0.57 0.43 0.14 8071429
+ 0.57 0.43 0.14 15142857
+ 0.57 0.43 0.14 22214286
+ 0.57 0.43 0.14 29285714
+ 0.57 0.43 0.14 36357143
+ 0.57 0.43 0.14 43428571
+ 0.57 0.43 0.14 50500000
+ 0.57 0.43 0.14 57571429
+ 0.57 0.43 0.14 64642857
+ 0.57 0.43 0.14 71714286
+ 0.57 0.43 0.14 78785714
+ 0.57 0.43 0.14 85857143
+ 0.57 0.43 0.14 92928571
+ 0.57 0.43 0.14 100000000
+ 0.57 0.43 0.21 1000000
+ 0.57 0.43 0.21 8071429
+ 0.57 0.43 0.21 15142857
+ 0.57 0.43 0.21 22214286
+ 0.57 0.43 0.21 29285714
+ 0.57 0.43 0.21 36357143
+ 0.57 0.43 0.21 43428571
+ 0.57 0.43 0.21 50500000
+ 0.57 0.43 0.21 57571429
+ 0.57 0.43 0.21 64642857
+ 0.57 0.43 0.21 71714286
+ 0.57 0.43 0.21 78785714
+ 0.57 0.43 0.21 85857143
+ 0.57 0.43 0.21 92928571
+ 0.57 0.43 0.21 100000000
+ 0.57 0.43 0.29 1000000
+ 0.57 0.43 0.29 8071429
+ 0.57 0.43 0.29 15142857
+ 0.57 0.43 0.29 22214286
+ 0.57 0.43 0.29 29285714
+ 0.57 0.43 0.29 36357143
+ 0.57 0.43 0.29 43428571
+ 0.57 0.43 0.29 50500000
+ 0.57 0.43 0.29 57571429
+ 0.57 0.43 0.29 64642857
+ 0.57 0.43 0.29 71714286
+ 0.57 0.43 0.29 78785714
+ 0.57 0.43 0.29 85857143
+ 0.57 0.43 0.29 92928571
+ 0.57 0.43 0.29 100000000
+ 0.57 0.43 0.36 1000000
+ 0.57 0.43 0.36 8071429
+ 0.57 0.43 0.36 15142857
+ 0.57 0.43 0.36 22214286
+ 0.57 0.43 0.36 29285714
+ 0.57 0.43 0.36 36357143
+ 0.57 0.43 0.36 43428571
+ 0.57 0.43 0.36 50500000
+ 0.57 0.43 0.36 57571429
+ 0.57 0.43 0.36 64642857
+ 0.57 0.43 0.36 71714286
+ 0.57 0.43 0.36 78785714
+ 0.57 0.43 0.36 85857143
+ 0.57 0.43 0.36 92928571
+ 0.57 0.43 0.36 100000000
+ 0.57 0.43 0.43 1000000
+ 0.57 0.43 0.43 8071429
+ 0.57 0.43 0.43 15142857
+ 0.57 0.43 0.43 22214286
+ 0.57 0.43 0.43 29285714
+ 0.57 0.43 0.43 36357143
+ 0.57 0.43 0.43 43428571
+ 0.57 0.43 0.43 50500000
+ 0.57 0.43 0.43 57571429
+ 0.57 0.43 0.43 64642857
+ 0.57 0.43 0.43 71714286
+ 0.57 0.43 0.43 78785714
+ 0.57 0.43 0.43 85857143
+ 0.57 0.43 0.43 92928571
+ 0.57 0.43 0.43 100000000
+ 0.57 0.43 0.50 1000000
+ 0.57 0.43 0.50 8071429
+ 0.57 0.43 0.50 15142857
+ 0.57 0.43 0.50 22214286
+ 0.57 0.43 0.50 29285714
+ 0.57 0.43 0.50 36357143
+ 0.57 0.43 0.50 43428571
+ 0.57 0.43 0.50 50500000
+ 0.57 0.43 0.50 57571429
+ 0.57 0.43 0.50 64642857
+ 0.57 0.43 0.50 71714286
+ 0.57 0.43 0.50 78785714
+ 0.57 0.43 0.50 85857143
+ 0.57 0.43 0.50 92928571
+ 0.57 0.43 0.50 100000000
+ 0.57 0.43 0.57 1000000
+ 0.57 0.43 0.57 8071429
+ 0.57 0.43 0.57 15142857
+ 0.57 0.43 0.57 22214286
+ 0.57 0.43 0.57 29285714
+ 0.57 0.43 0.57 36357143
+ 0.57 0.43 0.57 43428571
+ 0.57 0.43 0.57 50500000
+ 0.57 0.43 0.57 57571429
+ 0.57 0.43 0.57 64642857
+ 0.57 0.43 0.57 71714286
+ 0.57 0.43 0.57 78785714
+ 0.57 0.43 0.57 85857143
+ 0.57 0.43 0.57 92928571
+ 0.57 0.43 0.57 100000000
+ 0.57 0.43 0.64 1000000
+ 0.57 0.43 0.64 8071429
+ 0.57 0.43 0.64 15142857
+ 0.57 0.43 0.64 22214286
+ 0.57 0.43 0.64 29285714
+ 0.57 0.43 0.64 36357143
+ 0.57 0.43 0.64 43428571
+ 0.57 0.43 0.64 50500000
+ 0.57 0.43 0.64 57571429
+ 0.57 0.43 0.64 64642857
+ 0.57 0.43 0.64 71714286
+ 0.57 0.43 0.64 78785714
+ 0.57 0.43 0.64 85857143
+ 0.57 0.43 0.64 92928571
+ 0.57 0.43 0.64 100000000
+ 0.57 0.43 0.71 1000000
+ 0.57 0.43 0.71 8071429
+ 0.57 0.43 0.71 15142857
+ 0.57 0.43 0.71 22214286
+ 0.57 0.43 0.71 29285714
+ 0.57 0.43 0.71 36357143
+ 0.57 0.43 0.71 43428571
+ 0.57 0.43 0.71 50500000
+ 0.57 0.43 0.71 57571429
+ 0.57 0.43 0.71 64642857
+ 0.57 0.43 0.71 71714286
+ 0.57 0.43 0.71 78785714
+ 0.57 0.43 0.71 85857143
+ 0.57 0.43 0.71 92928571
+ 0.57 0.43 0.71 100000000
+ 0.57 0.43 0.79 1000000
+ 0.57 0.43 0.79 8071429
+ 0.57 0.43 0.79 15142857
+ 0.57 0.43 0.79 22214286
+ 0.57 0.43 0.79 29285714
+ 0.57 0.43 0.79 36357143
+ 0.57 0.43 0.79 43428571
+ 0.57 0.43 0.79 50500000
+ 0.57 0.43 0.79 57571429
+ 0.57 0.43 0.79 64642857
+ 0.57 0.43 0.79 71714286
+ 0.57 0.43 0.79 78785714
+ 0.57 0.43 0.79 85857143
+ 0.57 0.43 0.79 92928571
+ 0.57 0.43 0.79 100000000
+ 0.57 0.43 0.86 1000000
+ 0.57 0.43 0.86 8071429
+ 0.57 0.43 0.86 15142857
+ 0.57 0.43 0.86 22214286
+ 0.57 0.43 0.86 29285714
+ 0.57 0.43 0.86 36357143
+ 0.57 0.43 0.86 43428571
+ 0.57 0.43 0.86 50500000
+ 0.57 0.43 0.86 57571429
+ 0.57 0.43 0.86 64642857
+ 0.57 0.43 0.86 71714286
+ 0.57 0.43 0.86 78785714
+ 0.57 0.43 0.86 85857143
+ 0.57 0.43 0.86 92928571
+ 0.57 0.43 0.86 100000000
+ 0.57 0.43 0.93 1000000
+ 0.57 0.43 0.93 8071429
+ 0.57 0.43 0.93 15142857
+ 0.57 0.43 0.93 22214286
+ 0.57 0.43 0.93 29285714
+ 0.57 0.43 0.93 36357143
+ 0.57 0.43 0.93 43428571
+ 0.57 0.43 0.93 50500000
+ 0.57 0.43 0.93 57571429
+ 0.57 0.43 0.93 64642857
+ 0.57 0.43 0.93 71714286
+ 0.57 0.43 0.93 78785714
+ 0.57 0.43 0.93 85857143
+ 0.57 0.43 0.93 92928571
+ 0.57 0.43 0.93 100000000
+ 0.57 0.43 1.00 1000000
+ 0.57 0.43 1.00 8071429
+ 0.57 0.43 1.00 15142857
+ 0.57 0.43 1.00 22214286
+ 0.57 0.43 1.00 29285714
+ 0.57 0.43 1.00 36357143
+ 0.57 0.43 1.00 43428571
+ 0.57 0.43 1.00 50500000
+ 0.57 0.43 1.00 57571429
+ 0.57 0.43 1.00 64642857
+ 0.57 0.43 1.00 71714286
+ 0.57 0.43 1.00 78785714
+ 0.57 0.43 1.00 85857143
+ 0.57 0.43 1.00 92928571
+ 0.57 0.43 1.00 100000000
+ 0.57 0.50 0.00 1000000
+ 0.57 0.50 0.00 8071429
+ 0.57 0.50 0.00 15142857
+ 0.57 0.50 0.00 22214286
+ 0.57 0.50 0.00 29285714
+ 0.57 0.50 0.00 36357143
+ 0.57 0.50 0.00 43428571
+ 0.57 0.50 0.00 50500000
+ 0.57 0.50 0.00 57571429
+ 0.57 0.50 0.00 64642857
+ 0.57 0.50 0.00 71714286
+ 0.57 0.50 0.00 78785714
+ 0.57 0.50 0.00 85857143
+ 0.57 0.50 0.00 92928571
+ 0.57 0.50 0.00 100000000
+ 0.57 0.50 0.07 1000000
+ 0.57 0.50 0.07 8071429
+ 0.57 0.50 0.07 15142857
+ 0.57 0.50 0.07 22214286
+ 0.57 0.50 0.07 29285714
+ 0.57 0.50 0.07 36357143
+ 0.57 0.50 0.07 43428571
+ 0.57 0.50 0.07 50500000
+ 0.57 0.50 0.07 57571429
+ 0.57 0.50 0.07 64642857
+ 0.57 0.50 0.07 71714286
+ 0.57 0.50 0.07 78785714
+ 0.57 0.50 0.07 85857143
+ 0.57 0.50 0.07 92928571
+ 0.57 0.50 0.07 100000000
+ 0.57 0.50 0.14 1000000
+ 0.57 0.50 0.14 8071429
+ 0.57 0.50 0.14 15142857
+ 0.57 0.50 0.14 22214286
+ 0.57 0.50 0.14 29285714
+ 0.57 0.50 0.14 36357143
+ 0.57 0.50 0.14 43428571
+ 0.57 0.50 0.14 50500000
+ 0.57 0.50 0.14 57571429
+ 0.57 0.50 0.14 64642857
+ 0.57 0.50 0.14 71714286
+ 0.57 0.50 0.14 78785714
+ 0.57 0.50 0.14 85857143
+ 0.57 0.50 0.14 92928571
+ 0.57 0.50 0.14 100000000
+ 0.57 0.50 0.21 1000000
+ 0.57 0.50 0.21 8071429
+ 0.57 0.50 0.21 15142857
+ 0.57 0.50 0.21 22214286
+ 0.57 0.50 0.21 29285714
+ 0.57 0.50 0.21 36357143
+ 0.57 0.50 0.21 43428571
+ 0.57 0.50 0.21 50500000
+ 0.57 0.50 0.21 57571429
+ 0.57 0.50 0.21 64642857
+ 0.57 0.50 0.21 71714286
+ 0.57 0.50 0.21 78785714
+ 0.57 0.50 0.21 85857143
+ 0.57 0.50 0.21 92928571
+ 0.57 0.50 0.21 100000000
+ 0.57 0.50 0.29 1000000
+ 0.57 0.50 0.29 8071429
+ 0.57 0.50 0.29 15142857
+ 0.57 0.50 0.29 22214286
+ 0.57 0.50 0.29 29285714
+ 0.57 0.50 0.29 36357143
+ 0.57 0.50 0.29 43428571
+ 0.57 0.50 0.29 50500000
+ 0.57 0.50 0.29 57571429
+ 0.57 0.50 0.29 64642857
+ 0.57 0.50 0.29 71714286
+ 0.57 0.50 0.29 78785714
+ 0.57 0.50 0.29 85857143
+ 0.57 0.50 0.29 92928571
+ 0.57 0.50 0.29 100000000
+ 0.57 0.50 0.36 1000000
+ 0.57 0.50 0.36 8071429
+ 0.57 0.50 0.36 15142857
+ 0.57 0.50 0.36 22214286
+ 0.57 0.50 0.36 29285714
+ 0.57 0.50 0.36 36357143
+ 0.57 0.50 0.36 43428571
+ 0.57 0.50 0.36 50500000
+ 0.57 0.50 0.36 57571429
+ 0.57 0.50 0.36 64642857
+ 0.57 0.50 0.36 71714286
+ 0.57 0.50 0.36 78785714
+ 0.57 0.50 0.36 85857143
+ 0.57 0.50 0.36 92928571
+ 0.57 0.50 0.36 100000000
+ 0.57 0.50 0.43 1000000
+ 0.57 0.50 0.43 8071429
+ 0.57 0.50 0.43 15142857
+ 0.57 0.50 0.43 22214286
+ 0.57 0.50 0.43 29285714
+ 0.57 0.50 0.43 36357143
+ 0.57 0.50 0.43 43428571
+ 0.57 0.50 0.43 50500000
+ 0.57 0.50 0.43 57571429
+ 0.57 0.50 0.43 64642857
+ 0.57 0.50 0.43 71714286
+ 0.57 0.50 0.43 78785714
+ 0.57 0.50 0.43 85857143
+ 0.57 0.50 0.43 92928571
+ 0.57 0.50 0.43 100000000
+ 0.57 0.50 0.50 1000000
+ 0.57 0.50 0.50 8071429
+ 0.57 0.50 0.50 15142857
+ 0.57 0.50 0.50 22214286
+ 0.57 0.50 0.50 29285714
+ 0.57 0.50 0.50 36357143
+ 0.57 0.50 0.50 43428571
+ 0.57 0.50 0.50 50500000
+ 0.57 0.50 0.50 57571429
+ 0.57 0.50 0.50 64642857
+ 0.57 0.50 0.50 71714286
+ 0.57 0.50 0.50 78785714
+ 0.57 0.50 0.50 85857143
+ 0.57 0.50 0.50 92928571
+ 0.57 0.50 0.50 100000000
+ 0.57 0.50 0.57 1000000
+ 0.57 0.50 0.57 8071429
+ 0.57 0.50 0.57 15142857
+ 0.57 0.50 0.57 22214286
+ 0.57 0.50 0.57 29285714
+ 0.57 0.50 0.57 36357143
+ 0.57 0.50 0.57 43428571
+ 0.57 0.50 0.57 50500000
+ 0.57 0.50 0.57 57571429
+ 0.57 0.50 0.57 64642857
+ 0.57 0.50 0.57 71714286
+ 0.57 0.50 0.57 78785714
+ 0.57 0.50 0.57 85857143
+ 0.57 0.50 0.57 92928571
+ 0.57 0.50 0.57 100000000
+ 0.57 0.50 0.64 1000000
+ 0.57 0.50 0.64 8071429
+ 0.57 0.50 0.64 15142857
+ 0.57 0.50 0.64 22214286
+ 0.57 0.50 0.64 29285714
+ 0.57 0.50 0.64 36357143
+ 0.57 0.50 0.64 43428571
+ 0.57 0.50 0.64 50500000
+ 0.57 0.50 0.64 57571429
+ 0.57 0.50 0.64 64642857
+ 0.57 0.50 0.64 71714286
+ 0.57 0.50 0.64 78785714
+ 0.57 0.50 0.64 85857143
+ 0.57 0.50 0.64 92928571
+ 0.57 0.50 0.64 100000000
+ 0.57 0.50 0.71 1000000
+ 0.57 0.50 0.71 8071429
+ 0.57 0.50 0.71 15142857
+ 0.57 0.50 0.71 22214286
+ 0.57 0.50 0.71 29285714
+ 0.57 0.50 0.71 36357143
+ 0.57 0.50 0.71 43428571
+ 0.57 0.50 0.71 50500000
+ 0.57 0.50 0.71 57571429
+ 0.57 0.50 0.71 64642857
+ 0.57 0.50 0.71 71714286
+ 0.57 0.50 0.71 78785714
+ 0.57 0.50 0.71 85857143
+ 0.57 0.50 0.71 92928571
+ 0.57 0.50 0.71 100000000
+ 0.57 0.50 0.79 1000000
+ 0.57 0.50 0.79 8071429
+ 0.57 0.50 0.79 15142857
+ 0.57 0.50 0.79 22214286
+ 0.57 0.50 0.79 29285714
+ 0.57 0.50 0.79 36357143
+ 0.57 0.50 0.79 43428571
+ 0.57 0.50 0.79 50500000
+ 0.57 0.50 0.79 57571429
+ 0.57 0.50 0.79 64642857
+ 0.57 0.50 0.79 71714286
+ 0.57 0.50 0.79 78785714
+ 0.57 0.50 0.79 85857143
+ 0.57 0.50 0.79 92928571
+ 0.57 0.50 0.79 100000000
+ 0.57 0.50 0.86 1000000
+ 0.57 0.50 0.86 8071429
+ 0.57 0.50 0.86 15142857
+ 0.57 0.50 0.86 22214286
+ 0.57 0.50 0.86 29285714
+ 0.57 0.50 0.86 36357143
+ 0.57 0.50 0.86 43428571
+ 0.57 0.50 0.86 50500000
+ 0.57 0.50 0.86 57571429
+ 0.57 0.50 0.86 64642857
+ 0.57 0.50 0.86 71714286
+ 0.57 0.50 0.86 78785714
+ 0.57 0.50 0.86 85857143
+ 0.57 0.50 0.86 92928571
+ 0.57 0.50 0.86 100000000
+ 0.57 0.50 0.93 1000000
+ 0.57 0.50 0.93 8071429
+ 0.57 0.50 0.93 15142857
+ 0.57 0.50 0.93 22214286
+ 0.57 0.50 0.93 29285714
+ 0.57 0.50 0.93 36357143
+ 0.57 0.50 0.93 43428571
+ 0.57 0.50 0.93 50500000
+ 0.57 0.50 0.93 57571429
+ 0.57 0.50 0.93 64642857
+ 0.57 0.50 0.93 71714286
+ 0.57 0.50 0.93 78785714
+ 0.57 0.50 0.93 85857143
+ 0.57 0.50 0.93 92928571
+ 0.57 0.50 0.93 100000000
+ 0.57 0.50 1.00 1000000
+ 0.57 0.50 1.00 8071429
+ 0.57 0.50 1.00 15142857
+ 0.57 0.50 1.00 22214286
+ 0.57 0.50 1.00 29285714
+ 0.57 0.50 1.00 36357143
+ 0.57 0.50 1.00 43428571
+ 0.57 0.50 1.00 50500000
+ 0.57 0.50 1.00 57571429
+ 0.57 0.50 1.00 64642857
+ 0.57 0.50 1.00 71714286
+ 0.57 0.50 1.00 78785714
+ 0.57 0.50 1.00 85857143
+ 0.57 0.50 1.00 92928571
+ 0.57 0.50 1.00 100000000
+ 0.57 0.57 0.00 1000000
+ 0.57 0.57 0.00 8071429
+ 0.57 0.57 0.00 15142857
+ 0.57 0.57 0.00 22214286
+ 0.57 0.57 0.00 29285714
+ 0.57 0.57 0.00 36357143
+ 0.57 0.57 0.00 43428571
+ 0.57 0.57 0.00 50500000
+ 0.57 0.57 0.00 57571429
+ 0.57 0.57 0.00 64642857
+ 0.57 0.57 0.00 71714286
+ 0.57 0.57 0.00 78785714
+ 0.57 0.57 0.00 85857143
+ 0.57 0.57 0.00 92928571
+ 0.57 0.57 0.00 100000000
+ 0.57 0.57 0.07 1000000
+ 0.57 0.57 0.07 8071429
+ 0.57 0.57 0.07 15142857
+ 0.57 0.57 0.07 22214286
+ 0.57 0.57 0.07 29285714
+ 0.57 0.57 0.07 36357143
+ 0.57 0.57 0.07 43428571
+ 0.57 0.57 0.07 50500000
+ 0.57 0.57 0.07 57571429
+ 0.57 0.57 0.07 64642857
+ 0.57 0.57 0.07 71714286
+ 0.57 0.57 0.07 78785714
+ 0.57 0.57 0.07 85857143
+ 0.57 0.57 0.07 92928571
+ 0.57 0.57 0.07 100000000
+ 0.57 0.57 0.14 1000000
+ 0.57 0.57 0.14 8071429
+ 0.57 0.57 0.14 15142857
+ 0.57 0.57 0.14 22214286
+ 0.57 0.57 0.14 29285714
+ 0.57 0.57 0.14 36357143
+ 0.57 0.57 0.14 43428571
+ 0.57 0.57 0.14 50500000
+ 0.57 0.57 0.14 57571429
+ 0.57 0.57 0.14 64642857
+ 0.57 0.57 0.14 71714286
+ 0.57 0.57 0.14 78785714
+ 0.57 0.57 0.14 85857143
+ 0.57 0.57 0.14 92928571
+ 0.57 0.57 0.14 100000000
+ 0.57 0.57 0.21 1000000
+ 0.57 0.57 0.21 8071429
+ 0.57 0.57 0.21 15142857
+ 0.57 0.57 0.21 22214286
+ 0.57 0.57 0.21 29285714
+ 0.57 0.57 0.21 36357143
+ 0.57 0.57 0.21 43428571
+ 0.57 0.57 0.21 50500000
+ 0.57 0.57 0.21 57571429
+ 0.57 0.57 0.21 64642857
+ 0.57 0.57 0.21 71714286
+ 0.57 0.57 0.21 78785714
+ 0.57 0.57 0.21 85857143
+ 0.57 0.57 0.21 92928571
+ 0.57 0.57 0.21 100000000
+ 0.57 0.57 0.29 1000000
+ 0.57 0.57 0.29 8071429
+ 0.57 0.57 0.29 15142857
+ 0.57 0.57 0.29 22214286
+ 0.57 0.57 0.29 29285714
+ 0.57 0.57 0.29 36357143
+ 0.57 0.57 0.29 43428571
+ 0.57 0.57 0.29 50500000
+ 0.57 0.57 0.29 57571429
+ 0.57 0.57 0.29 64642857
+ 0.57 0.57 0.29 71714286
+ 0.57 0.57 0.29 78785714
+ 0.57 0.57 0.29 85857143
+ 0.57 0.57 0.29 92928571
+ 0.57 0.57 0.29 100000000
+ 0.57 0.57 0.36 1000000
+ 0.57 0.57 0.36 8071429
+ 0.57 0.57 0.36 15142857
+ 0.57 0.57 0.36 22214286
+ 0.57 0.57 0.36 29285714
+ 0.57 0.57 0.36 36357143
+ 0.57 0.57 0.36 43428571
+ 0.57 0.57 0.36 50500000
+ 0.57 0.57 0.36 57571429
+ 0.57 0.57 0.36 64642857
+ 0.57 0.57 0.36 71714286
+ 0.57 0.57 0.36 78785714
+ 0.57 0.57 0.36 85857143
+ 0.57 0.57 0.36 92928571
+ 0.57 0.57 0.36 100000000
+ 0.57 0.57 0.43 1000000
+ 0.57 0.57 0.43 8071429
+ 0.57 0.57 0.43 15142857
+ 0.57 0.57 0.43 22214286
+ 0.57 0.57 0.43 29285714
+ 0.57 0.57 0.43 36357143
+ 0.57 0.57 0.43 43428571
+ 0.57 0.57 0.43 50500000
+ 0.57 0.57 0.43 57571429
+ 0.57 0.57 0.43 64642857
+ 0.57 0.57 0.43 71714286
+ 0.57 0.57 0.43 78785714
+ 0.57 0.57 0.43 85857143
+ 0.57 0.57 0.43 92928571
+ 0.57 0.57 0.43 100000000
+ 0.57 0.57 0.50 1000000
+ 0.57 0.57 0.50 8071429
+ 0.57 0.57 0.50 15142857
+ 0.57 0.57 0.50 22214286
+ 0.57 0.57 0.50 29285714
+ 0.57 0.57 0.50 36357143
+ 0.57 0.57 0.50 43428571
+ 0.57 0.57 0.50 50500000
+ 0.57 0.57 0.50 57571429
+ 0.57 0.57 0.50 64642857
+ 0.57 0.57 0.50 71714286
+ 0.57 0.57 0.50 78785714
+ 0.57 0.57 0.50 85857143
+ 0.57 0.57 0.50 92928571
+ 0.57 0.57 0.50 100000000
+ 0.57 0.57 0.57 1000000
+ 0.57 0.57 0.57 8071429
+ 0.57 0.57 0.57 15142857
+ 0.57 0.57 0.57 22214286
+ 0.57 0.57 0.57 29285714
+ 0.57 0.57 0.57 36357143
+ 0.57 0.57 0.57 43428571
+ 0.57 0.57 0.57 50500000
+ 0.57 0.57 0.57 57571429
+ 0.57 0.57 0.57 64642857
+ 0.57 0.57 0.57 71714286
+ 0.57 0.57 0.57 78785714
+ 0.57 0.57 0.57 85857143
+ 0.57 0.57 0.57 92928571
+ 0.57 0.57 0.57 100000000
+ 0.57 0.57 0.64 1000000
+ 0.57 0.57 0.64 8071429
+ 0.57 0.57 0.64 15142857
+ 0.57 0.57 0.64 22214286
+ 0.57 0.57 0.64 29285714
+ 0.57 0.57 0.64 36357143
+ 0.57 0.57 0.64 43428571
+ 0.57 0.57 0.64 50500000
+ 0.57 0.57 0.64 57571429
+ 0.57 0.57 0.64 64642857
+ 0.57 0.57 0.64 71714286
+ 0.57 0.57 0.64 78785714
+ 0.57 0.57 0.64 85857143
+ 0.57 0.57 0.64 92928571
+ 0.57 0.57 0.64 100000000
+ 0.57 0.57 0.71 1000000
+ 0.57 0.57 0.71 8071429
+ 0.57 0.57 0.71 15142857
+ 0.57 0.57 0.71 22214286
+ 0.57 0.57 0.71 29285714
+ 0.57 0.57 0.71 36357143
+ 0.57 0.57 0.71 43428571
+ 0.57 0.57 0.71 50500000
+ 0.57 0.57 0.71 57571429
+ 0.57 0.57 0.71 64642857
+ 0.57 0.57 0.71 71714286
+ 0.57 0.57 0.71 78785714
+ 0.57 0.57 0.71 85857143
+ 0.57 0.57 0.71 92928571
+ 0.57 0.57 0.71 100000000
+ 0.57 0.57 0.79 1000000
+ 0.57 0.57 0.79 8071429
+ 0.57 0.57 0.79 15142857
+ 0.57 0.57 0.79 22214286
+ 0.57 0.57 0.79 29285714
+ 0.57 0.57 0.79 36357143
+ 0.57 0.57 0.79 43428571
+ 0.57 0.57 0.79 50500000
+ 0.57 0.57 0.79 57571429
+ 0.57 0.57 0.79 64642857
+ 0.57 0.57 0.79 71714286
+ 0.57 0.57 0.79 78785714
+ 0.57 0.57 0.79 85857143
+ 0.57 0.57 0.79 92928571
+ 0.57 0.57 0.79 100000000
+ 0.57 0.57 0.86 1000000
+ 0.57 0.57 0.86 8071429
+ 0.57 0.57 0.86 15142857
+ 0.57 0.57 0.86 22214286
+ 0.57 0.57 0.86 29285714
+ 0.57 0.57 0.86 36357143
+ 0.57 0.57 0.86 43428571
+ 0.57 0.57 0.86 50500000
+ 0.57 0.57 0.86 57571429
+ 0.57 0.57 0.86 64642857
+ 0.57 0.57 0.86 71714286
+ 0.57 0.57 0.86 78785714
+ 0.57 0.57 0.86 85857143
+ 0.57 0.57 0.86 92928571
+ 0.57 0.57 0.86 100000000
+ 0.57 0.57 0.93 1000000
+ 0.57 0.57 0.93 8071429
+ 0.57 0.57 0.93 15142857
+ 0.57 0.57 0.93 22214286
+ 0.57 0.57 0.93 29285714
+ 0.57 0.57 0.93 36357143
+ 0.57 0.57 0.93 43428571
+ 0.57 0.57 0.93 50500000
+ 0.57 0.57 0.93 57571429
+ 0.57 0.57 0.93 64642857
+ 0.57 0.57 0.93 71714286
+ 0.57 0.57 0.93 78785714
+ 0.57 0.57 0.93 85857143
+ 0.57 0.57 0.93 92928571
+ 0.57 0.57 0.93 100000000
+ 0.57 0.57 1.00 1000000
+ 0.57 0.57 1.00 8071429
+ 0.57 0.57 1.00 15142857
+ 0.57 0.57 1.00 22214286
+ 0.57 0.57 1.00 29285714
+ 0.57 0.57 1.00 36357143
+ 0.57 0.57 1.00 43428571
+ 0.57 0.57 1.00 50500000
+ 0.57 0.57 1.00 57571429
+ 0.57 0.57 1.00 64642857
+ 0.57 0.57 1.00 71714286
+ 0.57 0.57 1.00 78785714
+ 0.57 0.57 1.00 85857143
+ 0.57 0.57 1.00 92928571
+ 0.57 0.57 1.00 100000000
+ 0.57 0.64 0.00 1000000
+ 0.57 0.64 0.00 8071429
+ 0.57 0.64 0.00 15142857
+ 0.57 0.64 0.00 22214286
+ 0.57 0.64 0.00 29285714
+ 0.57 0.64 0.00 36357143
+ 0.57 0.64 0.00 43428571
+ 0.57 0.64 0.00 50500000
+ 0.57 0.64 0.00 57571429
+ 0.57 0.64 0.00 64642857
+ 0.57 0.64 0.00 71714286
+ 0.57 0.64 0.00 78785714
+ 0.57 0.64 0.00 85857143
+ 0.57 0.64 0.00 92928571
+ 0.57 0.64 0.00 100000000
+ 0.57 0.64 0.07 1000000
+ 0.57 0.64 0.07 8071429
+ 0.57 0.64 0.07 15142857
+ 0.57 0.64 0.07 22214286
+ 0.57 0.64 0.07 29285714
+ 0.57 0.64 0.07 36357143
+ 0.57 0.64 0.07 43428571
+ 0.57 0.64 0.07 50500000
+ 0.57 0.64 0.07 57571429
+ 0.57 0.64 0.07 64642857
+ 0.57 0.64 0.07 71714286
+ 0.57 0.64 0.07 78785714
+ 0.57 0.64 0.07 85857143
+ 0.57 0.64 0.07 92928571
+ 0.57 0.64 0.07 100000000
+ 0.57 0.64 0.14 1000000
+ 0.57 0.64 0.14 8071429
+ 0.57 0.64 0.14 15142857
+ 0.57 0.64 0.14 22214286
+ 0.57 0.64 0.14 29285714
+ 0.57 0.64 0.14 36357143
+ 0.57 0.64 0.14 43428571
+ 0.57 0.64 0.14 50500000
+ 0.57 0.64 0.14 57571429
+ 0.57 0.64 0.14 64642857
+ 0.57 0.64 0.14 71714286
+ 0.57 0.64 0.14 78785714
+ 0.57 0.64 0.14 85857143
+ 0.57 0.64 0.14 92928571
+ 0.57 0.64 0.14 100000000
+ 0.57 0.64 0.21 1000000
+ 0.57 0.64 0.21 8071429
+ 0.57 0.64 0.21 15142857
+ 0.57 0.64 0.21 22214286
+ 0.57 0.64 0.21 29285714
+ 0.57 0.64 0.21 36357143
+ 0.57 0.64 0.21 43428571
+ 0.57 0.64 0.21 50500000
+ 0.57 0.64 0.21 57571429
+ 0.57 0.64 0.21 64642857
+ 0.57 0.64 0.21 71714286
+ 0.57 0.64 0.21 78785714
+ 0.57 0.64 0.21 85857143
+ 0.57 0.64 0.21 92928571
+ 0.57 0.64 0.21 100000000
+ 0.57 0.64 0.29 1000000
+ 0.57 0.64 0.29 8071429
+ 0.57 0.64 0.29 15142857
+ 0.57 0.64 0.29 22214286
+ 0.57 0.64 0.29 29285714
+ 0.57 0.64 0.29 36357143
+ 0.57 0.64 0.29 43428571
+ 0.57 0.64 0.29 50500000
+ 0.57 0.64 0.29 57571429
+ 0.57 0.64 0.29 64642857
+ 0.57 0.64 0.29 71714286
+ 0.57 0.64 0.29 78785714
+ 0.57 0.64 0.29 85857143
+ 0.57 0.64 0.29 92928571
+ 0.57 0.64 0.29 100000000
+ 0.57 0.64 0.36 1000000
+ 0.57 0.64 0.36 8071429
+ 0.57 0.64 0.36 15142857
+ 0.57 0.64 0.36 22214286
+ 0.57 0.64 0.36 29285714
+ 0.57 0.64 0.36 36357143
+ 0.57 0.64 0.36 43428571
+ 0.57 0.64 0.36 50500000
+ 0.57 0.64 0.36 57571429
+ 0.57 0.64 0.36 64642857
+ 0.57 0.64 0.36 71714286
+ 0.57 0.64 0.36 78785714
+ 0.57 0.64 0.36 85857143
+ 0.57 0.64 0.36 92928571
+ 0.57 0.64 0.36 100000000
+ 0.57 0.64 0.43 1000000
+ 0.57 0.64 0.43 8071429
+ 0.57 0.64 0.43 15142857
+ 0.57 0.64 0.43 22214286
+ 0.57 0.64 0.43 29285714
+ 0.57 0.64 0.43 36357143
+ 0.57 0.64 0.43 43428571
+ 0.57 0.64 0.43 50500000
+ 0.57 0.64 0.43 57571429
+ 0.57 0.64 0.43 64642857
+ 0.57 0.64 0.43 71714286
+ 0.57 0.64 0.43 78785714
+ 0.57 0.64 0.43 85857143
+ 0.57 0.64 0.43 92928571
+ 0.57 0.64 0.43 100000000
+ 0.57 0.64 0.50 1000000
+ 0.57 0.64 0.50 8071429
+ 0.57 0.64 0.50 15142857
+ 0.57 0.64 0.50 22214286
+ 0.57 0.64 0.50 29285714
+ 0.57 0.64 0.50 36357143
+ 0.57 0.64 0.50 43428571
+ 0.57 0.64 0.50 50500000
+ 0.57 0.64 0.50 57571429
+ 0.57 0.64 0.50 64642857
+ 0.57 0.64 0.50 71714286
+ 0.57 0.64 0.50 78785714
+ 0.57 0.64 0.50 85857143
+ 0.57 0.64 0.50 92928571
+ 0.57 0.64 0.50 100000000
+ 0.57 0.64 0.57 1000000
+ 0.57 0.64 0.57 8071429
+ 0.57 0.64 0.57 15142857
+ 0.57 0.64 0.57 22214286
+ 0.57 0.64 0.57 29285714
+ 0.57 0.64 0.57 36357143
+ 0.57 0.64 0.57 43428571
+ 0.57 0.64 0.57 50500000
+ 0.57 0.64 0.57 57571429
+ 0.57 0.64 0.57 64642857
+ 0.57 0.64 0.57 71714286
+ 0.57 0.64 0.57 78785714
+ 0.57 0.64 0.57 85857143
+ 0.57 0.64 0.57 92928571
+ 0.57 0.64 0.57 100000000
+ 0.57 0.64 0.64 1000000
+ 0.57 0.64 0.64 8071429
+ 0.57 0.64 0.64 15142857
+ 0.57 0.64 0.64 22214286
+ 0.57 0.64 0.64 29285714
+ 0.57 0.64 0.64 36357143
+ 0.57 0.64 0.64 43428571
+ 0.57 0.64 0.64 50500000
+ 0.57 0.64 0.64 57571429
+ 0.57 0.64 0.64 64642857
+ 0.57 0.64 0.64 71714286
+ 0.57 0.64 0.64 78785714
+ 0.57 0.64 0.64 85857143
+ 0.57 0.64 0.64 92928571
+ 0.57 0.64 0.64 100000000
+ 0.57 0.64 0.71 1000000
+ 0.57 0.64 0.71 8071429
+ 0.57 0.64 0.71 15142857
+ 0.57 0.64 0.71 22214286
+ 0.57 0.64 0.71 29285714
+ 0.57 0.64 0.71 36357143
+ 0.57 0.64 0.71 43428571
+ 0.57 0.64 0.71 50500000
+ 0.57 0.64 0.71 57571429
+ 0.57 0.64 0.71 64642857
+ 0.57 0.64 0.71 71714286
+ 0.57 0.64 0.71 78785714
+ 0.57 0.64 0.71 85857143
+ 0.57 0.64 0.71 92928571
+ 0.57 0.64 0.71 100000000
+ 0.57 0.64 0.79 1000000
+ 0.57 0.64 0.79 8071429
+ 0.57 0.64 0.79 15142857
+ 0.57 0.64 0.79 22214286
+ 0.57 0.64 0.79 29285714
+ 0.57 0.64 0.79 36357143
+ 0.57 0.64 0.79 43428571
+ 0.57 0.64 0.79 50500000
+ 0.57 0.64 0.79 57571429
+ 0.57 0.64 0.79 64642857
+ 0.57 0.64 0.79 71714286
+ 0.57 0.64 0.79 78785714
+ 0.57 0.64 0.79 85857143
+ 0.57 0.64 0.79 92928571
+ 0.57 0.64 0.79 100000000
+ 0.57 0.64 0.86 1000000
+ 0.57 0.64 0.86 8071429
+ 0.57 0.64 0.86 15142857
+ 0.57 0.64 0.86 22214286
+ 0.57 0.64 0.86 29285714
+ 0.57 0.64 0.86 36357143
+ 0.57 0.64 0.86 43428571
+ 0.57 0.64 0.86 50500000
+ 0.57 0.64 0.86 57571429
+ 0.57 0.64 0.86 64642857
+ 0.57 0.64 0.86 71714286
+ 0.57 0.64 0.86 78785714
+ 0.57 0.64 0.86 85857143
+ 0.57 0.64 0.86 92928571
+ 0.57 0.64 0.86 100000000
+ 0.57 0.64 0.93 1000000
+ 0.57 0.64 0.93 8071429
+ 0.57 0.64 0.93 15142857
+ 0.57 0.64 0.93 22214286
+ 0.57 0.64 0.93 29285714
+ 0.57 0.64 0.93 36357143
+ 0.57 0.64 0.93 43428571
+ 0.57 0.64 0.93 50500000
+ 0.57 0.64 0.93 57571429
+ 0.57 0.64 0.93 64642857
+ 0.57 0.64 0.93 71714286
+ 0.57 0.64 0.93 78785714
+ 0.57 0.64 0.93 85857143
+ 0.57 0.64 0.93 92928571
+ 0.57 0.64 0.93 100000000
+ 0.57 0.64 1.00 1000000
+ 0.57 0.64 1.00 8071429
+ 0.57 0.64 1.00 15142857
+ 0.57 0.64 1.00 22214286
+ 0.57 0.64 1.00 29285714
+ 0.57 0.64 1.00 36357143
+ 0.57 0.64 1.00 43428571
+ 0.57 0.64 1.00 50500000
+ 0.57 0.64 1.00 57571429
+ 0.57 0.64 1.00 64642857
+ 0.57 0.64 1.00 71714286
+ 0.57 0.64 1.00 78785714
+ 0.57 0.64 1.00 85857143
+ 0.57 0.64 1.00 92928571
+ 0.57 0.64 1.00 100000000
+ 0.57 0.71 0.00 1000000
+ 0.57 0.71 0.00 8071429
+ 0.57 0.71 0.00 15142857
+ 0.57 0.71 0.00 22214286
+ 0.57 0.71 0.00 29285714
+ 0.57 0.71 0.00 36357143
+ 0.57 0.71 0.00 43428571
+ 0.57 0.71 0.00 50500000
+ 0.57 0.71 0.00 57571429
+ 0.57 0.71 0.00 64642857
+ 0.57 0.71 0.00 71714286
+ 0.57 0.71 0.00 78785714
+ 0.57 0.71 0.00 85857143
+ 0.57 0.71 0.00 92928571
+ 0.57 0.71 0.00 100000000
+ 0.57 0.71 0.07 1000000
+ 0.57 0.71 0.07 8071429
+ 0.57 0.71 0.07 15142857
+ 0.57 0.71 0.07 22214286
+ 0.57 0.71 0.07 29285714
+ 0.57 0.71 0.07 36357143
+ 0.57 0.71 0.07 43428571
+ 0.57 0.71 0.07 50500000
+ 0.57 0.71 0.07 57571429
+ 0.57 0.71 0.07 64642857
+ 0.57 0.71 0.07 71714286
+ 0.57 0.71 0.07 78785714
+ 0.57 0.71 0.07 85857143
+ 0.57 0.71 0.07 92928571
+ 0.57 0.71 0.07 100000000
+ 0.57 0.71 0.14 1000000
+ 0.57 0.71 0.14 8071429
+ 0.57 0.71 0.14 15142857
+ 0.57 0.71 0.14 22214286
+ 0.57 0.71 0.14 29285714
+ 0.57 0.71 0.14 36357143
+ 0.57 0.71 0.14 43428571
+ 0.57 0.71 0.14 50500000
+ 0.57 0.71 0.14 57571429
+ 0.57 0.71 0.14 64642857
+ 0.57 0.71 0.14 71714286
+ 0.57 0.71 0.14 78785714
+ 0.57 0.71 0.14 85857143
+ 0.57 0.71 0.14 92928571
+ 0.57 0.71 0.14 100000000
+ 0.57 0.71 0.21 1000000
+ 0.57 0.71 0.21 8071429
+ 0.57 0.71 0.21 15142857
+ 0.57 0.71 0.21 22214286
+ 0.57 0.71 0.21 29285714
+ 0.57 0.71 0.21 36357143
+ 0.57 0.71 0.21 43428571
+ 0.57 0.71 0.21 50500000
+ 0.57 0.71 0.21 57571429
+ 0.57 0.71 0.21 64642857
+ 0.57 0.71 0.21 71714286
+ 0.57 0.71 0.21 78785714
+ 0.57 0.71 0.21 85857143
+ 0.57 0.71 0.21 92928571
+ 0.57 0.71 0.21 100000000
+ 0.57 0.71 0.29 1000000
+ 0.57 0.71 0.29 8071429
+ 0.57 0.71 0.29 15142857
+ 0.57 0.71 0.29 22214286
+ 0.57 0.71 0.29 29285714
+ 0.57 0.71 0.29 36357143
+ 0.57 0.71 0.29 43428571
+ 0.57 0.71 0.29 50500000
+ 0.57 0.71 0.29 57571429
+ 0.57 0.71 0.29 64642857
+ 0.57 0.71 0.29 71714286
+ 0.57 0.71 0.29 78785714
+ 0.57 0.71 0.29 85857143
+ 0.57 0.71 0.29 92928571
+ 0.57 0.71 0.29 100000000
+ 0.57 0.71 0.36 1000000
+ 0.57 0.71 0.36 8071429
+ 0.57 0.71 0.36 15142857
+ 0.57 0.71 0.36 22214286
+ 0.57 0.71 0.36 29285714
+ 0.57 0.71 0.36 36357143
+ 0.57 0.71 0.36 43428571
+ 0.57 0.71 0.36 50500000
+ 0.57 0.71 0.36 57571429
+ 0.57 0.71 0.36 64642857
+ 0.57 0.71 0.36 71714286
+ 0.57 0.71 0.36 78785714
+ 0.57 0.71 0.36 85857143
+ 0.57 0.71 0.36 92928571
+ 0.57 0.71 0.36 100000000
+ 0.57 0.71 0.43 1000000
+ 0.57 0.71 0.43 8071429
+ 0.57 0.71 0.43 15142857
+ 0.57 0.71 0.43 22214286
+ 0.57 0.71 0.43 29285714
+ 0.57 0.71 0.43 36357143
+ 0.57 0.71 0.43 43428571
+ 0.57 0.71 0.43 50500000
+ 0.57 0.71 0.43 57571429
+ 0.57 0.71 0.43 64642857
+ 0.57 0.71 0.43 71714286
+ 0.57 0.71 0.43 78785714
+ 0.57 0.71 0.43 85857143
+ 0.57 0.71 0.43 92928571
+ 0.57 0.71 0.43 100000000
+ 0.57 0.71 0.50 1000000
+ 0.57 0.71 0.50 8071429
+ 0.57 0.71 0.50 15142857
+ 0.57 0.71 0.50 22214286
+ 0.57 0.71 0.50 29285714
+ 0.57 0.71 0.50 36357143
+ 0.57 0.71 0.50 43428571
+ 0.57 0.71 0.50 50500000
+ 0.57 0.71 0.50 57571429
+ 0.57 0.71 0.50 64642857
+ 0.57 0.71 0.50 71714286
+ 0.57 0.71 0.50 78785714
+ 0.57 0.71 0.50 85857143
+ 0.57 0.71 0.50 92928571
+ 0.57 0.71 0.50 100000000
+ 0.57 0.71 0.57 1000000
+ 0.57 0.71 0.57 8071429
+ 0.57 0.71 0.57 15142857
+ 0.57 0.71 0.57 22214286
+ 0.57 0.71 0.57 29285714
+ 0.57 0.71 0.57 36357143
+ 0.57 0.71 0.57 43428571
+ 0.57 0.71 0.57 50500000
+ 0.57 0.71 0.57 57571429
+ 0.57 0.71 0.57 64642857
+ 0.57 0.71 0.57 71714286
+ 0.57 0.71 0.57 78785714
+ 0.57 0.71 0.57 85857143
+ 0.57 0.71 0.57 92928571
+ 0.57 0.71 0.57 100000000
+ 0.57 0.71 0.64 1000000
+ 0.57 0.71 0.64 8071429
+ 0.57 0.71 0.64 15142857
+ 0.57 0.71 0.64 22214286
+ 0.57 0.71 0.64 29285714
+ 0.57 0.71 0.64 36357143
+ 0.57 0.71 0.64 43428571
+ 0.57 0.71 0.64 50500000
+ 0.57 0.71 0.64 57571429
+ 0.57 0.71 0.64 64642857
+ 0.57 0.71 0.64 71714286
+ 0.57 0.71 0.64 78785714
+ 0.57 0.71 0.64 85857143
+ 0.57 0.71 0.64 92928571
+ 0.57 0.71 0.64 100000000
+ 0.57 0.71 0.71 1000000
+ 0.57 0.71 0.71 8071429
+ 0.57 0.71 0.71 15142857
+ 0.57 0.71 0.71 22214286
+ 0.57 0.71 0.71 29285714
+ 0.57 0.71 0.71 36357143
+ 0.57 0.71 0.71 43428571
+ 0.57 0.71 0.71 50500000
+ 0.57 0.71 0.71 57571429
+ 0.57 0.71 0.71 64642857
+ 0.57 0.71 0.71 71714286
+ 0.57 0.71 0.71 78785714
+ 0.57 0.71 0.71 85857143
+ 0.57 0.71 0.71 92928571
+ 0.57 0.71 0.71 100000000
+ 0.57 0.71 0.79 1000000
+ 0.57 0.71 0.79 8071429
+ 0.57 0.71 0.79 15142857
+ 0.57 0.71 0.79 22214286
+ 0.57 0.71 0.79 29285714
+ 0.57 0.71 0.79 36357143
+ 0.57 0.71 0.79 43428571
+ 0.57 0.71 0.79 50500000
+ 0.57 0.71 0.79 57571429
+ 0.57 0.71 0.79 64642857
+ 0.57 0.71 0.79 71714286
+ 0.57 0.71 0.79 78785714
+ 0.57 0.71 0.79 85857143
+ 0.57 0.71 0.79 92928571
+ 0.57 0.71 0.79 100000000
+ 0.57 0.71 0.86 1000000
+ 0.57 0.71 0.86 8071429
+ 0.57 0.71 0.86 15142857
+ 0.57 0.71 0.86 22214286
+ 0.57 0.71 0.86 29285714
+ 0.57 0.71 0.86 36357143
+ 0.57 0.71 0.86 43428571
+ 0.57 0.71 0.86 50500000
+ 0.57 0.71 0.86 57571429
+ 0.57 0.71 0.86 64642857
+ 0.57 0.71 0.86 71714286
+ 0.57 0.71 0.86 78785714
+ 0.57 0.71 0.86 85857143
+ 0.57 0.71 0.86 92928571
+ 0.57 0.71 0.86 100000000
+ 0.57 0.71 0.93 1000000
+ 0.57 0.71 0.93 8071429
+ 0.57 0.71 0.93 15142857
+ 0.57 0.71 0.93 22214286
+ 0.57 0.71 0.93 29285714
+ 0.57 0.71 0.93 36357143
+ 0.57 0.71 0.93 43428571
+ 0.57 0.71 0.93 50500000
+ 0.57 0.71 0.93 57571429
+ 0.57 0.71 0.93 64642857
+ 0.57 0.71 0.93 71714286
+ 0.57 0.71 0.93 78785714
+ 0.57 0.71 0.93 85857143
+ 0.57 0.71 0.93 92928571
+ 0.57 0.71 0.93 100000000
+ 0.57 0.71 1.00 1000000
+ 0.57 0.71 1.00 8071429
+ 0.57 0.71 1.00 15142857
+ 0.57 0.71 1.00 22214286
+ 0.57 0.71 1.00 29285714
+ 0.57 0.71 1.00 36357143
+ 0.57 0.71 1.00 43428571
+ 0.57 0.71 1.00 50500000
+ 0.57 0.71 1.00 57571429
+ 0.57 0.71 1.00 64642857
+ 0.57 0.71 1.00 71714286
+ 0.57 0.71 1.00 78785714
+ 0.57 0.71 1.00 85857143
+ 0.57 0.71 1.00 92928571
+ 0.57 0.71 1.00 100000000
+ 0.57 0.79 0.00 1000000
+ 0.57 0.79 0.00 8071429
+ 0.57 0.79 0.00 15142857
+ 0.57 0.79 0.00 22214286
+ 0.57 0.79 0.00 29285714
+ 0.57 0.79 0.00 36357143
+ 0.57 0.79 0.00 43428571
+ 0.57 0.79 0.00 50500000
+ 0.57 0.79 0.00 57571429
+ 0.57 0.79 0.00 64642857
+ 0.57 0.79 0.00 71714286
+ 0.57 0.79 0.00 78785714
+ 0.57 0.79 0.00 85857143
+ 0.57 0.79 0.00 92928571
+ 0.57 0.79 0.00 100000000
+ 0.57 0.79 0.07 1000000
+ 0.57 0.79 0.07 8071429
+ 0.57 0.79 0.07 15142857
+ 0.57 0.79 0.07 22214286
+ 0.57 0.79 0.07 29285714
+ 0.57 0.79 0.07 36357143
+ 0.57 0.79 0.07 43428571
+ 0.57 0.79 0.07 50500000
+ 0.57 0.79 0.07 57571429
+ 0.57 0.79 0.07 64642857
+ 0.57 0.79 0.07 71714286
+ 0.57 0.79 0.07 78785714
+ 0.57 0.79 0.07 85857143
+ 0.57 0.79 0.07 92928571
+ 0.57 0.79 0.07 100000000
+ 0.57 0.79 0.14 1000000
+ 0.57 0.79 0.14 8071429
+ 0.57 0.79 0.14 15142857
+ 0.57 0.79 0.14 22214286
+ 0.57 0.79 0.14 29285714
+ 0.57 0.79 0.14 36357143
+ 0.57 0.79 0.14 43428571
+ 0.57 0.79 0.14 50500000
+ 0.57 0.79 0.14 57571429
+ 0.57 0.79 0.14 64642857
+ 0.57 0.79 0.14 71714286
+ 0.57 0.79 0.14 78785714
+ 0.57 0.79 0.14 85857143
+ 0.57 0.79 0.14 92928571
+ 0.57 0.79 0.14 100000000
+ 0.57 0.79 0.21 1000000
+ 0.57 0.79 0.21 8071429
+ 0.57 0.79 0.21 15142857
+ 0.57 0.79 0.21 22214286
+ 0.57 0.79 0.21 29285714
+ 0.57 0.79 0.21 36357143
+ 0.57 0.79 0.21 43428571
+ 0.57 0.79 0.21 50500000
+ 0.57 0.79 0.21 57571429
+ 0.57 0.79 0.21 64642857
+ 0.57 0.79 0.21 71714286
+ 0.57 0.79 0.21 78785714
+ 0.57 0.79 0.21 85857143
+ 0.57 0.79 0.21 92928571
+ 0.57 0.79 0.21 100000000
+ 0.57 0.79 0.29 1000000
+ 0.57 0.79 0.29 8071429
+ 0.57 0.79 0.29 15142857
+ 0.57 0.79 0.29 22214286
+ 0.57 0.79 0.29 29285714
+ 0.57 0.79 0.29 36357143
+ 0.57 0.79 0.29 43428571
+ 0.57 0.79 0.29 50500000
+ 0.57 0.79 0.29 57571429
+ 0.57 0.79 0.29 64642857
+ 0.57 0.79 0.29 71714286
+ 0.57 0.79 0.29 78785714
+ 0.57 0.79 0.29 85857143
+ 0.57 0.79 0.29 92928571
+ 0.57 0.79 0.29 100000000
+ 0.57 0.79 0.36 1000000
+ 0.57 0.79 0.36 8071429
+ 0.57 0.79 0.36 15142857
+ 0.57 0.79 0.36 22214286
+ 0.57 0.79 0.36 29285714
+ 0.57 0.79 0.36 36357143
+ 0.57 0.79 0.36 43428571
+ 0.57 0.79 0.36 50500000
+ 0.57 0.79 0.36 57571429
+ 0.57 0.79 0.36 64642857
+ 0.57 0.79 0.36 71714286
+ 0.57 0.79 0.36 78785714
+ 0.57 0.79 0.36 85857143
+ 0.57 0.79 0.36 92928571
+ 0.57 0.79 0.36 100000000
+ 0.57 0.79 0.43 1000000
+ 0.57 0.79 0.43 8071429
+ 0.57 0.79 0.43 15142857
+ 0.57 0.79 0.43 22214286
+ 0.57 0.79 0.43 29285714
+ 0.57 0.79 0.43 36357143
+ 0.57 0.79 0.43 43428571
+ 0.57 0.79 0.43 50500000
+ 0.57 0.79 0.43 57571429
+ 0.57 0.79 0.43 64642857
+ 0.57 0.79 0.43 71714286
+ 0.57 0.79 0.43 78785714
+ 0.57 0.79 0.43 85857143
+ 0.57 0.79 0.43 92928571
+ 0.57 0.79 0.43 100000000
+ 0.57 0.79 0.50 1000000
+ 0.57 0.79 0.50 8071429
+ 0.57 0.79 0.50 15142857
+ 0.57 0.79 0.50 22214286
+ 0.57 0.79 0.50 29285714
+ 0.57 0.79 0.50 36357143
+ 0.57 0.79 0.50 43428571
+ 0.57 0.79 0.50 50500000
+ 0.57 0.79 0.50 57571429
+ 0.57 0.79 0.50 64642857
+ 0.57 0.79 0.50 71714286
+ 0.57 0.79 0.50 78785714
+ 0.57 0.79 0.50 85857143
+ 0.57 0.79 0.50 92928571
+ 0.57 0.79 0.50 100000000
+ 0.57 0.79 0.57 1000000
+ 0.57 0.79 0.57 8071429
+ 0.57 0.79 0.57 15142857
+ 0.57 0.79 0.57 22214286
+ 0.57 0.79 0.57 29285714
+ 0.57 0.79 0.57 36357143
+ 0.57 0.79 0.57 43428571
+ 0.57 0.79 0.57 50500000
+ 0.57 0.79 0.57 57571429
+ 0.57 0.79 0.57 64642857
+ 0.57 0.79 0.57 71714286
+ 0.57 0.79 0.57 78785714
+ 0.57 0.79 0.57 85857143
+ 0.57 0.79 0.57 92928571
+ 0.57 0.79 0.57 100000000
+ 0.57 0.79 0.64 1000000
+ 0.57 0.79 0.64 8071429
+ 0.57 0.79 0.64 15142857
+ 0.57 0.79 0.64 22214286
+ 0.57 0.79 0.64 29285714
+ 0.57 0.79 0.64 36357143
+ 0.57 0.79 0.64 43428571
+ 0.57 0.79 0.64 50500000
+ 0.57 0.79 0.64 57571429
+ 0.57 0.79 0.64 64642857
+ 0.57 0.79 0.64 71714286
+ 0.57 0.79 0.64 78785714
+ 0.57 0.79 0.64 85857143
+ 0.57 0.79 0.64 92928571
+ 0.57 0.79 0.64 100000000
+ 0.57 0.79 0.71 1000000
+ 0.57 0.79 0.71 8071429
+ 0.57 0.79 0.71 15142857
+ 0.57 0.79 0.71 22214286
+ 0.57 0.79 0.71 29285714
+ 0.57 0.79 0.71 36357143
+ 0.57 0.79 0.71 43428571
+ 0.57 0.79 0.71 50500000
+ 0.57 0.79 0.71 57571429
+ 0.57 0.79 0.71 64642857
+ 0.57 0.79 0.71 71714286
+ 0.57 0.79 0.71 78785714
+ 0.57 0.79 0.71 85857143
+ 0.57 0.79 0.71 92928571
+ 0.57 0.79 0.71 100000000
+ 0.57 0.79 0.79 1000000
+ 0.57 0.79 0.79 8071429
+ 0.57 0.79 0.79 15142857
+ 0.57 0.79 0.79 22214286
+ 0.57 0.79 0.79 29285714
+ 0.57 0.79 0.79 36357143
+ 0.57 0.79 0.79 43428571
+ 0.57 0.79 0.79 50500000
+ 0.57 0.79 0.79 57571429
+ 0.57 0.79 0.79 64642857
+ 0.57 0.79 0.79 71714286
+ 0.57 0.79 0.79 78785714
+ 0.57 0.79 0.79 85857143
+ 0.57 0.79 0.79 92928571
+ 0.57 0.79 0.79 100000000
+ 0.57 0.79 0.86 1000000
+ 0.57 0.79 0.86 8071429
+ 0.57 0.79 0.86 15142857
+ 0.57 0.79 0.86 22214286
+ 0.57 0.79 0.86 29285714
+ 0.57 0.79 0.86 36357143
+ 0.57 0.79 0.86 43428571
+ 0.57 0.79 0.86 50500000
+ 0.57 0.79 0.86 57571429
+ 0.57 0.79 0.86 64642857
+ 0.57 0.79 0.86 71714286
+ 0.57 0.79 0.86 78785714
+ 0.57 0.79 0.86 85857143
+ 0.57 0.79 0.86 92928571
+ 0.57 0.79 0.86 100000000
+ 0.57 0.79 0.93 1000000
+ 0.57 0.79 0.93 8071429
+ 0.57 0.79 0.93 15142857
+ 0.57 0.79 0.93 22214286
+ 0.57 0.79 0.93 29285714
+ 0.57 0.79 0.93 36357143
+ 0.57 0.79 0.93 43428571
+ 0.57 0.79 0.93 50500000
+ 0.57 0.79 0.93 57571429
+ 0.57 0.79 0.93 64642857
+ 0.57 0.79 0.93 71714286
+ 0.57 0.79 0.93 78785714
+ 0.57 0.79 0.93 85857143
+ 0.57 0.79 0.93 92928571
+ 0.57 0.79 0.93 100000000
+ 0.57 0.79 1.00 1000000
+ 0.57 0.79 1.00 8071429
+ 0.57 0.79 1.00 15142857
+ 0.57 0.79 1.00 22214286
+ 0.57 0.79 1.00 29285714
+ 0.57 0.79 1.00 36357143
+ 0.57 0.79 1.00 43428571
+ 0.57 0.79 1.00 50500000
+ 0.57 0.79 1.00 57571429
+ 0.57 0.79 1.00 64642857
+ 0.57 0.79 1.00 71714286
+ 0.57 0.79 1.00 78785714
+ 0.57 0.79 1.00 85857143
+ 0.57 0.79 1.00 92928571
+ 0.57 0.79 1.00 100000000
+ 0.57 0.86 0.00 1000000
+ 0.57 0.86 0.00 8071429
+ 0.57 0.86 0.00 15142857
+ 0.57 0.86 0.00 22214286
+ 0.57 0.86 0.00 29285714
+ 0.57 0.86 0.00 36357143
+ 0.57 0.86 0.00 43428571
+ 0.57 0.86 0.00 50500000
+ 0.57 0.86 0.00 57571429
+ 0.57 0.86 0.00 64642857
+ 0.57 0.86 0.00 71714286
+ 0.57 0.86 0.00 78785714
+ 0.57 0.86 0.00 85857143
+ 0.57 0.86 0.00 92928571
+ 0.57 0.86 0.00 100000000
+ 0.57 0.86 0.07 1000000
+ 0.57 0.86 0.07 8071429
+ 0.57 0.86 0.07 15142857
+ 0.57 0.86 0.07 22214286
+ 0.57 0.86 0.07 29285714
+ 0.57 0.86 0.07 36357143
+ 0.57 0.86 0.07 43428571
+ 0.57 0.86 0.07 50500000
+ 0.57 0.86 0.07 57571429
+ 0.57 0.86 0.07 64642857
+ 0.57 0.86 0.07 71714286
+ 0.57 0.86 0.07 78785714
+ 0.57 0.86 0.07 85857143
+ 0.57 0.86 0.07 92928571
+ 0.57 0.86 0.07 100000000
+ 0.57 0.86 0.14 1000000
+ 0.57 0.86 0.14 8071429
+ 0.57 0.86 0.14 15142857
+ 0.57 0.86 0.14 22214286
+ 0.57 0.86 0.14 29285714
+ 0.57 0.86 0.14 36357143
+ 0.57 0.86 0.14 43428571
+ 0.57 0.86 0.14 50500000
+ 0.57 0.86 0.14 57571429
+ 0.57 0.86 0.14 64642857
+ 0.57 0.86 0.14 71714286
+ 0.57 0.86 0.14 78785714
+ 0.57 0.86 0.14 85857143
+ 0.57 0.86 0.14 92928571
+ 0.57 0.86 0.14 100000000
+ 0.57 0.86 0.21 1000000
+ 0.57 0.86 0.21 8071429
+ 0.57 0.86 0.21 15142857
+ 0.57 0.86 0.21 22214286
+ 0.57 0.86 0.21 29285714
+ 0.57 0.86 0.21 36357143
+ 0.57 0.86 0.21 43428571
+ 0.57 0.86 0.21 50500000
+ 0.57 0.86 0.21 57571429
+ 0.57 0.86 0.21 64642857
+ 0.57 0.86 0.21 71714286
+ 0.57 0.86 0.21 78785714
+ 0.57 0.86 0.21 85857143
+ 0.57 0.86 0.21 92928571
+ 0.57 0.86 0.21 100000000
+ 0.57 0.86 0.29 1000000
+ 0.57 0.86 0.29 8071429
+ 0.57 0.86 0.29 15142857
+ 0.57 0.86 0.29 22214286
+ 0.57 0.86 0.29 29285714
+ 0.57 0.86 0.29 36357143
+ 0.57 0.86 0.29 43428571
+ 0.57 0.86 0.29 50500000
+ 0.57 0.86 0.29 57571429
+ 0.57 0.86 0.29 64642857
+ 0.57 0.86 0.29 71714286
+ 0.57 0.86 0.29 78785714
+ 0.57 0.86 0.29 85857143
+ 0.57 0.86 0.29 92928571
+ 0.57 0.86 0.29 100000000
+ 0.57 0.86 0.36 1000000
+ 0.57 0.86 0.36 8071429
+ 0.57 0.86 0.36 15142857
+ 0.57 0.86 0.36 22214286
+ 0.57 0.86 0.36 29285714
+ 0.57 0.86 0.36 36357143
+ 0.57 0.86 0.36 43428571
+ 0.57 0.86 0.36 50500000
+ 0.57 0.86 0.36 57571429
+ 0.57 0.86 0.36 64642857
+ 0.57 0.86 0.36 71714286
+ 0.57 0.86 0.36 78785714
+ 0.57 0.86 0.36 85857143
+ 0.57 0.86 0.36 92928571
+ 0.57 0.86 0.36 100000000
+ 0.57 0.86 0.43 1000000
+ 0.57 0.86 0.43 8071429
+ 0.57 0.86 0.43 15142857
+ 0.57 0.86 0.43 22214286
+ 0.57 0.86 0.43 29285714
+ 0.57 0.86 0.43 36357143
+ 0.57 0.86 0.43 43428571
+ 0.57 0.86 0.43 50500000
+ 0.57 0.86 0.43 57571429
+ 0.57 0.86 0.43 64642857
+ 0.57 0.86 0.43 71714286
+ 0.57 0.86 0.43 78785714
+ 0.57 0.86 0.43 85857143
+ 0.57 0.86 0.43 92928571
+ 0.57 0.86 0.43 100000000
+ 0.57 0.86 0.50 1000000
+ 0.57 0.86 0.50 8071429
+ 0.57 0.86 0.50 15142857
+ 0.57 0.86 0.50 22214286
+ 0.57 0.86 0.50 29285714
+ 0.57 0.86 0.50 36357143
+ 0.57 0.86 0.50 43428571
+ 0.57 0.86 0.50 50500000
+ 0.57 0.86 0.50 57571429
+ 0.57 0.86 0.50 64642857
+ 0.57 0.86 0.50 71714286
+ 0.57 0.86 0.50 78785714
+ 0.57 0.86 0.50 85857143
+ 0.57 0.86 0.50 92928571
+ 0.57 0.86 0.50 100000000
+ 0.57 0.86 0.57 1000000
+ 0.57 0.86 0.57 8071429
+ 0.57 0.86 0.57 15142857
+ 0.57 0.86 0.57 22214286
+ 0.57 0.86 0.57 29285714
+ 0.57 0.86 0.57 36357143
+ 0.57 0.86 0.57 43428571
+ 0.57 0.86 0.57 50500000
+ 0.57 0.86 0.57 57571429
+ 0.57 0.86 0.57 64642857
+ 0.57 0.86 0.57 71714286
+ 0.57 0.86 0.57 78785714
+ 0.57 0.86 0.57 85857143
+ 0.57 0.86 0.57 92928571
+ 0.57 0.86 0.57 100000000
+ 0.57 0.86 0.64 1000000
+ 0.57 0.86 0.64 8071429
+ 0.57 0.86 0.64 15142857
+ 0.57 0.86 0.64 22214286
+ 0.57 0.86 0.64 29285714
+ 0.57 0.86 0.64 36357143
+ 0.57 0.86 0.64 43428571
+ 0.57 0.86 0.64 50500000
+ 0.57 0.86 0.64 57571429
+ 0.57 0.86 0.64 64642857
+ 0.57 0.86 0.64 71714286
+ 0.57 0.86 0.64 78785714
+ 0.57 0.86 0.64 85857143
+ 0.57 0.86 0.64 92928571
+ 0.57 0.86 0.64 100000000
+ 0.57 0.86 0.71 1000000
+ 0.57 0.86 0.71 8071429
+ 0.57 0.86 0.71 15142857
+ 0.57 0.86 0.71 22214286
+ 0.57 0.86 0.71 29285714
+ 0.57 0.86 0.71 36357143
+ 0.57 0.86 0.71 43428571
+ 0.57 0.86 0.71 50500000
+ 0.57 0.86 0.71 57571429
+ 0.57 0.86 0.71 64642857
+ 0.57 0.86 0.71 71714286
+ 0.57 0.86 0.71 78785714
+ 0.57 0.86 0.71 85857143
+ 0.57 0.86 0.71 92928571
+ 0.57 0.86 0.71 100000000
+ 0.57 0.86 0.79 1000000
+ 0.57 0.86 0.79 8071429
+ 0.57 0.86 0.79 15142857
+ 0.57 0.86 0.79 22214286
+ 0.57 0.86 0.79 29285714
+ 0.57 0.86 0.79 36357143
+ 0.57 0.86 0.79 43428571
+ 0.57 0.86 0.79 50500000
+ 0.57 0.86 0.79 57571429
+ 0.57 0.86 0.79 64642857
+ 0.57 0.86 0.79 71714286
+ 0.57 0.86 0.79 78785714
+ 0.57 0.86 0.79 85857143
+ 0.57 0.86 0.79 92928571
+ 0.57 0.86 0.79 100000000
+ 0.57 0.86 0.86 1000000
+ 0.57 0.86 0.86 8071429
+ 0.57 0.86 0.86 15142857
+ 0.57 0.86 0.86 22214286
+ 0.57 0.86 0.86 29285714
+ 0.57 0.86 0.86 36357143
+ 0.57 0.86 0.86 43428571
+ 0.57 0.86 0.86 50500000
+ 0.57 0.86 0.86 57571429
+ 0.57 0.86 0.86 64642857
+ 0.57 0.86 0.86 71714286
+ 0.57 0.86 0.86 78785714
+ 0.57 0.86 0.86 85857143
+ 0.57 0.86 0.86 92928571
+ 0.57 0.86 0.86 100000000
+ 0.57 0.86 0.93 1000000
+ 0.57 0.86 0.93 8071429
+ 0.57 0.86 0.93 15142857
+ 0.57 0.86 0.93 22214286
+ 0.57 0.86 0.93 29285714
+ 0.57 0.86 0.93 36357143
+ 0.57 0.86 0.93 43428571
+ 0.57 0.86 0.93 50500000
+ 0.57 0.86 0.93 57571429
+ 0.57 0.86 0.93 64642857
+ 0.57 0.86 0.93 71714286
+ 0.57 0.86 0.93 78785714
+ 0.57 0.86 0.93 85857143
+ 0.57 0.86 0.93 92928571
+ 0.57 0.86 0.93 100000000
+ 0.57 0.86 1.00 1000000
+ 0.57 0.86 1.00 8071429
+ 0.57 0.86 1.00 15142857
+ 0.57 0.86 1.00 22214286
+ 0.57 0.86 1.00 29285714
+ 0.57 0.86 1.00 36357143
+ 0.57 0.86 1.00 43428571
+ 0.57 0.86 1.00 50500000
+ 0.57 0.86 1.00 57571429
+ 0.57 0.86 1.00 64642857
+ 0.57 0.86 1.00 71714286
+ 0.57 0.86 1.00 78785714
+ 0.57 0.86 1.00 85857143
+ 0.57 0.86 1.00 92928571
+ 0.57 0.86 1.00 100000000
+ 0.57 0.93 0.00 1000000
+ 0.57 0.93 0.00 8071429
+ 0.57 0.93 0.00 15142857
+ 0.57 0.93 0.00 22214286
+ 0.57 0.93 0.00 29285714
+ 0.57 0.93 0.00 36357143
+ 0.57 0.93 0.00 43428571
+ 0.57 0.93 0.00 50500000
+ 0.57 0.93 0.00 57571429
+ 0.57 0.93 0.00 64642857
+ 0.57 0.93 0.00 71714286
+ 0.57 0.93 0.00 78785714
+ 0.57 0.93 0.00 85857143
+ 0.57 0.93 0.00 92928571
+ 0.57 0.93 0.00 100000000
+ 0.57 0.93 0.07 1000000
+ 0.57 0.93 0.07 8071429
+ 0.57 0.93 0.07 15142857
+ 0.57 0.93 0.07 22214286
+ 0.57 0.93 0.07 29285714
+ 0.57 0.93 0.07 36357143
+ 0.57 0.93 0.07 43428571
+ 0.57 0.93 0.07 50500000
+ 0.57 0.93 0.07 57571429
+ 0.57 0.93 0.07 64642857
+ 0.57 0.93 0.07 71714286
+ 0.57 0.93 0.07 78785714
+ 0.57 0.93 0.07 85857143
+ 0.57 0.93 0.07 92928571
+ 0.57 0.93 0.07 100000000
+ 0.57 0.93 0.14 1000000
+ 0.57 0.93 0.14 8071429
+ 0.57 0.93 0.14 15142857
+ 0.57 0.93 0.14 22214286
+ 0.57 0.93 0.14 29285714
+ 0.57 0.93 0.14 36357143
+ 0.57 0.93 0.14 43428571
+ 0.57 0.93 0.14 50500000
+ 0.57 0.93 0.14 57571429
+ 0.57 0.93 0.14 64642857
+ 0.57 0.93 0.14 71714286
+ 0.57 0.93 0.14 78785714
+ 0.57 0.93 0.14 85857143
+ 0.57 0.93 0.14 92928571
+ 0.57 0.93 0.14 100000000
+ 0.57 0.93 0.21 1000000
+ 0.57 0.93 0.21 8071429
+ 0.57 0.93 0.21 15142857
+ 0.57 0.93 0.21 22214286
+ 0.57 0.93 0.21 29285714
+ 0.57 0.93 0.21 36357143
+ 0.57 0.93 0.21 43428571
+ 0.57 0.93 0.21 50500000
+ 0.57 0.93 0.21 57571429
+ 0.57 0.93 0.21 64642857
+ 0.57 0.93 0.21 71714286
+ 0.57 0.93 0.21 78785714
+ 0.57 0.93 0.21 85857143
+ 0.57 0.93 0.21 92928571
+ 0.57 0.93 0.21 100000000
+ 0.57 0.93 0.29 1000000
+ 0.57 0.93 0.29 8071429
+ 0.57 0.93 0.29 15142857
+ 0.57 0.93 0.29 22214286
+ 0.57 0.93 0.29 29285714
+ 0.57 0.93 0.29 36357143
+ 0.57 0.93 0.29 43428571
+ 0.57 0.93 0.29 50500000
+ 0.57 0.93 0.29 57571429
+ 0.57 0.93 0.29 64642857
+ 0.57 0.93 0.29 71714286
+ 0.57 0.93 0.29 78785714
+ 0.57 0.93 0.29 85857143
+ 0.57 0.93 0.29 92928571
+ 0.57 0.93 0.29 100000000
+ 0.57 0.93 0.36 1000000
+ 0.57 0.93 0.36 8071429
+ 0.57 0.93 0.36 15142857
+ 0.57 0.93 0.36 22214286
+ 0.57 0.93 0.36 29285714
+ 0.57 0.93 0.36 36357143
+ 0.57 0.93 0.36 43428571
+ 0.57 0.93 0.36 50500000
+ 0.57 0.93 0.36 57571429
+ 0.57 0.93 0.36 64642857
+ 0.57 0.93 0.36 71714286
+ 0.57 0.93 0.36 78785714
+ 0.57 0.93 0.36 85857143
+ 0.57 0.93 0.36 92928571
+ 0.57 0.93 0.36 100000000
+ 0.57 0.93 0.43 1000000
+ 0.57 0.93 0.43 8071429
+ 0.57 0.93 0.43 15142857
+ 0.57 0.93 0.43 22214286
+ 0.57 0.93 0.43 29285714
+ 0.57 0.93 0.43 36357143
+ 0.57 0.93 0.43 43428571
+ 0.57 0.93 0.43 50500000
+ 0.57 0.93 0.43 57571429
+ 0.57 0.93 0.43 64642857
+ 0.57 0.93 0.43 71714286
+ 0.57 0.93 0.43 78785714
+ 0.57 0.93 0.43 85857143
+ 0.57 0.93 0.43 92928571
+ 0.57 0.93 0.43 100000000
+ 0.57 0.93 0.50 1000000
+ 0.57 0.93 0.50 8071429
+ 0.57 0.93 0.50 15142857
+ 0.57 0.93 0.50 22214286
+ 0.57 0.93 0.50 29285714
+ 0.57 0.93 0.50 36357143
+ 0.57 0.93 0.50 43428571
+ 0.57 0.93 0.50 50500000
+ 0.57 0.93 0.50 57571429
+ 0.57 0.93 0.50 64642857
+ 0.57 0.93 0.50 71714286
+ 0.57 0.93 0.50 78785714
+ 0.57 0.93 0.50 85857143
+ 0.57 0.93 0.50 92928571
+ 0.57 0.93 0.50 100000000
+ 0.57 0.93 0.57 1000000
+ 0.57 0.93 0.57 8071429
+ 0.57 0.93 0.57 15142857
+ 0.57 0.93 0.57 22214286
+ 0.57 0.93 0.57 29285714
+ 0.57 0.93 0.57 36357143
+ 0.57 0.93 0.57 43428571
+ 0.57 0.93 0.57 50500000
+ 0.57 0.93 0.57 57571429
+ 0.57 0.93 0.57 64642857
+ 0.57 0.93 0.57 71714286
+ 0.57 0.93 0.57 78785714
+ 0.57 0.93 0.57 85857143
+ 0.57 0.93 0.57 92928571
+ 0.57 0.93 0.57 100000000
+ 0.57 0.93 0.64 1000000
+ 0.57 0.93 0.64 8071429
+ 0.57 0.93 0.64 15142857
+ 0.57 0.93 0.64 22214286
+ 0.57 0.93 0.64 29285714
+ 0.57 0.93 0.64 36357143
+ 0.57 0.93 0.64 43428571
+ 0.57 0.93 0.64 50500000
+ 0.57 0.93 0.64 57571429
+ 0.57 0.93 0.64 64642857
+ 0.57 0.93 0.64 71714286
+ 0.57 0.93 0.64 78785714
+ 0.57 0.93 0.64 85857143
+ 0.57 0.93 0.64 92928571
+ 0.57 0.93 0.64 100000000
+ 0.57 0.93 0.71 1000000
+ 0.57 0.93 0.71 8071429
+ 0.57 0.93 0.71 15142857
+ 0.57 0.93 0.71 22214286
+ 0.57 0.93 0.71 29285714
+ 0.57 0.93 0.71 36357143
+ 0.57 0.93 0.71 43428571
+ 0.57 0.93 0.71 50500000
+ 0.57 0.93 0.71 57571429
+ 0.57 0.93 0.71 64642857
+ 0.57 0.93 0.71 71714286
+ 0.57 0.93 0.71 78785714
+ 0.57 0.93 0.71 85857143
+ 0.57 0.93 0.71 92928571
+ 0.57 0.93 0.71 100000000
+ 0.57 0.93 0.79 1000000
+ 0.57 0.93 0.79 8071429
+ 0.57 0.93 0.79 15142857
+ 0.57 0.93 0.79 22214286
+ 0.57 0.93 0.79 29285714
+ 0.57 0.93 0.79 36357143
+ 0.57 0.93 0.79 43428571
+ 0.57 0.93 0.79 50500000
+ 0.57 0.93 0.79 57571429
+ 0.57 0.93 0.79 64642857
+ 0.57 0.93 0.79 71714286
+ 0.57 0.93 0.79 78785714
+ 0.57 0.93 0.79 85857143
+ 0.57 0.93 0.79 92928571
+ 0.57 0.93 0.79 100000000
+ 0.57 0.93 0.86 1000000
+ 0.57 0.93 0.86 8071429
+ 0.57 0.93 0.86 15142857
+ 0.57 0.93 0.86 22214286
+ 0.57 0.93 0.86 29285714
+ 0.57 0.93 0.86 36357143
+ 0.57 0.93 0.86 43428571
+ 0.57 0.93 0.86 50500000
+ 0.57 0.93 0.86 57571429
+ 0.57 0.93 0.86 64642857
+ 0.57 0.93 0.86 71714286
+ 0.57 0.93 0.86 78785714
+ 0.57 0.93 0.86 85857143
+ 0.57 0.93 0.86 92928571
+ 0.57 0.93 0.86 100000000
+ 0.57 0.93 0.93 1000000
+ 0.57 0.93 0.93 8071429
+ 0.57 0.93 0.93 15142857
+ 0.57 0.93 0.93 22214286
+ 0.57 0.93 0.93 29285714
+ 0.57 0.93 0.93 36357143
+ 0.57 0.93 0.93 43428571
+ 0.57 0.93 0.93 50500000
+ 0.57 0.93 0.93 57571429
+ 0.57 0.93 0.93 64642857
+ 0.57 0.93 0.93 71714286
+ 0.57 0.93 0.93 78785714
+ 0.57 0.93 0.93 85857143
+ 0.57 0.93 0.93 92928571
+ 0.57 0.93 0.93 100000000
+ 0.57 0.93 1.00 1000000
+ 0.57 0.93 1.00 8071429
+ 0.57 0.93 1.00 15142857
+ 0.57 0.93 1.00 22214286
+ 0.57 0.93 1.00 29285714
+ 0.57 0.93 1.00 36357143
+ 0.57 0.93 1.00 43428571
+ 0.57 0.93 1.00 50500000
+ 0.57 0.93 1.00 57571429
+ 0.57 0.93 1.00 64642857
+ 0.57 0.93 1.00 71714286
+ 0.57 0.93 1.00 78785714
+ 0.57 0.93 1.00 85857143
+ 0.57 0.93 1.00 92928571
+ 0.57 0.93 1.00 100000000
+ 0.57 1.00 0.00 1000000
+ 0.57 1.00 0.00 8071429
+ 0.57 1.00 0.00 15142857
+ 0.57 1.00 0.00 22214286
+ 0.57 1.00 0.00 29285714
+ 0.57 1.00 0.00 36357143
+ 0.57 1.00 0.00 43428571
+ 0.57 1.00 0.00 50500000
+ 0.57 1.00 0.00 57571429
+ 0.57 1.00 0.00 64642857
+ 0.57 1.00 0.00 71714286
+ 0.57 1.00 0.00 78785714
+ 0.57 1.00 0.00 85857143
+ 0.57 1.00 0.00 92928571
+ 0.57 1.00 0.00 100000000
+ 0.57 1.00 0.07 1000000
+ 0.57 1.00 0.07 8071429
+ 0.57 1.00 0.07 15142857
+ 0.57 1.00 0.07 22214286
+ 0.57 1.00 0.07 29285714
+ 0.57 1.00 0.07 36357143
+ 0.57 1.00 0.07 43428571
+ 0.57 1.00 0.07 50500000
+ 0.57 1.00 0.07 57571429
+ 0.57 1.00 0.07 64642857
+ 0.57 1.00 0.07 71714286
+ 0.57 1.00 0.07 78785714
+ 0.57 1.00 0.07 85857143
+ 0.57 1.00 0.07 92928571
+ 0.57 1.00 0.07 100000000
+ 0.57 1.00 0.14 1000000
+ 0.57 1.00 0.14 8071429
+ 0.57 1.00 0.14 15142857
+ 0.57 1.00 0.14 22214286
+ 0.57 1.00 0.14 29285714
+ 0.57 1.00 0.14 36357143
+ 0.57 1.00 0.14 43428571
+ 0.57 1.00 0.14 50500000
+ 0.57 1.00 0.14 57571429
+ 0.57 1.00 0.14 64642857
+ 0.57 1.00 0.14 71714286
+ 0.57 1.00 0.14 78785714
+ 0.57 1.00 0.14 85857143
+ 0.57 1.00 0.14 92928571
+ 0.57 1.00 0.14 100000000
+ 0.57 1.00 0.21 1000000
+ 0.57 1.00 0.21 8071429
+ 0.57 1.00 0.21 15142857
+ 0.57 1.00 0.21 22214286
+ 0.57 1.00 0.21 29285714
+ 0.57 1.00 0.21 36357143
+ 0.57 1.00 0.21 43428571
+ 0.57 1.00 0.21 50500000
+ 0.57 1.00 0.21 57571429
+ 0.57 1.00 0.21 64642857
+ 0.57 1.00 0.21 71714286
+ 0.57 1.00 0.21 78785714
+ 0.57 1.00 0.21 85857143
+ 0.57 1.00 0.21 92928571
+ 0.57 1.00 0.21 100000000
+ 0.57 1.00 0.29 1000000
+ 0.57 1.00 0.29 8071429
+ 0.57 1.00 0.29 15142857
+ 0.57 1.00 0.29 22214286
+ 0.57 1.00 0.29 29285714
+ 0.57 1.00 0.29 36357143
+ 0.57 1.00 0.29 43428571
+ 0.57 1.00 0.29 50500000
+ 0.57 1.00 0.29 57571429
+ 0.57 1.00 0.29 64642857
+ 0.57 1.00 0.29 71714286
+ 0.57 1.00 0.29 78785714
+ 0.57 1.00 0.29 85857143
+ 0.57 1.00 0.29 92928571
+ 0.57 1.00 0.29 100000000
+ 0.57 1.00 0.36 1000000
+ 0.57 1.00 0.36 8071429
+ 0.57 1.00 0.36 15142857
+ 0.57 1.00 0.36 22214286
+ 0.57 1.00 0.36 29285714
+ 0.57 1.00 0.36 36357143
+ 0.57 1.00 0.36 43428571
+ 0.57 1.00 0.36 50500000
+ 0.57 1.00 0.36 57571429
+ 0.57 1.00 0.36 64642857
+ 0.57 1.00 0.36 71714286
+ 0.57 1.00 0.36 78785714
+ 0.57 1.00 0.36 85857143
+ 0.57 1.00 0.36 92928571
+ 0.57 1.00 0.36 100000000
+ 0.57 1.00 0.43 1000000
+ 0.57 1.00 0.43 8071429
+ 0.57 1.00 0.43 15142857
+ 0.57 1.00 0.43 22214286
+ 0.57 1.00 0.43 29285714
+ 0.57 1.00 0.43 36357143
+ 0.57 1.00 0.43 43428571
+ 0.57 1.00 0.43 50500000
+ 0.57 1.00 0.43 57571429
+ 0.57 1.00 0.43 64642857
+ 0.57 1.00 0.43 71714286
+ 0.57 1.00 0.43 78785714
+ 0.57 1.00 0.43 85857143
+ 0.57 1.00 0.43 92928571
+ 0.57 1.00 0.43 100000000
+ 0.57 1.00 0.50 1000000
+ 0.57 1.00 0.50 8071429
+ 0.57 1.00 0.50 15142857
+ 0.57 1.00 0.50 22214286
+ 0.57 1.00 0.50 29285714
+ 0.57 1.00 0.50 36357143
+ 0.57 1.00 0.50 43428571
+ 0.57 1.00 0.50 50500000
+ 0.57 1.00 0.50 57571429
+ 0.57 1.00 0.50 64642857
+ 0.57 1.00 0.50 71714286
+ 0.57 1.00 0.50 78785714
+ 0.57 1.00 0.50 85857143
+ 0.57 1.00 0.50 92928571
+ 0.57 1.00 0.50 100000000
+ 0.57 1.00 0.57 1000000
+ 0.57 1.00 0.57 8071429
+ 0.57 1.00 0.57 15142857
+ 0.57 1.00 0.57 22214286
+ 0.57 1.00 0.57 29285714
+ 0.57 1.00 0.57 36357143
+ 0.57 1.00 0.57 43428571
+ 0.57 1.00 0.57 50500000
+ 0.57 1.00 0.57 57571429
+ 0.57 1.00 0.57 64642857
+ 0.57 1.00 0.57 71714286
+ 0.57 1.00 0.57 78785714
+ 0.57 1.00 0.57 85857143
+ 0.57 1.00 0.57 92928571
+ 0.57 1.00 0.57 100000000
+ 0.57 1.00 0.64 1000000
+ 0.57 1.00 0.64 8071429
+ 0.57 1.00 0.64 15142857
+ 0.57 1.00 0.64 22214286
+ 0.57 1.00 0.64 29285714
+ 0.57 1.00 0.64 36357143
+ 0.57 1.00 0.64 43428571
+ 0.57 1.00 0.64 50500000
+ 0.57 1.00 0.64 57571429
+ 0.57 1.00 0.64 64642857
+ 0.57 1.00 0.64 71714286
+ 0.57 1.00 0.64 78785714
+ 0.57 1.00 0.64 85857143
+ 0.57 1.00 0.64 92928571
+ 0.57 1.00 0.64 100000000
+ 0.57 1.00 0.71 1000000
+ 0.57 1.00 0.71 8071429
+ 0.57 1.00 0.71 15142857
+ 0.57 1.00 0.71 22214286
+ 0.57 1.00 0.71 29285714
+ 0.57 1.00 0.71 36357143
+ 0.57 1.00 0.71 43428571
+ 0.57 1.00 0.71 50500000
+ 0.57 1.00 0.71 57571429
+ 0.57 1.00 0.71 64642857
+ 0.57 1.00 0.71 71714286
+ 0.57 1.00 0.71 78785714
+ 0.57 1.00 0.71 85857143
+ 0.57 1.00 0.71 92928571
+ 0.57 1.00 0.71 100000000
+ 0.57 1.00 0.79 1000000
+ 0.57 1.00 0.79 8071429
+ 0.57 1.00 0.79 15142857
+ 0.57 1.00 0.79 22214286
+ 0.57 1.00 0.79 29285714
+ 0.57 1.00 0.79 36357143
+ 0.57 1.00 0.79 43428571
+ 0.57 1.00 0.79 50500000
+ 0.57 1.00 0.79 57571429
+ 0.57 1.00 0.79 64642857
+ 0.57 1.00 0.79 71714286
+ 0.57 1.00 0.79 78785714
+ 0.57 1.00 0.79 85857143
+ 0.57 1.00 0.79 92928571
+ 0.57 1.00 0.79 100000000
+ 0.57 1.00 0.86 1000000
+ 0.57 1.00 0.86 8071429
+ 0.57 1.00 0.86 15142857
+ 0.57 1.00 0.86 22214286
+ 0.57 1.00 0.86 29285714
+ 0.57 1.00 0.86 36357143
+ 0.57 1.00 0.86 43428571
+ 0.57 1.00 0.86 50500000
+ 0.57 1.00 0.86 57571429
+ 0.57 1.00 0.86 64642857
+ 0.57 1.00 0.86 71714286
+ 0.57 1.00 0.86 78785714
+ 0.57 1.00 0.86 85857143
+ 0.57 1.00 0.86 92928571
+ 0.57 1.00 0.86 100000000
+ 0.57 1.00 0.93 1000000
+ 0.57 1.00 0.93 8071429
+ 0.57 1.00 0.93 15142857
+ 0.57 1.00 0.93 22214286
+ 0.57 1.00 0.93 29285714
+ 0.57 1.00 0.93 36357143
+ 0.57 1.00 0.93 43428571
+ 0.57 1.00 0.93 50500000
+ 0.57 1.00 0.93 57571429
+ 0.57 1.00 0.93 64642857
+ 0.57 1.00 0.93 71714286
+ 0.57 1.00 0.93 78785714
+ 0.57 1.00 0.93 85857143
+ 0.57 1.00 0.93 92928571
+ 0.57 1.00 0.93 100000000
+ 0.57 1.00 1.00 1000000
+ 0.57 1.00 1.00 8071429
+ 0.57 1.00 1.00 15142857
+ 0.57 1.00 1.00 22214286
+ 0.57 1.00 1.00 29285714
+ 0.57 1.00 1.00 36357143
+ 0.57 1.00 1.00 43428571
+ 0.57 1.00 1.00 50500000
+ 0.57 1.00 1.00 57571429
+ 0.57 1.00 1.00 64642857
+ 0.57 1.00 1.00 71714286
+ 0.57 1.00 1.00 78785714
+ 0.57 1.00 1.00 85857143
+ 0.57 1.00 1.00 92928571
+ 0.57 1.00 1.00 100000000
+ 0.64 0.00 0.00 1000000
+ 0.64 0.00 0.00 8071429
+ 0.64 0.00 0.00 15142857
+ 0.64 0.00 0.00 22214286
+ 0.64 0.00 0.00 29285714
+ 0.64 0.00 0.00 36357143
+ 0.64 0.00 0.00 43428571
+ 0.64 0.00 0.00 50500000
+ 0.64 0.00 0.00 57571429
+ 0.64 0.00 0.00 64642857
+ 0.64 0.00 0.00 71714286
+ 0.64 0.00 0.00 78785714
+ 0.64 0.00 0.00 85857143
+ 0.64 0.00 0.00 92928571
+ 0.64 0.00 0.00 100000000
+ 0.64 0.00 0.07 1000000
+ 0.64 0.00 0.07 8071429
+ 0.64 0.00 0.07 15142857
+ 0.64 0.00 0.07 22214286
+ 0.64 0.00 0.07 29285714
+ 0.64 0.00 0.07 36357143
+ 0.64 0.00 0.07 43428571
+ 0.64 0.00 0.07 50500000
+ 0.64 0.00 0.07 57571429
+ 0.64 0.00 0.07 64642857
+ 0.64 0.00 0.07 71714286
+ 0.64 0.00 0.07 78785714
+ 0.64 0.00 0.07 85857143
+ 0.64 0.00 0.07 92928571
+ 0.64 0.00 0.07 100000000
+ 0.64 0.00 0.14 1000000
+ 0.64 0.00 0.14 8071429
+ 0.64 0.00 0.14 15142857
+ 0.64 0.00 0.14 22214286
+ 0.64 0.00 0.14 29285714
+ 0.64 0.00 0.14 36357143
+ 0.64 0.00 0.14 43428571
+ 0.64 0.00 0.14 50500000
+ 0.64 0.00 0.14 57571429
+ 0.64 0.00 0.14 64642857
+ 0.64 0.00 0.14 71714286
+ 0.64 0.00 0.14 78785714
+ 0.64 0.00 0.14 85857143
+ 0.64 0.00 0.14 92928571
+ 0.64 0.00 0.14 100000000
+ 0.64 0.00 0.21 1000000
+ 0.64 0.00 0.21 8071429
+ 0.64 0.00 0.21 15142857
+ 0.64 0.00 0.21 22214286
+ 0.64 0.00 0.21 29285714
+ 0.64 0.00 0.21 36357143
+ 0.64 0.00 0.21 43428571
+ 0.64 0.00 0.21 50500000
+ 0.64 0.00 0.21 57571429
+ 0.64 0.00 0.21 64642857
+ 0.64 0.00 0.21 71714286
+ 0.64 0.00 0.21 78785714
+ 0.64 0.00 0.21 85857143
+ 0.64 0.00 0.21 92928571
+ 0.64 0.00 0.21 100000000
+ 0.64 0.00 0.29 1000000
+ 0.64 0.00 0.29 8071429
+ 0.64 0.00 0.29 15142857
+ 0.64 0.00 0.29 22214286
+ 0.64 0.00 0.29 29285714
+ 0.64 0.00 0.29 36357143
+ 0.64 0.00 0.29 43428571
+ 0.64 0.00 0.29 50500000
+ 0.64 0.00 0.29 57571429
+ 0.64 0.00 0.29 64642857
+ 0.64 0.00 0.29 71714286
+ 0.64 0.00 0.29 78785714
+ 0.64 0.00 0.29 85857143
+ 0.64 0.00 0.29 92928571
+ 0.64 0.00 0.29 100000000
+ 0.64 0.00 0.36 1000000
+ 0.64 0.00 0.36 8071429
+ 0.64 0.00 0.36 15142857
+ 0.64 0.00 0.36 22214286
+ 0.64 0.00 0.36 29285714
+ 0.64 0.00 0.36 36357143
+ 0.64 0.00 0.36 43428571
+ 0.64 0.00 0.36 50500000
+ 0.64 0.00 0.36 57571429
+ 0.64 0.00 0.36 64642857
+ 0.64 0.00 0.36 71714286
+ 0.64 0.00 0.36 78785714
+ 0.64 0.00 0.36 85857143
+ 0.64 0.00 0.36 92928571
+ 0.64 0.00 0.36 100000000
+ 0.64 0.00 0.43 1000000
+ 0.64 0.00 0.43 8071429
+ 0.64 0.00 0.43 15142857
+ 0.64 0.00 0.43 22214286
+ 0.64 0.00 0.43 29285714
+ 0.64 0.00 0.43 36357143
+ 0.64 0.00 0.43 43428571
+ 0.64 0.00 0.43 50500000
+ 0.64 0.00 0.43 57571429
+ 0.64 0.00 0.43 64642857
+ 0.64 0.00 0.43 71714286
+ 0.64 0.00 0.43 78785714
+ 0.64 0.00 0.43 85857143
+ 0.64 0.00 0.43 92928571
+ 0.64 0.00 0.43 100000000
+ 0.64 0.00 0.50 1000000
+ 0.64 0.00 0.50 8071429
+ 0.64 0.00 0.50 15142857
+ 0.64 0.00 0.50 22214286
+ 0.64 0.00 0.50 29285714
+ 0.64 0.00 0.50 36357143
+ 0.64 0.00 0.50 43428571
+ 0.64 0.00 0.50 50500000
+ 0.64 0.00 0.50 57571429
+ 0.64 0.00 0.50 64642857
+ 0.64 0.00 0.50 71714286
+ 0.64 0.00 0.50 78785714
+ 0.64 0.00 0.50 85857143
+ 0.64 0.00 0.50 92928571
+ 0.64 0.00 0.50 100000000
+ 0.64 0.00 0.57 1000000
+ 0.64 0.00 0.57 8071429
+ 0.64 0.00 0.57 15142857
+ 0.64 0.00 0.57 22214286
+ 0.64 0.00 0.57 29285714
+ 0.64 0.00 0.57 36357143
+ 0.64 0.00 0.57 43428571
+ 0.64 0.00 0.57 50500000
+ 0.64 0.00 0.57 57571429
+ 0.64 0.00 0.57 64642857
+ 0.64 0.00 0.57 71714286
+ 0.64 0.00 0.57 78785714
+ 0.64 0.00 0.57 85857143
+ 0.64 0.00 0.57 92928571
+ 0.64 0.00 0.57 100000000
+ 0.64 0.00 0.64 1000000
+ 0.64 0.00 0.64 8071429
+ 0.64 0.00 0.64 15142857
+ 0.64 0.00 0.64 22214286
+ 0.64 0.00 0.64 29285714
+ 0.64 0.00 0.64 36357143
+ 0.64 0.00 0.64 43428571
+ 0.64 0.00 0.64 50500000
+ 0.64 0.00 0.64 57571429
+ 0.64 0.00 0.64 64642857
+ 0.64 0.00 0.64 71714286
+ 0.64 0.00 0.64 78785714
+ 0.64 0.00 0.64 85857143
+ 0.64 0.00 0.64 92928571
+ 0.64 0.00 0.64 100000000
+ 0.64 0.00 0.71 1000000
+ 0.64 0.00 0.71 8071429
+ 0.64 0.00 0.71 15142857
+ 0.64 0.00 0.71 22214286
+ 0.64 0.00 0.71 29285714
+ 0.64 0.00 0.71 36357143
+ 0.64 0.00 0.71 43428571
+ 0.64 0.00 0.71 50500000
+ 0.64 0.00 0.71 57571429
+ 0.64 0.00 0.71 64642857
+ 0.64 0.00 0.71 71714286
+ 0.64 0.00 0.71 78785714
+ 0.64 0.00 0.71 85857143
+ 0.64 0.00 0.71 92928571
+ 0.64 0.00 0.71 100000000
+ 0.64 0.00 0.79 1000000
+ 0.64 0.00 0.79 8071429
+ 0.64 0.00 0.79 15142857
+ 0.64 0.00 0.79 22214286
+ 0.64 0.00 0.79 29285714
+ 0.64 0.00 0.79 36357143
+ 0.64 0.00 0.79 43428571
+ 0.64 0.00 0.79 50500000
+ 0.64 0.00 0.79 57571429
+ 0.64 0.00 0.79 64642857
+ 0.64 0.00 0.79 71714286
+ 0.64 0.00 0.79 78785714
+ 0.64 0.00 0.79 85857143
+ 0.64 0.00 0.79 92928571
+ 0.64 0.00 0.79 100000000
+ 0.64 0.00 0.86 1000000
+ 0.64 0.00 0.86 8071429
+ 0.64 0.00 0.86 15142857
+ 0.64 0.00 0.86 22214286
+ 0.64 0.00 0.86 29285714
+ 0.64 0.00 0.86 36357143
+ 0.64 0.00 0.86 43428571
+ 0.64 0.00 0.86 50500000
+ 0.64 0.00 0.86 57571429
+ 0.64 0.00 0.86 64642857
+ 0.64 0.00 0.86 71714286
+ 0.64 0.00 0.86 78785714
+ 0.64 0.00 0.86 85857143
+ 0.64 0.00 0.86 92928571
+ 0.64 0.00 0.86 100000000
+ 0.64 0.00 0.93 1000000
+ 0.64 0.00 0.93 8071429
+ 0.64 0.00 0.93 15142857
+ 0.64 0.00 0.93 22214286
+ 0.64 0.00 0.93 29285714
+ 0.64 0.00 0.93 36357143
+ 0.64 0.00 0.93 43428571
+ 0.64 0.00 0.93 50500000
+ 0.64 0.00 0.93 57571429
+ 0.64 0.00 0.93 64642857
+ 0.64 0.00 0.93 71714286
+ 0.64 0.00 0.93 78785714
+ 0.64 0.00 0.93 85857143
+ 0.64 0.00 0.93 92928571
+ 0.64 0.00 0.93 100000000
+ 0.64 0.00 1.00 1000000
+ 0.64 0.00 1.00 8071429
+ 0.64 0.00 1.00 15142857
+ 0.64 0.00 1.00 22214286
+ 0.64 0.00 1.00 29285714
+ 0.64 0.00 1.00 36357143
+ 0.64 0.00 1.00 43428571
+ 0.64 0.00 1.00 50500000
+ 0.64 0.00 1.00 57571429
+ 0.64 0.00 1.00 64642857
+ 0.64 0.00 1.00 71714286
+ 0.64 0.00 1.00 78785714
+ 0.64 0.00 1.00 85857143
+ 0.64 0.00 1.00 92928571
+ 0.64 0.00 1.00 100000000
+ 0.64 0.07 0.00 1000000
+ 0.64 0.07 0.00 8071429
+ 0.64 0.07 0.00 15142857
+ 0.64 0.07 0.00 22214286
+ 0.64 0.07 0.00 29285714
+ 0.64 0.07 0.00 36357143
+ 0.64 0.07 0.00 43428571
+ 0.64 0.07 0.00 50500000
+ 0.64 0.07 0.00 57571429
+ 0.64 0.07 0.00 64642857
+ 0.64 0.07 0.00 71714286
+ 0.64 0.07 0.00 78785714
+ 0.64 0.07 0.00 85857143
+ 0.64 0.07 0.00 92928571
+ 0.64 0.07 0.00 100000000
+ 0.64 0.07 0.07 1000000
+ 0.64 0.07 0.07 8071429
+ 0.64 0.07 0.07 15142857
+ 0.64 0.07 0.07 22214286
+ 0.64 0.07 0.07 29285714
+ 0.64 0.07 0.07 36357143
+ 0.64 0.07 0.07 43428571
+ 0.64 0.07 0.07 50500000
+ 0.64 0.07 0.07 57571429
+ 0.64 0.07 0.07 64642857
+ 0.64 0.07 0.07 71714286
+ 0.64 0.07 0.07 78785714
+ 0.64 0.07 0.07 85857143
+ 0.64 0.07 0.07 92928571
+ 0.64 0.07 0.07 100000000
+ 0.64 0.07 0.14 1000000
+ 0.64 0.07 0.14 8071429
+ 0.64 0.07 0.14 15142857
+ 0.64 0.07 0.14 22214286
+ 0.64 0.07 0.14 29285714
+ 0.64 0.07 0.14 36357143
+ 0.64 0.07 0.14 43428571
+ 0.64 0.07 0.14 50500000
+ 0.64 0.07 0.14 57571429
+ 0.64 0.07 0.14 64642857
+ 0.64 0.07 0.14 71714286
+ 0.64 0.07 0.14 78785714
+ 0.64 0.07 0.14 85857143
+ 0.64 0.07 0.14 92928571
+ 0.64 0.07 0.14 100000000
+ 0.64 0.07 0.21 1000000
+ 0.64 0.07 0.21 8071429
+ 0.64 0.07 0.21 15142857
+ 0.64 0.07 0.21 22214286
+ 0.64 0.07 0.21 29285714
+ 0.64 0.07 0.21 36357143
+ 0.64 0.07 0.21 43428571
+ 0.64 0.07 0.21 50500000
+ 0.64 0.07 0.21 57571429
+ 0.64 0.07 0.21 64642857
+ 0.64 0.07 0.21 71714286
+ 0.64 0.07 0.21 78785714
+ 0.64 0.07 0.21 85857143
+ 0.64 0.07 0.21 92928571
+ 0.64 0.07 0.21 100000000
+ 0.64 0.07 0.29 1000000
+ 0.64 0.07 0.29 8071429
+ 0.64 0.07 0.29 15142857
+ 0.64 0.07 0.29 22214286
+ 0.64 0.07 0.29 29285714
+ 0.64 0.07 0.29 36357143
+ 0.64 0.07 0.29 43428571
+ 0.64 0.07 0.29 50500000
+ 0.64 0.07 0.29 57571429
+ 0.64 0.07 0.29 64642857
+ 0.64 0.07 0.29 71714286
+ 0.64 0.07 0.29 78785714
+ 0.64 0.07 0.29 85857143
+ 0.64 0.07 0.29 92928571
+ 0.64 0.07 0.29 100000000
+ 0.64 0.07 0.36 1000000
+ 0.64 0.07 0.36 8071429
+ 0.64 0.07 0.36 15142857
+ 0.64 0.07 0.36 22214286
+ 0.64 0.07 0.36 29285714
+ 0.64 0.07 0.36 36357143
+ 0.64 0.07 0.36 43428571
+ 0.64 0.07 0.36 50500000
+ 0.64 0.07 0.36 57571429
+ 0.64 0.07 0.36 64642857
+ 0.64 0.07 0.36 71714286
+ 0.64 0.07 0.36 78785714
+ 0.64 0.07 0.36 85857143
+ 0.64 0.07 0.36 92928571
+ 0.64 0.07 0.36 100000000
+ 0.64 0.07 0.43 1000000
+ 0.64 0.07 0.43 8071429
+ 0.64 0.07 0.43 15142857
+ 0.64 0.07 0.43 22214286
+ 0.64 0.07 0.43 29285714
+ 0.64 0.07 0.43 36357143
+ 0.64 0.07 0.43 43428571
+ 0.64 0.07 0.43 50500000
+ 0.64 0.07 0.43 57571429
+ 0.64 0.07 0.43 64642857
+ 0.64 0.07 0.43 71714286
+ 0.64 0.07 0.43 78785714
+ 0.64 0.07 0.43 85857143
+ 0.64 0.07 0.43 92928571
+ 0.64 0.07 0.43 100000000
+ 0.64 0.07 0.50 1000000
+ 0.64 0.07 0.50 8071429
+ 0.64 0.07 0.50 15142857
+ 0.64 0.07 0.50 22214286
+ 0.64 0.07 0.50 29285714
+ 0.64 0.07 0.50 36357143
+ 0.64 0.07 0.50 43428571
+ 0.64 0.07 0.50 50500000
+ 0.64 0.07 0.50 57571429
+ 0.64 0.07 0.50 64642857
+ 0.64 0.07 0.50 71714286
+ 0.64 0.07 0.50 78785714
+ 0.64 0.07 0.50 85857143
+ 0.64 0.07 0.50 92928571
+ 0.64 0.07 0.50 100000000
+ 0.64 0.07 0.57 1000000
+ 0.64 0.07 0.57 8071429
+ 0.64 0.07 0.57 15142857
+ 0.64 0.07 0.57 22214286
+ 0.64 0.07 0.57 29285714
+ 0.64 0.07 0.57 36357143
+ 0.64 0.07 0.57 43428571
+ 0.64 0.07 0.57 50500000
+ 0.64 0.07 0.57 57571429
+ 0.64 0.07 0.57 64642857
+ 0.64 0.07 0.57 71714286
+ 0.64 0.07 0.57 78785714
+ 0.64 0.07 0.57 85857143
+ 0.64 0.07 0.57 92928571
+ 0.64 0.07 0.57 100000000
+ 0.64 0.07 0.64 1000000
+ 0.64 0.07 0.64 8071429
+ 0.64 0.07 0.64 15142857
+ 0.64 0.07 0.64 22214286
+ 0.64 0.07 0.64 29285714
+ 0.64 0.07 0.64 36357143
+ 0.64 0.07 0.64 43428571
+ 0.64 0.07 0.64 50500000
+ 0.64 0.07 0.64 57571429
+ 0.64 0.07 0.64 64642857
+ 0.64 0.07 0.64 71714286
+ 0.64 0.07 0.64 78785714
+ 0.64 0.07 0.64 85857143
+ 0.64 0.07 0.64 92928571
+ 0.64 0.07 0.64 100000000
+ 0.64 0.07 0.71 1000000
+ 0.64 0.07 0.71 8071429
+ 0.64 0.07 0.71 15142857
+ 0.64 0.07 0.71 22214286
+ 0.64 0.07 0.71 29285714
+ 0.64 0.07 0.71 36357143
+ 0.64 0.07 0.71 43428571
+ 0.64 0.07 0.71 50500000
+ 0.64 0.07 0.71 57571429
+ 0.64 0.07 0.71 64642857
+ 0.64 0.07 0.71 71714286
+ 0.64 0.07 0.71 78785714
+ 0.64 0.07 0.71 85857143
+ 0.64 0.07 0.71 92928571
+ 0.64 0.07 0.71 100000000
+ 0.64 0.07 0.79 1000000
+ 0.64 0.07 0.79 8071429
+ 0.64 0.07 0.79 15142857
+ 0.64 0.07 0.79 22214286
+ 0.64 0.07 0.79 29285714
+ 0.64 0.07 0.79 36357143
+ 0.64 0.07 0.79 43428571
+ 0.64 0.07 0.79 50500000
+ 0.64 0.07 0.79 57571429
+ 0.64 0.07 0.79 64642857
+ 0.64 0.07 0.79 71714286
+ 0.64 0.07 0.79 78785714
+ 0.64 0.07 0.79 85857143
+ 0.64 0.07 0.79 92928571
+ 0.64 0.07 0.79 100000000
+ 0.64 0.07 0.86 1000000
+ 0.64 0.07 0.86 8071429
+ 0.64 0.07 0.86 15142857
+ 0.64 0.07 0.86 22214286
+ 0.64 0.07 0.86 29285714
+ 0.64 0.07 0.86 36357143
+ 0.64 0.07 0.86 43428571
+ 0.64 0.07 0.86 50500000
+ 0.64 0.07 0.86 57571429
+ 0.64 0.07 0.86 64642857
+ 0.64 0.07 0.86 71714286
+ 0.64 0.07 0.86 78785714
+ 0.64 0.07 0.86 85857143
+ 0.64 0.07 0.86 92928571
+ 0.64 0.07 0.86 100000000
+ 0.64 0.07 0.93 1000000
+ 0.64 0.07 0.93 8071429
+ 0.64 0.07 0.93 15142857
+ 0.64 0.07 0.93 22214286
+ 0.64 0.07 0.93 29285714
+ 0.64 0.07 0.93 36357143
+ 0.64 0.07 0.93 43428571
+ 0.64 0.07 0.93 50500000
+ 0.64 0.07 0.93 57571429
+ 0.64 0.07 0.93 64642857
+ 0.64 0.07 0.93 71714286
+ 0.64 0.07 0.93 78785714
+ 0.64 0.07 0.93 85857143
+ 0.64 0.07 0.93 92928571
+ 0.64 0.07 0.93 100000000
+ 0.64 0.07 1.00 1000000
+ 0.64 0.07 1.00 8071429
+ 0.64 0.07 1.00 15142857
+ 0.64 0.07 1.00 22214286
+ 0.64 0.07 1.00 29285714
+ 0.64 0.07 1.00 36357143
+ 0.64 0.07 1.00 43428571
+ 0.64 0.07 1.00 50500000
+ 0.64 0.07 1.00 57571429
+ 0.64 0.07 1.00 64642857
+ 0.64 0.07 1.00 71714286
+ 0.64 0.07 1.00 78785714
+ 0.64 0.07 1.00 85857143
+ 0.64 0.07 1.00 92928571
+ 0.64 0.07 1.00 100000000
+ 0.64 0.14 0.00 1000000
+ 0.64 0.14 0.00 8071429
+ 0.64 0.14 0.00 15142857
+ 0.64 0.14 0.00 22214286
+ 0.64 0.14 0.00 29285714
+ 0.64 0.14 0.00 36357143
+ 0.64 0.14 0.00 43428571
+ 0.64 0.14 0.00 50500000
+ 0.64 0.14 0.00 57571429
+ 0.64 0.14 0.00 64642857
+ 0.64 0.14 0.00 71714286
+ 0.64 0.14 0.00 78785714
+ 0.64 0.14 0.00 85857143
+ 0.64 0.14 0.00 92928571
+ 0.64 0.14 0.00 100000000
+ 0.64 0.14 0.07 1000000
+ 0.64 0.14 0.07 8071429
+ 0.64 0.14 0.07 15142857
+ 0.64 0.14 0.07 22214286
+ 0.64 0.14 0.07 29285714
+ 0.64 0.14 0.07 36357143
+ 0.64 0.14 0.07 43428571
+ 0.64 0.14 0.07 50500000
+ 0.64 0.14 0.07 57571429
+ 0.64 0.14 0.07 64642857
+ 0.64 0.14 0.07 71714286
+ 0.64 0.14 0.07 78785714
+ 0.64 0.14 0.07 85857143
+ 0.64 0.14 0.07 92928571
+ 0.64 0.14 0.07 100000000
+ 0.64 0.14 0.14 1000000
+ 0.64 0.14 0.14 8071429
+ 0.64 0.14 0.14 15142857
+ 0.64 0.14 0.14 22214286
+ 0.64 0.14 0.14 29285714
+ 0.64 0.14 0.14 36357143
+ 0.64 0.14 0.14 43428571
+ 0.64 0.14 0.14 50500000
+ 0.64 0.14 0.14 57571429
+ 0.64 0.14 0.14 64642857
+ 0.64 0.14 0.14 71714286
+ 0.64 0.14 0.14 78785714
+ 0.64 0.14 0.14 85857143
+ 0.64 0.14 0.14 92928571
+ 0.64 0.14 0.14 100000000
+ 0.64 0.14 0.21 1000000
+ 0.64 0.14 0.21 8071429
+ 0.64 0.14 0.21 15142857
+ 0.64 0.14 0.21 22214286
+ 0.64 0.14 0.21 29285714
+ 0.64 0.14 0.21 36357143
+ 0.64 0.14 0.21 43428571
+ 0.64 0.14 0.21 50500000
+ 0.64 0.14 0.21 57571429
+ 0.64 0.14 0.21 64642857
+ 0.64 0.14 0.21 71714286
+ 0.64 0.14 0.21 78785714
+ 0.64 0.14 0.21 85857143
+ 0.64 0.14 0.21 92928571
+ 0.64 0.14 0.21 100000000
+ 0.64 0.14 0.29 1000000
+ 0.64 0.14 0.29 8071429
+ 0.64 0.14 0.29 15142857
+ 0.64 0.14 0.29 22214286
+ 0.64 0.14 0.29 29285714
+ 0.64 0.14 0.29 36357143
+ 0.64 0.14 0.29 43428571
+ 0.64 0.14 0.29 50500000
+ 0.64 0.14 0.29 57571429
+ 0.64 0.14 0.29 64642857
+ 0.64 0.14 0.29 71714286
+ 0.64 0.14 0.29 78785714
+ 0.64 0.14 0.29 85857143
+ 0.64 0.14 0.29 92928571
+ 0.64 0.14 0.29 100000000
+ 0.64 0.14 0.36 1000000
+ 0.64 0.14 0.36 8071429
+ 0.64 0.14 0.36 15142857
+ 0.64 0.14 0.36 22214286
+ 0.64 0.14 0.36 29285714
+ 0.64 0.14 0.36 36357143
+ 0.64 0.14 0.36 43428571
+ 0.64 0.14 0.36 50500000
+ 0.64 0.14 0.36 57571429
+ 0.64 0.14 0.36 64642857
+ 0.64 0.14 0.36 71714286
+ 0.64 0.14 0.36 78785714
+ 0.64 0.14 0.36 85857143
+ 0.64 0.14 0.36 92928571
+ 0.64 0.14 0.36 100000000
+ 0.64 0.14 0.43 1000000
+ 0.64 0.14 0.43 8071429
+ 0.64 0.14 0.43 15142857
+ 0.64 0.14 0.43 22214286
+ 0.64 0.14 0.43 29285714
+ 0.64 0.14 0.43 36357143
+ 0.64 0.14 0.43 43428571
+ 0.64 0.14 0.43 50500000
+ 0.64 0.14 0.43 57571429
+ 0.64 0.14 0.43 64642857
+ 0.64 0.14 0.43 71714286
+ 0.64 0.14 0.43 78785714
+ 0.64 0.14 0.43 85857143
+ 0.64 0.14 0.43 92928571
+ 0.64 0.14 0.43 100000000
+ 0.64 0.14 0.50 1000000
+ 0.64 0.14 0.50 8071429
+ 0.64 0.14 0.50 15142857
+ 0.64 0.14 0.50 22214286
+ 0.64 0.14 0.50 29285714
+ 0.64 0.14 0.50 36357143
+ 0.64 0.14 0.50 43428571
+ 0.64 0.14 0.50 50500000
+ 0.64 0.14 0.50 57571429
+ 0.64 0.14 0.50 64642857
+ 0.64 0.14 0.50 71714286
+ 0.64 0.14 0.50 78785714
+ 0.64 0.14 0.50 85857143
+ 0.64 0.14 0.50 92928571
+ 0.64 0.14 0.50 100000000
+ 0.64 0.14 0.57 1000000
+ 0.64 0.14 0.57 8071429
+ 0.64 0.14 0.57 15142857
+ 0.64 0.14 0.57 22214286
+ 0.64 0.14 0.57 29285714
+ 0.64 0.14 0.57 36357143
+ 0.64 0.14 0.57 43428571
+ 0.64 0.14 0.57 50500000
+ 0.64 0.14 0.57 57571429
+ 0.64 0.14 0.57 64642857
+ 0.64 0.14 0.57 71714286
+ 0.64 0.14 0.57 78785714
+ 0.64 0.14 0.57 85857143
+ 0.64 0.14 0.57 92928571
+ 0.64 0.14 0.57 100000000
+ 0.64 0.14 0.64 1000000
+ 0.64 0.14 0.64 8071429
+ 0.64 0.14 0.64 15142857
+ 0.64 0.14 0.64 22214286
+ 0.64 0.14 0.64 29285714
+ 0.64 0.14 0.64 36357143
+ 0.64 0.14 0.64 43428571
+ 0.64 0.14 0.64 50500000
+ 0.64 0.14 0.64 57571429
+ 0.64 0.14 0.64 64642857
+ 0.64 0.14 0.64 71714286
+ 0.64 0.14 0.64 78785714
+ 0.64 0.14 0.64 85857143
+ 0.64 0.14 0.64 92928571
+ 0.64 0.14 0.64 100000000
+ 0.64 0.14 0.71 1000000
+ 0.64 0.14 0.71 8071429
+ 0.64 0.14 0.71 15142857
+ 0.64 0.14 0.71 22214286
+ 0.64 0.14 0.71 29285714
+ 0.64 0.14 0.71 36357143
+ 0.64 0.14 0.71 43428571
+ 0.64 0.14 0.71 50500000
+ 0.64 0.14 0.71 57571429
+ 0.64 0.14 0.71 64642857
+ 0.64 0.14 0.71 71714286
+ 0.64 0.14 0.71 78785714
+ 0.64 0.14 0.71 85857143
+ 0.64 0.14 0.71 92928571
+ 0.64 0.14 0.71 100000000
+ 0.64 0.14 0.79 1000000
+ 0.64 0.14 0.79 8071429
+ 0.64 0.14 0.79 15142857
+ 0.64 0.14 0.79 22214286
+ 0.64 0.14 0.79 29285714
+ 0.64 0.14 0.79 36357143
+ 0.64 0.14 0.79 43428571
+ 0.64 0.14 0.79 50500000
+ 0.64 0.14 0.79 57571429
+ 0.64 0.14 0.79 64642857
+ 0.64 0.14 0.79 71714286
+ 0.64 0.14 0.79 78785714
+ 0.64 0.14 0.79 85857143
+ 0.64 0.14 0.79 92928571
+ 0.64 0.14 0.79 100000000
+ 0.64 0.14 0.86 1000000
+ 0.64 0.14 0.86 8071429
+ 0.64 0.14 0.86 15142857
+ 0.64 0.14 0.86 22214286
+ 0.64 0.14 0.86 29285714
+ 0.64 0.14 0.86 36357143
+ 0.64 0.14 0.86 43428571
+ 0.64 0.14 0.86 50500000
+ 0.64 0.14 0.86 57571429
+ 0.64 0.14 0.86 64642857
+ 0.64 0.14 0.86 71714286
+ 0.64 0.14 0.86 78785714
+ 0.64 0.14 0.86 85857143
+ 0.64 0.14 0.86 92928571
+ 0.64 0.14 0.86 100000000
+ 0.64 0.14 0.93 1000000
+ 0.64 0.14 0.93 8071429
+ 0.64 0.14 0.93 15142857
+ 0.64 0.14 0.93 22214286
+ 0.64 0.14 0.93 29285714
+ 0.64 0.14 0.93 36357143
+ 0.64 0.14 0.93 43428571
+ 0.64 0.14 0.93 50500000
+ 0.64 0.14 0.93 57571429
+ 0.64 0.14 0.93 64642857
+ 0.64 0.14 0.93 71714286
+ 0.64 0.14 0.93 78785714
+ 0.64 0.14 0.93 85857143
+ 0.64 0.14 0.93 92928571
+ 0.64 0.14 0.93 100000000
+ 0.64 0.14 1.00 1000000
+ 0.64 0.14 1.00 8071429
+ 0.64 0.14 1.00 15142857
+ 0.64 0.14 1.00 22214286
+ 0.64 0.14 1.00 29285714
+ 0.64 0.14 1.00 36357143
+ 0.64 0.14 1.00 43428571
+ 0.64 0.14 1.00 50500000
+ 0.64 0.14 1.00 57571429
+ 0.64 0.14 1.00 64642857
+ 0.64 0.14 1.00 71714286
+ 0.64 0.14 1.00 78785714
+ 0.64 0.14 1.00 85857143
+ 0.64 0.14 1.00 92928571
+ 0.64 0.14 1.00 100000000
+ 0.64 0.21 0.00 1000000
+ 0.64 0.21 0.00 8071429
+ 0.64 0.21 0.00 15142857
+ 0.64 0.21 0.00 22214286
+ 0.64 0.21 0.00 29285714
+ 0.64 0.21 0.00 36357143
+ 0.64 0.21 0.00 43428571
+ 0.64 0.21 0.00 50500000
+ 0.64 0.21 0.00 57571429
+ 0.64 0.21 0.00 64642857
+ 0.64 0.21 0.00 71714286
+ 0.64 0.21 0.00 78785714
+ 0.64 0.21 0.00 85857143
+ 0.64 0.21 0.00 92928571
+ 0.64 0.21 0.00 100000000
+ 0.64 0.21 0.07 1000000
+ 0.64 0.21 0.07 8071429
+ 0.64 0.21 0.07 15142857
+ 0.64 0.21 0.07 22214286
+ 0.64 0.21 0.07 29285714
+ 0.64 0.21 0.07 36357143
+ 0.64 0.21 0.07 43428571
+ 0.64 0.21 0.07 50500000
+ 0.64 0.21 0.07 57571429
+ 0.64 0.21 0.07 64642857
+ 0.64 0.21 0.07 71714286
+ 0.64 0.21 0.07 78785714
+ 0.64 0.21 0.07 85857143
+ 0.64 0.21 0.07 92928571
+ 0.64 0.21 0.07 100000000
+ 0.64 0.21 0.14 1000000
+ 0.64 0.21 0.14 8071429
+ 0.64 0.21 0.14 15142857
+ 0.64 0.21 0.14 22214286
+ 0.64 0.21 0.14 29285714
+ 0.64 0.21 0.14 36357143
+ 0.64 0.21 0.14 43428571
+ 0.64 0.21 0.14 50500000
+ 0.64 0.21 0.14 57571429
+ 0.64 0.21 0.14 64642857
+ 0.64 0.21 0.14 71714286
+ 0.64 0.21 0.14 78785714
+ 0.64 0.21 0.14 85857143
+ 0.64 0.21 0.14 92928571
+ 0.64 0.21 0.14 100000000
+ 0.64 0.21 0.21 1000000
+ 0.64 0.21 0.21 8071429
+ 0.64 0.21 0.21 15142857
+ 0.64 0.21 0.21 22214286
+ 0.64 0.21 0.21 29285714
+ 0.64 0.21 0.21 36357143
+ 0.64 0.21 0.21 43428571
+ 0.64 0.21 0.21 50500000
+ 0.64 0.21 0.21 57571429
+ 0.64 0.21 0.21 64642857
+ 0.64 0.21 0.21 71714286
+ 0.64 0.21 0.21 78785714
+ 0.64 0.21 0.21 85857143
+ 0.64 0.21 0.21 92928571
+ 0.64 0.21 0.21 100000000
+ 0.64 0.21 0.29 1000000
+ 0.64 0.21 0.29 8071429
+ 0.64 0.21 0.29 15142857
+ 0.64 0.21 0.29 22214286
+ 0.64 0.21 0.29 29285714
+ 0.64 0.21 0.29 36357143
+ 0.64 0.21 0.29 43428571
+ 0.64 0.21 0.29 50500000
+ 0.64 0.21 0.29 57571429
+ 0.64 0.21 0.29 64642857
+ 0.64 0.21 0.29 71714286
+ 0.64 0.21 0.29 78785714
+ 0.64 0.21 0.29 85857143
+ 0.64 0.21 0.29 92928571
+ 0.64 0.21 0.29 100000000
+ 0.64 0.21 0.36 1000000
+ 0.64 0.21 0.36 8071429
+ 0.64 0.21 0.36 15142857
+ 0.64 0.21 0.36 22214286
+ 0.64 0.21 0.36 29285714
+ 0.64 0.21 0.36 36357143
+ 0.64 0.21 0.36 43428571
+ 0.64 0.21 0.36 50500000
+ 0.64 0.21 0.36 57571429
+ 0.64 0.21 0.36 64642857
+ 0.64 0.21 0.36 71714286
+ 0.64 0.21 0.36 78785714
+ 0.64 0.21 0.36 85857143
+ 0.64 0.21 0.36 92928571
+ 0.64 0.21 0.36 100000000
+ 0.64 0.21 0.43 1000000
+ 0.64 0.21 0.43 8071429
+ 0.64 0.21 0.43 15142857
+ 0.64 0.21 0.43 22214286
+ 0.64 0.21 0.43 29285714
+ 0.64 0.21 0.43 36357143
+ 0.64 0.21 0.43 43428571
+ 0.64 0.21 0.43 50500000
+ 0.64 0.21 0.43 57571429
+ 0.64 0.21 0.43 64642857
+ 0.64 0.21 0.43 71714286
+ 0.64 0.21 0.43 78785714
+ 0.64 0.21 0.43 85857143
+ 0.64 0.21 0.43 92928571
+ 0.64 0.21 0.43 100000000
+ 0.64 0.21 0.50 1000000
+ 0.64 0.21 0.50 8071429
+ 0.64 0.21 0.50 15142857
+ 0.64 0.21 0.50 22214286
+ 0.64 0.21 0.50 29285714
+ 0.64 0.21 0.50 36357143
+ 0.64 0.21 0.50 43428571
+ 0.64 0.21 0.50 50500000
+ 0.64 0.21 0.50 57571429
+ 0.64 0.21 0.50 64642857
+ 0.64 0.21 0.50 71714286
+ 0.64 0.21 0.50 78785714
+ 0.64 0.21 0.50 85857143
+ 0.64 0.21 0.50 92928571
+ 0.64 0.21 0.50 100000000
+ 0.64 0.21 0.57 1000000
+ 0.64 0.21 0.57 8071429
+ 0.64 0.21 0.57 15142857
+ 0.64 0.21 0.57 22214286
+ 0.64 0.21 0.57 29285714
+ 0.64 0.21 0.57 36357143
+ 0.64 0.21 0.57 43428571
+ 0.64 0.21 0.57 50500000
+ 0.64 0.21 0.57 57571429
+ 0.64 0.21 0.57 64642857
+ 0.64 0.21 0.57 71714286
+ 0.64 0.21 0.57 78785714
+ 0.64 0.21 0.57 85857143
+ 0.64 0.21 0.57 92928571
+ 0.64 0.21 0.57 100000000
+ 0.64 0.21 0.64 1000000
+ 0.64 0.21 0.64 8071429
+ 0.64 0.21 0.64 15142857
+ 0.64 0.21 0.64 22214286
+ 0.64 0.21 0.64 29285714
+ 0.64 0.21 0.64 36357143
+ 0.64 0.21 0.64 43428571
+ 0.64 0.21 0.64 50500000
+ 0.64 0.21 0.64 57571429
+ 0.64 0.21 0.64 64642857
+ 0.64 0.21 0.64 71714286
+ 0.64 0.21 0.64 78785714
+ 0.64 0.21 0.64 85857143
+ 0.64 0.21 0.64 92928571
+ 0.64 0.21 0.64 100000000
+ 0.64 0.21 0.71 1000000
+ 0.64 0.21 0.71 8071429
+ 0.64 0.21 0.71 15142857
+ 0.64 0.21 0.71 22214286
+ 0.64 0.21 0.71 29285714
+ 0.64 0.21 0.71 36357143
+ 0.64 0.21 0.71 43428571
+ 0.64 0.21 0.71 50500000
+ 0.64 0.21 0.71 57571429
+ 0.64 0.21 0.71 64642857
+ 0.64 0.21 0.71 71714286
+ 0.64 0.21 0.71 78785714
+ 0.64 0.21 0.71 85857143
+ 0.64 0.21 0.71 92928571
+ 0.64 0.21 0.71 100000000
+ 0.64 0.21 0.79 1000000
+ 0.64 0.21 0.79 8071429
+ 0.64 0.21 0.79 15142857
+ 0.64 0.21 0.79 22214286
+ 0.64 0.21 0.79 29285714
+ 0.64 0.21 0.79 36357143
+ 0.64 0.21 0.79 43428571
+ 0.64 0.21 0.79 50500000
+ 0.64 0.21 0.79 57571429
+ 0.64 0.21 0.79 64642857
+ 0.64 0.21 0.79 71714286
+ 0.64 0.21 0.79 78785714
+ 0.64 0.21 0.79 85857143
+ 0.64 0.21 0.79 92928571
+ 0.64 0.21 0.79 100000000
+ 0.64 0.21 0.86 1000000
+ 0.64 0.21 0.86 8071429
+ 0.64 0.21 0.86 15142857
+ 0.64 0.21 0.86 22214286
+ 0.64 0.21 0.86 29285714
+ 0.64 0.21 0.86 36357143
+ 0.64 0.21 0.86 43428571
+ 0.64 0.21 0.86 50500000
+ 0.64 0.21 0.86 57571429
+ 0.64 0.21 0.86 64642857
+ 0.64 0.21 0.86 71714286
+ 0.64 0.21 0.86 78785714
+ 0.64 0.21 0.86 85857143
+ 0.64 0.21 0.86 92928571
+ 0.64 0.21 0.86 100000000
+ 0.64 0.21 0.93 1000000
+ 0.64 0.21 0.93 8071429
+ 0.64 0.21 0.93 15142857
+ 0.64 0.21 0.93 22214286
+ 0.64 0.21 0.93 29285714
+ 0.64 0.21 0.93 36357143
+ 0.64 0.21 0.93 43428571
+ 0.64 0.21 0.93 50500000
+ 0.64 0.21 0.93 57571429
+ 0.64 0.21 0.93 64642857
+ 0.64 0.21 0.93 71714286
+ 0.64 0.21 0.93 78785714
+ 0.64 0.21 0.93 85857143
+ 0.64 0.21 0.93 92928571
+ 0.64 0.21 0.93 100000000
+ 0.64 0.21 1.00 1000000
+ 0.64 0.21 1.00 8071429
+ 0.64 0.21 1.00 15142857
+ 0.64 0.21 1.00 22214286
+ 0.64 0.21 1.00 29285714
+ 0.64 0.21 1.00 36357143
+ 0.64 0.21 1.00 43428571
+ 0.64 0.21 1.00 50500000
+ 0.64 0.21 1.00 57571429
+ 0.64 0.21 1.00 64642857
+ 0.64 0.21 1.00 71714286
+ 0.64 0.21 1.00 78785714
+ 0.64 0.21 1.00 85857143
+ 0.64 0.21 1.00 92928571
+ 0.64 0.21 1.00 100000000
+ 0.64 0.29 0.00 1000000
+ 0.64 0.29 0.00 8071429
+ 0.64 0.29 0.00 15142857
+ 0.64 0.29 0.00 22214286
+ 0.64 0.29 0.00 29285714
+ 0.64 0.29 0.00 36357143
+ 0.64 0.29 0.00 43428571
+ 0.64 0.29 0.00 50500000
+ 0.64 0.29 0.00 57571429
+ 0.64 0.29 0.00 64642857
+ 0.64 0.29 0.00 71714286
+ 0.64 0.29 0.00 78785714
+ 0.64 0.29 0.00 85857143
+ 0.64 0.29 0.00 92928571
+ 0.64 0.29 0.00 100000000
+ 0.64 0.29 0.07 1000000
+ 0.64 0.29 0.07 8071429
+ 0.64 0.29 0.07 15142857
+ 0.64 0.29 0.07 22214286
+ 0.64 0.29 0.07 29285714
+ 0.64 0.29 0.07 36357143
+ 0.64 0.29 0.07 43428571
+ 0.64 0.29 0.07 50500000
+ 0.64 0.29 0.07 57571429
+ 0.64 0.29 0.07 64642857
+ 0.64 0.29 0.07 71714286
+ 0.64 0.29 0.07 78785714
+ 0.64 0.29 0.07 85857143
+ 0.64 0.29 0.07 92928571
+ 0.64 0.29 0.07 100000000
+ 0.64 0.29 0.14 1000000
+ 0.64 0.29 0.14 8071429
+ 0.64 0.29 0.14 15142857
+ 0.64 0.29 0.14 22214286
+ 0.64 0.29 0.14 29285714
+ 0.64 0.29 0.14 36357143
+ 0.64 0.29 0.14 43428571
+ 0.64 0.29 0.14 50500000
+ 0.64 0.29 0.14 57571429
+ 0.64 0.29 0.14 64642857
+ 0.64 0.29 0.14 71714286
+ 0.64 0.29 0.14 78785714
+ 0.64 0.29 0.14 85857143
+ 0.64 0.29 0.14 92928571
+ 0.64 0.29 0.14 100000000
+ 0.64 0.29 0.21 1000000
+ 0.64 0.29 0.21 8071429
+ 0.64 0.29 0.21 15142857
+ 0.64 0.29 0.21 22214286
+ 0.64 0.29 0.21 29285714
+ 0.64 0.29 0.21 36357143
+ 0.64 0.29 0.21 43428571
+ 0.64 0.29 0.21 50500000
+ 0.64 0.29 0.21 57571429
+ 0.64 0.29 0.21 64642857
+ 0.64 0.29 0.21 71714286
+ 0.64 0.29 0.21 78785714
+ 0.64 0.29 0.21 85857143
+ 0.64 0.29 0.21 92928571
+ 0.64 0.29 0.21 100000000
+ 0.64 0.29 0.29 1000000
+ 0.64 0.29 0.29 8071429
+ 0.64 0.29 0.29 15142857
+ 0.64 0.29 0.29 22214286
+ 0.64 0.29 0.29 29285714
+ 0.64 0.29 0.29 36357143
+ 0.64 0.29 0.29 43428571
+ 0.64 0.29 0.29 50500000
+ 0.64 0.29 0.29 57571429
+ 0.64 0.29 0.29 64642857
+ 0.64 0.29 0.29 71714286
+ 0.64 0.29 0.29 78785714
+ 0.64 0.29 0.29 85857143
+ 0.64 0.29 0.29 92928571
+ 0.64 0.29 0.29 100000000
+ 0.64 0.29 0.36 1000000
+ 0.64 0.29 0.36 8071429
+ 0.64 0.29 0.36 15142857
+ 0.64 0.29 0.36 22214286
+ 0.64 0.29 0.36 29285714
+ 0.64 0.29 0.36 36357143
+ 0.64 0.29 0.36 43428571
+ 0.64 0.29 0.36 50500000
+ 0.64 0.29 0.36 57571429
+ 0.64 0.29 0.36 64642857
+ 0.64 0.29 0.36 71714286
+ 0.64 0.29 0.36 78785714
+ 0.64 0.29 0.36 85857143
+ 0.64 0.29 0.36 92928571
+ 0.64 0.29 0.36 100000000
+ 0.64 0.29 0.43 1000000
+ 0.64 0.29 0.43 8071429
+ 0.64 0.29 0.43 15142857
+ 0.64 0.29 0.43 22214286
+ 0.64 0.29 0.43 29285714
+ 0.64 0.29 0.43 36357143
+ 0.64 0.29 0.43 43428571
+ 0.64 0.29 0.43 50500000
+ 0.64 0.29 0.43 57571429
+ 0.64 0.29 0.43 64642857
+ 0.64 0.29 0.43 71714286
+ 0.64 0.29 0.43 78785714
+ 0.64 0.29 0.43 85857143
+ 0.64 0.29 0.43 92928571
+ 0.64 0.29 0.43 100000000
+ 0.64 0.29 0.50 1000000
+ 0.64 0.29 0.50 8071429
+ 0.64 0.29 0.50 15142857
+ 0.64 0.29 0.50 22214286
+ 0.64 0.29 0.50 29285714
+ 0.64 0.29 0.50 36357143
+ 0.64 0.29 0.50 43428571
+ 0.64 0.29 0.50 50500000
+ 0.64 0.29 0.50 57571429
+ 0.64 0.29 0.50 64642857
+ 0.64 0.29 0.50 71714286
+ 0.64 0.29 0.50 78785714
+ 0.64 0.29 0.50 85857143
+ 0.64 0.29 0.50 92928571
+ 0.64 0.29 0.50 100000000
+ 0.64 0.29 0.57 1000000
+ 0.64 0.29 0.57 8071429
+ 0.64 0.29 0.57 15142857
+ 0.64 0.29 0.57 22214286
+ 0.64 0.29 0.57 29285714
+ 0.64 0.29 0.57 36357143
+ 0.64 0.29 0.57 43428571
+ 0.64 0.29 0.57 50500000
+ 0.64 0.29 0.57 57571429
+ 0.64 0.29 0.57 64642857
+ 0.64 0.29 0.57 71714286
+ 0.64 0.29 0.57 78785714
+ 0.64 0.29 0.57 85857143
+ 0.64 0.29 0.57 92928571
+ 0.64 0.29 0.57 100000000
+ 0.64 0.29 0.64 1000000
+ 0.64 0.29 0.64 8071429
+ 0.64 0.29 0.64 15142857
+ 0.64 0.29 0.64 22214286
+ 0.64 0.29 0.64 29285714
+ 0.64 0.29 0.64 36357143
+ 0.64 0.29 0.64 43428571
+ 0.64 0.29 0.64 50500000
+ 0.64 0.29 0.64 57571429
+ 0.64 0.29 0.64 64642857
+ 0.64 0.29 0.64 71714286
+ 0.64 0.29 0.64 78785714
+ 0.64 0.29 0.64 85857143
+ 0.64 0.29 0.64 92928571
+ 0.64 0.29 0.64 100000000
+ 0.64 0.29 0.71 1000000
+ 0.64 0.29 0.71 8071429
+ 0.64 0.29 0.71 15142857
+ 0.64 0.29 0.71 22214286
+ 0.64 0.29 0.71 29285714
+ 0.64 0.29 0.71 36357143
+ 0.64 0.29 0.71 43428571
+ 0.64 0.29 0.71 50500000
+ 0.64 0.29 0.71 57571429
+ 0.64 0.29 0.71 64642857
+ 0.64 0.29 0.71 71714286
+ 0.64 0.29 0.71 78785714
+ 0.64 0.29 0.71 85857143
+ 0.64 0.29 0.71 92928571
+ 0.64 0.29 0.71 100000000
+ 0.64 0.29 0.79 1000000
+ 0.64 0.29 0.79 8071429
+ 0.64 0.29 0.79 15142857
+ 0.64 0.29 0.79 22214286
+ 0.64 0.29 0.79 29285714
+ 0.64 0.29 0.79 36357143
+ 0.64 0.29 0.79 43428571
+ 0.64 0.29 0.79 50500000
+ 0.64 0.29 0.79 57571429
+ 0.64 0.29 0.79 64642857
+ 0.64 0.29 0.79 71714286
+ 0.64 0.29 0.79 78785714
+ 0.64 0.29 0.79 85857143
+ 0.64 0.29 0.79 92928571
+ 0.64 0.29 0.79 100000000
+ 0.64 0.29 0.86 1000000
+ 0.64 0.29 0.86 8071429
+ 0.64 0.29 0.86 15142857
+ 0.64 0.29 0.86 22214286
+ 0.64 0.29 0.86 29285714
+ 0.64 0.29 0.86 36357143
+ 0.64 0.29 0.86 43428571
+ 0.64 0.29 0.86 50500000
+ 0.64 0.29 0.86 57571429
+ 0.64 0.29 0.86 64642857
+ 0.64 0.29 0.86 71714286
+ 0.64 0.29 0.86 78785714
+ 0.64 0.29 0.86 85857143
+ 0.64 0.29 0.86 92928571
+ 0.64 0.29 0.86 100000000
+ 0.64 0.29 0.93 1000000
+ 0.64 0.29 0.93 8071429
+ 0.64 0.29 0.93 15142857
+ 0.64 0.29 0.93 22214286
+ 0.64 0.29 0.93 29285714
+ 0.64 0.29 0.93 36357143
+ 0.64 0.29 0.93 43428571
+ 0.64 0.29 0.93 50500000
+ 0.64 0.29 0.93 57571429
+ 0.64 0.29 0.93 64642857
+ 0.64 0.29 0.93 71714286
+ 0.64 0.29 0.93 78785714
+ 0.64 0.29 0.93 85857143
+ 0.64 0.29 0.93 92928571
+ 0.64 0.29 0.93 100000000
+ 0.64 0.29 1.00 1000000
+ 0.64 0.29 1.00 8071429
+ 0.64 0.29 1.00 15142857
+ 0.64 0.29 1.00 22214286
+ 0.64 0.29 1.00 29285714
+ 0.64 0.29 1.00 36357143
+ 0.64 0.29 1.00 43428571
+ 0.64 0.29 1.00 50500000
+ 0.64 0.29 1.00 57571429
+ 0.64 0.29 1.00 64642857
+ 0.64 0.29 1.00 71714286
+ 0.64 0.29 1.00 78785714
+ 0.64 0.29 1.00 85857143
+ 0.64 0.29 1.00 92928571
+ 0.64 0.29 1.00 100000000
+ 0.64 0.36 0.00 1000000
+ 0.64 0.36 0.00 8071429
+ 0.64 0.36 0.00 15142857
+ 0.64 0.36 0.00 22214286
+ 0.64 0.36 0.00 29285714
+ 0.64 0.36 0.00 36357143
+ 0.64 0.36 0.00 43428571
+ 0.64 0.36 0.00 50500000
+ 0.64 0.36 0.00 57571429
+ 0.64 0.36 0.00 64642857
+ 0.64 0.36 0.00 71714286
+ 0.64 0.36 0.00 78785714
+ 0.64 0.36 0.00 85857143
+ 0.64 0.36 0.00 92928571
+ 0.64 0.36 0.00 100000000
+ 0.64 0.36 0.07 1000000
+ 0.64 0.36 0.07 8071429
+ 0.64 0.36 0.07 15142857
+ 0.64 0.36 0.07 22214286
+ 0.64 0.36 0.07 29285714
+ 0.64 0.36 0.07 36357143
+ 0.64 0.36 0.07 43428571
+ 0.64 0.36 0.07 50500000
+ 0.64 0.36 0.07 57571429
+ 0.64 0.36 0.07 64642857
+ 0.64 0.36 0.07 71714286
+ 0.64 0.36 0.07 78785714
+ 0.64 0.36 0.07 85857143
+ 0.64 0.36 0.07 92928571
+ 0.64 0.36 0.07 100000000
+ 0.64 0.36 0.14 1000000
+ 0.64 0.36 0.14 8071429
+ 0.64 0.36 0.14 15142857
+ 0.64 0.36 0.14 22214286
+ 0.64 0.36 0.14 29285714
+ 0.64 0.36 0.14 36357143
+ 0.64 0.36 0.14 43428571
+ 0.64 0.36 0.14 50500000
+ 0.64 0.36 0.14 57571429
+ 0.64 0.36 0.14 64642857
+ 0.64 0.36 0.14 71714286
+ 0.64 0.36 0.14 78785714
+ 0.64 0.36 0.14 85857143
+ 0.64 0.36 0.14 92928571
+ 0.64 0.36 0.14 100000000
+ 0.64 0.36 0.21 1000000
+ 0.64 0.36 0.21 8071429
+ 0.64 0.36 0.21 15142857
+ 0.64 0.36 0.21 22214286
+ 0.64 0.36 0.21 29285714
+ 0.64 0.36 0.21 36357143
+ 0.64 0.36 0.21 43428571
+ 0.64 0.36 0.21 50500000
+ 0.64 0.36 0.21 57571429
+ 0.64 0.36 0.21 64642857
+ 0.64 0.36 0.21 71714286
+ 0.64 0.36 0.21 78785714
+ 0.64 0.36 0.21 85857143
+ 0.64 0.36 0.21 92928571
+ 0.64 0.36 0.21 100000000
+ 0.64 0.36 0.29 1000000
+ 0.64 0.36 0.29 8071429
+ 0.64 0.36 0.29 15142857
+ 0.64 0.36 0.29 22214286
+ 0.64 0.36 0.29 29285714
+ 0.64 0.36 0.29 36357143
+ 0.64 0.36 0.29 43428571
+ 0.64 0.36 0.29 50500000
+ 0.64 0.36 0.29 57571429
+ 0.64 0.36 0.29 64642857
+ 0.64 0.36 0.29 71714286
+ 0.64 0.36 0.29 78785714
+ 0.64 0.36 0.29 85857143
+ 0.64 0.36 0.29 92928571
+ 0.64 0.36 0.29 100000000
+ 0.64 0.36 0.36 1000000
+ 0.64 0.36 0.36 8071429
+ 0.64 0.36 0.36 15142857
+ 0.64 0.36 0.36 22214286
+ 0.64 0.36 0.36 29285714
+ 0.64 0.36 0.36 36357143
+ 0.64 0.36 0.36 43428571
+ 0.64 0.36 0.36 50500000
+ 0.64 0.36 0.36 57571429
+ 0.64 0.36 0.36 64642857
+ 0.64 0.36 0.36 71714286
+ 0.64 0.36 0.36 78785714
+ 0.64 0.36 0.36 85857143
+ 0.64 0.36 0.36 92928571
+ 0.64 0.36 0.36 100000000
+ 0.64 0.36 0.43 1000000
+ 0.64 0.36 0.43 8071429
+ 0.64 0.36 0.43 15142857
+ 0.64 0.36 0.43 22214286
+ 0.64 0.36 0.43 29285714
+ 0.64 0.36 0.43 36357143
+ 0.64 0.36 0.43 43428571
+ 0.64 0.36 0.43 50500000
+ 0.64 0.36 0.43 57571429
+ 0.64 0.36 0.43 64642857
+ 0.64 0.36 0.43 71714286
+ 0.64 0.36 0.43 78785714
+ 0.64 0.36 0.43 85857143
+ 0.64 0.36 0.43 92928571
+ 0.64 0.36 0.43 100000000
+ 0.64 0.36 0.50 1000000
+ 0.64 0.36 0.50 8071429
+ 0.64 0.36 0.50 15142857
+ 0.64 0.36 0.50 22214286
+ 0.64 0.36 0.50 29285714
+ 0.64 0.36 0.50 36357143
+ 0.64 0.36 0.50 43428571
+ 0.64 0.36 0.50 50500000
+ 0.64 0.36 0.50 57571429
+ 0.64 0.36 0.50 64642857
+ 0.64 0.36 0.50 71714286
+ 0.64 0.36 0.50 78785714
+ 0.64 0.36 0.50 85857143
+ 0.64 0.36 0.50 92928571
+ 0.64 0.36 0.50 100000000
+ 0.64 0.36 0.57 1000000
+ 0.64 0.36 0.57 8071429
+ 0.64 0.36 0.57 15142857
+ 0.64 0.36 0.57 22214286
+ 0.64 0.36 0.57 29285714
+ 0.64 0.36 0.57 36357143
+ 0.64 0.36 0.57 43428571
+ 0.64 0.36 0.57 50500000
+ 0.64 0.36 0.57 57571429
+ 0.64 0.36 0.57 64642857
+ 0.64 0.36 0.57 71714286
+ 0.64 0.36 0.57 78785714
+ 0.64 0.36 0.57 85857143
+ 0.64 0.36 0.57 92928571
+ 0.64 0.36 0.57 100000000
+ 0.64 0.36 0.64 1000000
+ 0.64 0.36 0.64 8071429
+ 0.64 0.36 0.64 15142857
+ 0.64 0.36 0.64 22214286
+ 0.64 0.36 0.64 29285714
+ 0.64 0.36 0.64 36357143
+ 0.64 0.36 0.64 43428571
+ 0.64 0.36 0.64 50500000
+ 0.64 0.36 0.64 57571429
+ 0.64 0.36 0.64 64642857
+ 0.64 0.36 0.64 71714286
+ 0.64 0.36 0.64 78785714
+ 0.64 0.36 0.64 85857143
+ 0.64 0.36 0.64 92928571
+ 0.64 0.36 0.64 100000000
+ 0.64 0.36 0.71 1000000
+ 0.64 0.36 0.71 8071429
+ 0.64 0.36 0.71 15142857
+ 0.64 0.36 0.71 22214286
+ 0.64 0.36 0.71 29285714
+ 0.64 0.36 0.71 36357143
+ 0.64 0.36 0.71 43428571
+ 0.64 0.36 0.71 50500000
+ 0.64 0.36 0.71 57571429
+ 0.64 0.36 0.71 64642857
+ 0.64 0.36 0.71 71714286
+ 0.64 0.36 0.71 78785714
+ 0.64 0.36 0.71 85857143
+ 0.64 0.36 0.71 92928571
+ 0.64 0.36 0.71 100000000
+ 0.64 0.36 0.79 1000000
+ 0.64 0.36 0.79 8071429
+ 0.64 0.36 0.79 15142857
+ 0.64 0.36 0.79 22214286
+ 0.64 0.36 0.79 29285714
+ 0.64 0.36 0.79 36357143
+ 0.64 0.36 0.79 43428571
+ 0.64 0.36 0.79 50500000
+ 0.64 0.36 0.79 57571429
+ 0.64 0.36 0.79 64642857
+ 0.64 0.36 0.79 71714286
+ 0.64 0.36 0.79 78785714
+ 0.64 0.36 0.79 85857143
+ 0.64 0.36 0.79 92928571
+ 0.64 0.36 0.79 100000000
+ 0.64 0.36 0.86 1000000
+ 0.64 0.36 0.86 8071429
+ 0.64 0.36 0.86 15142857
+ 0.64 0.36 0.86 22214286
+ 0.64 0.36 0.86 29285714
+ 0.64 0.36 0.86 36357143
+ 0.64 0.36 0.86 43428571
+ 0.64 0.36 0.86 50500000
+ 0.64 0.36 0.86 57571429
+ 0.64 0.36 0.86 64642857
+ 0.64 0.36 0.86 71714286
+ 0.64 0.36 0.86 78785714
+ 0.64 0.36 0.86 85857143
+ 0.64 0.36 0.86 92928571
+ 0.64 0.36 0.86 100000000
+ 0.64 0.36 0.93 1000000
+ 0.64 0.36 0.93 8071429
+ 0.64 0.36 0.93 15142857
+ 0.64 0.36 0.93 22214286
+ 0.64 0.36 0.93 29285714
+ 0.64 0.36 0.93 36357143
+ 0.64 0.36 0.93 43428571
+ 0.64 0.36 0.93 50500000
+ 0.64 0.36 0.93 57571429
+ 0.64 0.36 0.93 64642857
+ 0.64 0.36 0.93 71714286
+ 0.64 0.36 0.93 78785714
+ 0.64 0.36 0.93 85857143
+ 0.64 0.36 0.93 92928571
+ 0.64 0.36 0.93 100000000
+ 0.64 0.36 1.00 1000000
+ 0.64 0.36 1.00 8071429
+ 0.64 0.36 1.00 15142857
+ 0.64 0.36 1.00 22214286
+ 0.64 0.36 1.00 29285714
+ 0.64 0.36 1.00 36357143
+ 0.64 0.36 1.00 43428571
+ 0.64 0.36 1.00 50500000
+ 0.64 0.36 1.00 57571429
+ 0.64 0.36 1.00 64642857
+ 0.64 0.36 1.00 71714286
+ 0.64 0.36 1.00 78785714
+ 0.64 0.36 1.00 85857143
+ 0.64 0.36 1.00 92928571
+ 0.64 0.36 1.00 100000000
+ 0.64 0.43 0.00 1000000
+ 0.64 0.43 0.00 8071429
+ 0.64 0.43 0.00 15142857
+ 0.64 0.43 0.00 22214286
+ 0.64 0.43 0.00 29285714
+ 0.64 0.43 0.00 36357143
+ 0.64 0.43 0.00 43428571
+ 0.64 0.43 0.00 50500000
+ 0.64 0.43 0.00 57571429
+ 0.64 0.43 0.00 64642857
+ 0.64 0.43 0.00 71714286
+ 0.64 0.43 0.00 78785714
+ 0.64 0.43 0.00 85857143
+ 0.64 0.43 0.00 92928571
+ 0.64 0.43 0.00 100000000
+ 0.64 0.43 0.07 1000000
+ 0.64 0.43 0.07 8071429
+ 0.64 0.43 0.07 15142857
+ 0.64 0.43 0.07 22214286
+ 0.64 0.43 0.07 29285714
+ 0.64 0.43 0.07 36357143
+ 0.64 0.43 0.07 43428571
+ 0.64 0.43 0.07 50500000
+ 0.64 0.43 0.07 57571429
+ 0.64 0.43 0.07 64642857
+ 0.64 0.43 0.07 71714286
+ 0.64 0.43 0.07 78785714
+ 0.64 0.43 0.07 85857143
+ 0.64 0.43 0.07 92928571
+ 0.64 0.43 0.07 100000000
+ 0.64 0.43 0.14 1000000
+ 0.64 0.43 0.14 8071429
+ 0.64 0.43 0.14 15142857
+ 0.64 0.43 0.14 22214286
+ 0.64 0.43 0.14 29285714
+ 0.64 0.43 0.14 36357143
+ 0.64 0.43 0.14 43428571
+ 0.64 0.43 0.14 50500000
+ 0.64 0.43 0.14 57571429
+ 0.64 0.43 0.14 64642857
+ 0.64 0.43 0.14 71714286
+ 0.64 0.43 0.14 78785714
+ 0.64 0.43 0.14 85857143
+ 0.64 0.43 0.14 92928571
+ 0.64 0.43 0.14 100000000
+ 0.64 0.43 0.21 1000000
+ 0.64 0.43 0.21 8071429
+ 0.64 0.43 0.21 15142857
+ 0.64 0.43 0.21 22214286
+ 0.64 0.43 0.21 29285714
+ 0.64 0.43 0.21 36357143
+ 0.64 0.43 0.21 43428571
+ 0.64 0.43 0.21 50500000
+ 0.64 0.43 0.21 57571429
+ 0.64 0.43 0.21 64642857
+ 0.64 0.43 0.21 71714286
+ 0.64 0.43 0.21 78785714
+ 0.64 0.43 0.21 85857143
+ 0.64 0.43 0.21 92928571
+ 0.64 0.43 0.21 100000000
+ 0.64 0.43 0.29 1000000
+ 0.64 0.43 0.29 8071429
+ 0.64 0.43 0.29 15142857
+ 0.64 0.43 0.29 22214286
+ 0.64 0.43 0.29 29285714
+ 0.64 0.43 0.29 36357143
+ 0.64 0.43 0.29 43428571
+ 0.64 0.43 0.29 50500000
+ 0.64 0.43 0.29 57571429
+ 0.64 0.43 0.29 64642857
+ 0.64 0.43 0.29 71714286
+ 0.64 0.43 0.29 78785714
+ 0.64 0.43 0.29 85857143
+ 0.64 0.43 0.29 92928571
+ 0.64 0.43 0.29 100000000
+ 0.64 0.43 0.36 1000000
+ 0.64 0.43 0.36 8071429
+ 0.64 0.43 0.36 15142857
+ 0.64 0.43 0.36 22214286
+ 0.64 0.43 0.36 29285714
+ 0.64 0.43 0.36 36357143
+ 0.64 0.43 0.36 43428571
+ 0.64 0.43 0.36 50500000
+ 0.64 0.43 0.36 57571429
+ 0.64 0.43 0.36 64642857
+ 0.64 0.43 0.36 71714286
+ 0.64 0.43 0.36 78785714
+ 0.64 0.43 0.36 85857143
+ 0.64 0.43 0.36 92928571
+ 0.64 0.43 0.36 100000000
+ 0.64 0.43 0.43 1000000
+ 0.64 0.43 0.43 8071429
+ 0.64 0.43 0.43 15142857
+ 0.64 0.43 0.43 22214286
+ 0.64 0.43 0.43 29285714
+ 0.64 0.43 0.43 36357143
+ 0.64 0.43 0.43 43428571
+ 0.64 0.43 0.43 50500000
+ 0.64 0.43 0.43 57571429
+ 0.64 0.43 0.43 64642857
+ 0.64 0.43 0.43 71714286
+ 0.64 0.43 0.43 78785714
+ 0.64 0.43 0.43 85857143
+ 0.64 0.43 0.43 92928571
+ 0.64 0.43 0.43 100000000
+ 0.64 0.43 0.50 1000000
+ 0.64 0.43 0.50 8071429
+ 0.64 0.43 0.50 15142857
+ 0.64 0.43 0.50 22214286
+ 0.64 0.43 0.50 29285714
+ 0.64 0.43 0.50 36357143
+ 0.64 0.43 0.50 43428571
+ 0.64 0.43 0.50 50500000
+ 0.64 0.43 0.50 57571429
+ 0.64 0.43 0.50 64642857
+ 0.64 0.43 0.50 71714286
+ 0.64 0.43 0.50 78785714
+ 0.64 0.43 0.50 85857143
+ 0.64 0.43 0.50 92928571
+ 0.64 0.43 0.50 100000000
+ 0.64 0.43 0.57 1000000
+ 0.64 0.43 0.57 8071429
+ 0.64 0.43 0.57 15142857
+ 0.64 0.43 0.57 22214286
+ 0.64 0.43 0.57 29285714
+ 0.64 0.43 0.57 36357143
+ 0.64 0.43 0.57 43428571
+ 0.64 0.43 0.57 50500000
+ 0.64 0.43 0.57 57571429
+ 0.64 0.43 0.57 64642857
+ 0.64 0.43 0.57 71714286
+ 0.64 0.43 0.57 78785714
+ 0.64 0.43 0.57 85857143
+ 0.64 0.43 0.57 92928571
+ 0.64 0.43 0.57 100000000
+ 0.64 0.43 0.64 1000000
+ 0.64 0.43 0.64 8071429
+ 0.64 0.43 0.64 15142857
+ 0.64 0.43 0.64 22214286
+ 0.64 0.43 0.64 29285714
+ 0.64 0.43 0.64 36357143
+ 0.64 0.43 0.64 43428571
+ 0.64 0.43 0.64 50500000
+ 0.64 0.43 0.64 57571429
+ 0.64 0.43 0.64 64642857
+ 0.64 0.43 0.64 71714286
+ 0.64 0.43 0.64 78785714
+ 0.64 0.43 0.64 85857143
+ 0.64 0.43 0.64 92928571
+ 0.64 0.43 0.64 100000000
+ 0.64 0.43 0.71 1000000
+ 0.64 0.43 0.71 8071429
+ 0.64 0.43 0.71 15142857
+ 0.64 0.43 0.71 22214286
+ 0.64 0.43 0.71 29285714
+ 0.64 0.43 0.71 36357143
+ 0.64 0.43 0.71 43428571
+ 0.64 0.43 0.71 50500000
+ 0.64 0.43 0.71 57571429
+ 0.64 0.43 0.71 64642857
+ 0.64 0.43 0.71 71714286
+ 0.64 0.43 0.71 78785714
+ 0.64 0.43 0.71 85857143
+ 0.64 0.43 0.71 92928571
+ 0.64 0.43 0.71 100000000
+ 0.64 0.43 0.79 1000000
+ 0.64 0.43 0.79 8071429
+ 0.64 0.43 0.79 15142857
+ 0.64 0.43 0.79 22214286
+ 0.64 0.43 0.79 29285714
+ 0.64 0.43 0.79 36357143
+ 0.64 0.43 0.79 43428571
+ 0.64 0.43 0.79 50500000
+ 0.64 0.43 0.79 57571429
+ 0.64 0.43 0.79 64642857
+ 0.64 0.43 0.79 71714286
+ 0.64 0.43 0.79 78785714
+ 0.64 0.43 0.79 85857143
+ 0.64 0.43 0.79 92928571
+ 0.64 0.43 0.79 100000000
+ 0.64 0.43 0.86 1000000
+ 0.64 0.43 0.86 8071429
+ 0.64 0.43 0.86 15142857
+ 0.64 0.43 0.86 22214286
+ 0.64 0.43 0.86 29285714
+ 0.64 0.43 0.86 36357143
+ 0.64 0.43 0.86 43428571
+ 0.64 0.43 0.86 50500000
+ 0.64 0.43 0.86 57571429
+ 0.64 0.43 0.86 64642857
+ 0.64 0.43 0.86 71714286
+ 0.64 0.43 0.86 78785714
+ 0.64 0.43 0.86 85857143
+ 0.64 0.43 0.86 92928571
+ 0.64 0.43 0.86 100000000
+ 0.64 0.43 0.93 1000000
+ 0.64 0.43 0.93 8071429
+ 0.64 0.43 0.93 15142857
+ 0.64 0.43 0.93 22214286
+ 0.64 0.43 0.93 29285714
+ 0.64 0.43 0.93 36357143
+ 0.64 0.43 0.93 43428571
+ 0.64 0.43 0.93 50500000
+ 0.64 0.43 0.93 57571429
+ 0.64 0.43 0.93 64642857
+ 0.64 0.43 0.93 71714286
+ 0.64 0.43 0.93 78785714
+ 0.64 0.43 0.93 85857143
+ 0.64 0.43 0.93 92928571
+ 0.64 0.43 0.93 100000000
+ 0.64 0.43 1.00 1000000
+ 0.64 0.43 1.00 8071429
+ 0.64 0.43 1.00 15142857
+ 0.64 0.43 1.00 22214286
+ 0.64 0.43 1.00 29285714
+ 0.64 0.43 1.00 36357143
+ 0.64 0.43 1.00 43428571
+ 0.64 0.43 1.00 50500000
+ 0.64 0.43 1.00 57571429
+ 0.64 0.43 1.00 64642857
+ 0.64 0.43 1.00 71714286
+ 0.64 0.43 1.00 78785714
+ 0.64 0.43 1.00 85857143
+ 0.64 0.43 1.00 92928571
+ 0.64 0.43 1.00 100000000
+ 0.64 0.50 0.00 1000000
+ 0.64 0.50 0.00 8071429
+ 0.64 0.50 0.00 15142857
+ 0.64 0.50 0.00 22214286
+ 0.64 0.50 0.00 29285714
+ 0.64 0.50 0.00 36357143
+ 0.64 0.50 0.00 43428571
+ 0.64 0.50 0.00 50500000
+ 0.64 0.50 0.00 57571429
+ 0.64 0.50 0.00 64642857
+ 0.64 0.50 0.00 71714286
+ 0.64 0.50 0.00 78785714
+ 0.64 0.50 0.00 85857143
+ 0.64 0.50 0.00 92928571
+ 0.64 0.50 0.00 100000000
+ 0.64 0.50 0.07 1000000
+ 0.64 0.50 0.07 8071429
+ 0.64 0.50 0.07 15142857
+ 0.64 0.50 0.07 22214286
+ 0.64 0.50 0.07 29285714
+ 0.64 0.50 0.07 36357143
+ 0.64 0.50 0.07 43428571
+ 0.64 0.50 0.07 50500000
+ 0.64 0.50 0.07 57571429
+ 0.64 0.50 0.07 64642857
+ 0.64 0.50 0.07 71714286
+ 0.64 0.50 0.07 78785714
+ 0.64 0.50 0.07 85857143
+ 0.64 0.50 0.07 92928571
+ 0.64 0.50 0.07 100000000
+ 0.64 0.50 0.14 1000000
+ 0.64 0.50 0.14 8071429
+ 0.64 0.50 0.14 15142857
+ 0.64 0.50 0.14 22214286
+ 0.64 0.50 0.14 29285714
+ 0.64 0.50 0.14 36357143
+ 0.64 0.50 0.14 43428571
+ 0.64 0.50 0.14 50500000
+ 0.64 0.50 0.14 57571429
+ 0.64 0.50 0.14 64642857
+ 0.64 0.50 0.14 71714286
+ 0.64 0.50 0.14 78785714
+ 0.64 0.50 0.14 85857143
+ 0.64 0.50 0.14 92928571
+ 0.64 0.50 0.14 100000000
+ 0.64 0.50 0.21 1000000
+ 0.64 0.50 0.21 8071429
+ 0.64 0.50 0.21 15142857
+ 0.64 0.50 0.21 22214286
+ 0.64 0.50 0.21 29285714
+ 0.64 0.50 0.21 36357143
+ 0.64 0.50 0.21 43428571
+ 0.64 0.50 0.21 50500000
+ 0.64 0.50 0.21 57571429
+ 0.64 0.50 0.21 64642857
+ 0.64 0.50 0.21 71714286
+ 0.64 0.50 0.21 78785714
+ 0.64 0.50 0.21 85857143
+ 0.64 0.50 0.21 92928571
+ 0.64 0.50 0.21 100000000
+ 0.64 0.50 0.29 1000000
+ 0.64 0.50 0.29 8071429
+ 0.64 0.50 0.29 15142857
+ 0.64 0.50 0.29 22214286
+ 0.64 0.50 0.29 29285714
+ 0.64 0.50 0.29 36357143
+ 0.64 0.50 0.29 43428571
+ 0.64 0.50 0.29 50500000
+ 0.64 0.50 0.29 57571429
+ 0.64 0.50 0.29 64642857
+ 0.64 0.50 0.29 71714286
+ 0.64 0.50 0.29 78785714
+ 0.64 0.50 0.29 85857143
+ 0.64 0.50 0.29 92928571
+ 0.64 0.50 0.29 100000000
+ 0.64 0.50 0.36 1000000
+ 0.64 0.50 0.36 8071429
+ 0.64 0.50 0.36 15142857
+ 0.64 0.50 0.36 22214286
+ 0.64 0.50 0.36 29285714
+ 0.64 0.50 0.36 36357143
+ 0.64 0.50 0.36 43428571
+ 0.64 0.50 0.36 50500000
+ 0.64 0.50 0.36 57571429
+ 0.64 0.50 0.36 64642857
+ 0.64 0.50 0.36 71714286
+ 0.64 0.50 0.36 78785714
+ 0.64 0.50 0.36 85857143
+ 0.64 0.50 0.36 92928571
+ 0.64 0.50 0.36 100000000
+ 0.64 0.50 0.43 1000000
+ 0.64 0.50 0.43 8071429
+ 0.64 0.50 0.43 15142857
+ 0.64 0.50 0.43 22214286
+ 0.64 0.50 0.43 29285714
+ 0.64 0.50 0.43 36357143
+ 0.64 0.50 0.43 43428571
+ 0.64 0.50 0.43 50500000
+ 0.64 0.50 0.43 57571429
+ 0.64 0.50 0.43 64642857
+ 0.64 0.50 0.43 71714286
+ 0.64 0.50 0.43 78785714
+ 0.64 0.50 0.43 85857143
+ 0.64 0.50 0.43 92928571
+ 0.64 0.50 0.43 100000000
+ 0.64 0.50 0.50 1000000
+ 0.64 0.50 0.50 8071429
+ 0.64 0.50 0.50 15142857
+ 0.64 0.50 0.50 22214286
+ 0.64 0.50 0.50 29285714
+ 0.64 0.50 0.50 36357143
+ 0.64 0.50 0.50 43428571
+ 0.64 0.50 0.50 50500000
+ 0.64 0.50 0.50 57571429
+ 0.64 0.50 0.50 64642857
+ 0.64 0.50 0.50 71714286
+ 0.64 0.50 0.50 78785714
+ 0.64 0.50 0.50 85857143
+ 0.64 0.50 0.50 92928571
+ 0.64 0.50 0.50 100000000
+ 0.64 0.50 0.57 1000000
+ 0.64 0.50 0.57 8071429
+ 0.64 0.50 0.57 15142857
+ 0.64 0.50 0.57 22214286
+ 0.64 0.50 0.57 29285714
+ 0.64 0.50 0.57 36357143
+ 0.64 0.50 0.57 43428571
+ 0.64 0.50 0.57 50500000
+ 0.64 0.50 0.57 57571429
+ 0.64 0.50 0.57 64642857
+ 0.64 0.50 0.57 71714286
+ 0.64 0.50 0.57 78785714
+ 0.64 0.50 0.57 85857143
+ 0.64 0.50 0.57 92928571
+ 0.64 0.50 0.57 100000000
+ 0.64 0.50 0.64 1000000
+ 0.64 0.50 0.64 8071429
+ 0.64 0.50 0.64 15142857
+ 0.64 0.50 0.64 22214286
+ 0.64 0.50 0.64 29285714
+ 0.64 0.50 0.64 36357143
+ 0.64 0.50 0.64 43428571
+ 0.64 0.50 0.64 50500000
+ 0.64 0.50 0.64 57571429
+ 0.64 0.50 0.64 64642857
+ 0.64 0.50 0.64 71714286
+ 0.64 0.50 0.64 78785714
+ 0.64 0.50 0.64 85857143
+ 0.64 0.50 0.64 92928571
+ 0.64 0.50 0.64 100000000
+ 0.64 0.50 0.71 1000000
+ 0.64 0.50 0.71 8071429
+ 0.64 0.50 0.71 15142857
+ 0.64 0.50 0.71 22214286
+ 0.64 0.50 0.71 29285714
+ 0.64 0.50 0.71 36357143
+ 0.64 0.50 0.71 43428571
+ 0.64 0.50 0.71 50500000
+ 0.64 0.50 0.71 57571429
+ 0.64 0.50 0.71 64642857
+ 0.64 0.50 0.71 71714286
+ 0.64 0.50 0.71 78785714
+ 0.64 0.50 0.71 85857143
+ 0.64 0.50 0.71 92928571
+ 0.64 0.50 0.71 100000000
+ 0.64 0.50 0.79 1000000
+ 0.64 0.50 0.79 8071429
+ 0.64 0.50 0.79 15142857
+ 0.64 0.50 0.79 22214286
+ 0.64 0.50 0.79 29285714
+ 0.64 0.50 0.79 36357143
+ 0.64 0.50 0.79 43428571
+ 0.64 0.50 0.79 50500000
+ 0.64 0.50 0.79 57571429
+ 0.64 0.50 0.79 64642857
+ 0.64 0.50 0.79 71714286
+ 0.64 0.50 0.79 78785714
+ 0.64 0.50 0.79 85857143
+ 0.64 0.50 0.79 92928571
+ 0.64 0.50 0.79 100000000
+ 0.64 0.50 0.86 1000000
+ 0.64 0.50 0.86 8071429
+ 0.64 0.50 0.86 15142857
+ 0.64 0.50 0.86 22214286
+ 0.64 0.50 0.86 29285714
+ 0.64 0.50 0.86 36357143
+ 0.64 0.50 0.86 43428571
+ 0.64 0.50 0.86 50500000
+ 0.64 0.50 0.86 57571429
+ 0.64 0.50 0.86 64642857
+ 0.64 0.50 0.86 71714286
+ 0.64 0.50 0.86 78785714
+ 0.64 0.50 0.86 85857143
+ 0.64 0.50 0.86 92928571
+ 0.64 0.50 0.86 100000000
+ 0.64 0.50 0.93 1000000
+ 0.64 0.50 0.93 8071429
+ 0.64 0.50 0.93 15142857
+ 0.64 0.50 0.93 22214286
+ 0.64 0.50 0.93 29285714
+ 0.64 0.50 0.93 36357143
+ 0.64 0.50 0.93 43428571
+ 0.64 0.50 0.93 50500000
+ 0.64 0.50 0.93 57571429
+ 0.64 0.50 0.93 64642857
+ 0.64 0.50 0.93 71714286
+ 0.64 0.50 0.93 78785714
+ 0.64 0.50 0.93 85857143
+ 0.64 0.50 0.93 92928571
+ 0.64 0.50 0.93 100000000
+ 0.64 0.50 1.00 1000000
+ 0.64 0.50 1.00 8071429
+ 0.64 0.50 1.00 15142857
+ 0.64 0.50 1.00 22214286
+ 0.64 0.50 1.00 29285714
+ 0.64 0.50 1.00 36357143
+ 0.64 0.50 1.00 43428571
+ 0.64 0.50 1.00 50500000
+ 0.64 0.50 1.00 57571429
+ 0.64 0.50 1.00 64642857
+ 0.64 0.50 1.00 71714286
+ 0.64 0.50 1.00 78785714
+ 0.64 0.50 1.00 85857143
+ 0.64 0.50 1.00 92928571
+ 0.64 0.50 1.00 100000000
+ 0.64 0.57 0.00 1000000
+ 0.64 0.57 0.00 8071429
+ 0.64 0.57 0.00 15142857
+ 0.64 0.57 0.00 22214286
+ 0.64 0.57 0.00 29285714
+ 0.64 0.57 0.00 36357143
+ 0.64 0.57 0.00 43428571
+ 0.64 0.57 0.00 50500000
+ 0.64 0.57 0.00 57571429
+ 0.64 0.57 0.00 64642857
+ 0.64 0.57 0.00 71714286
+ 0.64 0.57 0.00 78785714
+ 0.64 0.57 0.00 85857143
+ 0.64 0.57 0.00 92928571
+ 0.64 0.57 0.00 100000000
+ 0.64 0.57 0.07 1000000
+ 0.64 0.57 0.07 8071429
+ 0.64 0.57 0.07 15142857
+ 0.64 0.57 0.07 22214286
+ 0.64 0.57 0.07 29285714
+ 0.64 0.57 0.07 36357143
+ 0.64 0.57 0.07 43428571
+ 0.64 0.57 0.07 50500000
+ 0.64 0.57 0.07 57571429
+ 0.64 0.57 0.07 64642857
+ 0.64 0.57 0.07 71714286
+ 0.64 0.57 0.07 78785714
+ 0.64 0.57 0.07 85857143
+ 0.64 0.57 0.07 92928571
+ 0.64 0.57 0.07 100000000
+ 0.64 0.57 0.14 1000000
+ 0.64 0.57 0.14 8071429
+ 0.64 0.57 0.14 15142857
+ 0.64 0.57 0.14 22214286
+ 0.64 0.57 0.14 29285714
+ 0.64 0.57 0.14 36357143
+ 0.64 0.57 0.14 43428571
+ 0.64 0.57 0.14 50500000
+ 0.64 0.57 0.14 57571429
+ 0.64 0.57 0.14 64642857
+ 0.64 0.57 0.14 71714286
+ 0.64 0.57 0.14 78785714
+ 0.64 0.57 0.14 85857143
+ 0.64 0.57 0.14 92928571
+ 0.64 0.57 0.14 100000000
+ 0.64 0.57 0.21 1000000
+ 0.64 0.57 0.21 8071429
+ 0.64 0.57 0.21 15142857
+ 0.64 0.57 0.21 22214286
+ 0.64 0.57 0.21 29285714
+ 0.64 0.57 0.21 36357143
+ 0.64 0.57 0.21 43428571
+ 0.64 0.57 0.21 50500000
+ 0.64 0.57 0.21 57571429
+ 0.64 0.57 0.21 64642857
+ 0.64 0.57 0.21 71714286
+ 0.64 0.57 0.21 78785714
+ 0.64 0.57 0.21 85857143
+ 0.64 0.57 0.21 92928571
+ 0.64 0.57 0.21 100000000
+ 0.64 0.57 0.29 1000000
+ 0.64 0.57 0.29 8071429
+ 0.64 0.57 0.29 15142857
+ 0.64 0.57 0.29 22214286
+ 0.64 0.57 0.29 29285714
+ 0.64 0.57 0.29 36357143
+ 0.64 0.57 0.29 43428571
+ 0.64 0.57 0.29 50500000
+ 0.64 0.57 0.29 57571429
+ 0.64 0.57 0.29 64642857
+ 0.64 0.57 0.29 71714286
+ 0.64 0.57 0.29 78785714
+ 0.64 0.57 0.29 85857143
+ 0.64 0.57 0.29 92928571
+ 0.64 0.57 0.29 100000000
+ 0.64 0.57 0.36 1000000
+ 0.64 0.57 0.36 8071429
+ 0.64 0.57 0.36 15142857
+ 0.64 0.57 0.36 22214286
+ 0.64 0.57 0.36 29285714
+ 0.64 0.57 0.36 36357143
+ 0.64 0.57 0.36 43428571
+ 0.64 0.57 0.36 50500000
+ 0.64 0.57 0.36 57571429
+ 0.64 0.57 0.36 64642857
+ 0.64 0.57 0.36 71714286
+ 0.64 0.57 0.36 78785714
+ 0.64 0.57 0.36 85857143
+ 0.64 0.57 0.36 92928571
+ 0.64 0.57 0.36 100000000
+ 0.64 0.57 0.43 1000000
+ 0.64 0.57 0.43 8071429
+ 0.64 0.57 0.43 15142857
+ 0.64 0.57 0.43 22214286
+ 0.64 0.57 0.43 29285714
+ 0.64 0.57 0.43 36357143
+ 0.64 0.57 0.43 43428571
+ 0.64 0.57 0.43 50500000
+ 0.64 0.57 0.43 57571429
+ 0.64 0.57 0.43 64642857
+ 0.64 0.57 0.43 71714286
+ 0.64 0.57 0.43 78785714
+ 0.64 0.57 0.43 85857143
+ 0.64 0.57 0.43 92928571
+ 0.64 0.57 0.43 100000000
+ 0.64 0.57 0.50 1000000
+ 0.64 0.57 0.50 8071429
+ 0.64 0.57 0.50 15142857
+ 0.64 0.57 0.50 22214286
+ 0.64 0.57 0.50 29285714
+ 0.64 0.57 0.50 36357143
+ 0.64 0.57 0.50 43428571
+ 0.64 0.57 0.50 50500000
+ 0.64 0.57 0.50 57571429
+ 0.64 0.57 0.50 64642857
+ 0.64 0.57 0.50 71714286
+ 0.64 0.57 0.50 78785714
+ 0.64 0.57 0.50 85857143
+ 0.64 0.57 0.50 92928571
+ 0.64 0.57 0.50 100000000
+ 0.64 0.57 0.57 1000000
+ 0.64 0.57 0.57 8071429
+ 0.64 0.57 0.57 15142857
+ 0.64 0.57 0.57 22214286
+ 0.64 0.57 0.57 29285714
+ 0.64 0.57 0.57 36357143
+ 0.64 0.57 0.57 43428571
+ 0.64 0.57 0.57 50500000
+ 0.64 0.57 0.57 57571429
+ 0.64 0.57 0.57 64642857
+ 0.64 0.57 0.57 71714286
+ 0.64 0.57 0.57 78785714
+ 0.64 0.57 0.57 85857143
+ 0.64 0.57 0.57 92928571
+ 0.64 0.57 0.57 100000000
+ 0.64 0.57 0.64 1000000
+ 0.64 0.57 0.64 8071429
+ 0.64 0.57 0.64 15142857
+ 0.64 0.57 0.64 22214286
+ 0.64 0.57 0.64 29285714
+ 0.64 0.57 0.64 36357143
+ 0.64 0.57 0.64 43428571
+ 0.64 0.57 0.64 50500000
+ 0.64 0.57 0.64 57571429
+ 0.64 0.57 0.64 64642857
+ 0.64 0.57 0.64 71714286
+ 0.64 0.57 0.64 78785714
+ 0.64 0.57 0.64 85857143
+ 0.64 0.57 0.64 92928571
+ 0.64 0.57 0.64 100000000
+ 0.64 0.57 0.71 1000000
+ 0.64 0.57 0.71 8071429
+ 0.64 0.57 0.71 15142857
+ 0.64 0.57 0.71 22214286
+ 0.64 0.57 0.71 29285714
+ 0.64 0.57 0.71 36357143
+ 0.64 0.57 0.71 43428571
+ 0.64 0.57 0.71 50500000
+ 0.64 0.57 0.71 57571429
+ 0.64 0.57 0.71 64642857
+ 0.64 0.57 0.71 71714286
+ 0.64 0.57 0.71 78785714
+ 0.64 0.57 0.71 85857143
+ 0.64 0.57 0.71 92928571
+ 0.64 0.57 0.71 100000000
+ 0.64 0.57 0.79 1000000
+ 0.64 0.57 0.79 8071429
+ 0.64 0.57 0.79 15142857
+ 0.64 0.57 0.79 22214286
+ 0.64 0.57 0.79 29285714
+ 0.64 0.57 0.79 36357143
+ 0.64 0.57 0.79 43428571
+ 0.64 0.57 0.79 50500000
+ 0.64 0.57 0.79 57571429
+ 0.64 0.57 0.79 64642857
+ 0.64 0.57 0.79 71714286
+ 0.64 0.57 0.79 78785714
+ 0.64 0.57 0.79 85857143
+ 0.64 0.57 0.79 92928571
+ 0.64 0.57 0.79 100000000
+ 0.64 0.57 0.86 1000000
+ 0.64 0.57 0.86 8071429
+ 0.64 0.57 0.86 15142857
+ 0.64 0.57 0.86 22214286
+ 0.64 0.57 0.86 29285714
+ 0.64 0.57 0.86 36357143
+ 0.64 0.57 0.86 43428571
+ 0.64 0.57 0.86 50500000
+ 0.64 0.57 0.86 57571429
+ 0.64 0.57 0.86 64642857
+ 0.64 0.57 0.86 71714286
+ 0.64 0.57 0.86 78785714
+ 0.64 0.57 0.86 85857143
+ 0.64 0.57 0.86 92928571
+ 0.64 0.57 0.86 100000000
+ 0.64 0.57 0.93 1000000
+ 0.64 0.57 0.93 8071429
+ 0.64 0.57 0.93 15142857
+ 0.64 0.57 0.93 22214286
+ 0.64 0.57 0.93 29285714
+ 0.64 0.57 0.93 36357143
+ 0.64 0.57 0.93 43428571
+ 0.64 0.57 0.93 50500000
+ 0.64 0.57 0.93 57571429
+ 0.64 0.57 0.93 64642857
+ 0.64 0.57 0.93 71714286
+ 0.64 0.57 0.93 78785714
+ 0.64 0.57 0.93 85857143
+ 0.64 0.57 0.93 92928571
+ 0.64 0.57 0.93 100000000
+ 0.64 0.57 1.00 1000000
+ 0.64 0.57 1.00 8071429
+ 0.64 0.57 1.00 15142857
+ 0.64 0.57 1.00 22214286
+ 0.64 0.57 1.00 29285714
+ 0.64 0.57 1.00 36357143
+ 0.64 0.57 1.00 43428571
+ 0.64 0.57 1.00 50500000
+ 0.64 0.57 1.00 57571429
+ 0.64 0.57 1.00 64642857
+ 0.64 0.57 1.00 71714286
+ 0.64 0.57 1.00 78785714
+ 0.64 0.57 1.00 85857143
+ 0.64 0.57 1.00 92928571
+ 0.64 0.57 1.00 100000000
+ 0.64 0.64 0.00 1000000
+ 0.64 0.64 0.00 8071429
+ 0.64 0.64 0.00 15142857
+ 0.64 0.64 0.00 22214286
+ 0.64 0.64 0.00 29285714
+ 0.64 0.64 0.00 36357143
+ 0.64 0.64 0.00 43428571
+ 0.64 0.64 0.00 50500000
+ 0.64 0.64 0.00 57571429
+ 0.64 0.64 0.00 64642857
+ 0.64 0.64 0.00 71714286
+ 0.64 0.64 0.00 78785714
+ 0.64 0.64 0.00 85857143
+ 0.64 0.64 0.00 92928571
+ 0.64 0.64 0.00 100000000
+ 0.64 0.64 0.07 1000000
+ 0.64 0.64 0.07 8071429
+ 0.64 0.64 0.07 15142857
+ 0.64 0.64 0.07 22214286
+ 0.64 0.64 0.07 29285714
+ 0.64 0.64 0.07 36357143
+ 0.64 0.64 0.07 43428571
+ 0.64 0.64 0.07 50500000
+ 0.64 0.64 0.07 57571429
+ 0.64 0.64 0.07 64642857
+ 0.64 0.64 0.07 71714286
+ 0.64 0.64 0.07 78785714
+ 0.64 0.64 0.07 85857143
+ 0.64 0.64 0.07 92928571
+ 0.64 0.64 0.07 100000000
+ 0.64 0.64 0.14 1000000
+ 0.64 0.64 0.14 8071429
+ 0.64 0.64 0.14 15142857
+ 0.64 0.64 0.14 22214286
+ 0.64 0.64 0.14 29285714
+ 0.64 0.64 0.14 36357143
+ 0.64 0.64 0.14 43428571
+ 0.64 0.64 0.14 50500000
+ 0.64 0.64 0.14 57571429
+ 0.64 0.64 0.14 64642857
+ 0.64 0.64 0.14 71714286
+ 0.64 0.64 0.14 78785714
+ 0.64 0.64 0.14 85857143
+ 0.64 0.64 0.14 92928571
+ 0.64 0.64 0.14 100000000
+ 0.64 0.64 0.21 1000000
+ 0.64 0.64 0.21 8071429
+ 0.64 0.64 0.21 15142857
+ 0.64 0.64 0.21 22214286
+ 0.64 0.64 0.21 29285714
+ 0.64 0.64 0.21 36357143
+ 0.64 0.64 0.21 43428571
+ 0.64 0.64 0.21 50500000
+ 0.64 0.64 0.21 57571429
+ 0.64 0.64 0.21 64642857
+ 0.64 0.64 0.21 71714286
+ 0.64 0.64 0.21 78785714
+ 0.64 0.64 0.21 85857143
+ 0.64 0.64 0.21 92928571
+ 0.64 0.64 0.21 100000000
+ 0.64 0.64 0.29 1000000
+ 0.64 0.64 0.29 8071429
+ 0.64 0.64 0.29 15142857
+ 0.64 0.64 0.29 22214286
+ 0.64 0.64 0.29 29285714
+ 0.64 0.64 0.29 36357143
+ 0.64 0.64 0.29 43428571
+ 0.64 0.64 0.29 50500000
+ 0.64 0.64 0.29 57571429
+ 0.64 0.64 0.29 64642857
+ 0.64 0.64 0.29 71714286
+ 0.64 0.64 0.29 78785714
+ 0.64 0.64 0.29 85857143
+ 0.64 0.64 0.29 92928571
+ 0.64 0.64 0.29 100000000
+ 0.64 0.64 0.36 1000000
+ 0.64 0.64 0.36 8071429
+ 0.64 0.64 0.36 15142857
+ 0.64 0.64 0.36 22214286
+ 0.64 0.64 0.36 29285714
+ 0.64 0.64 0.36 36357143
+ 0.64 0.64 0.36 43428571
+ 0.64 0.64 0.36 50500000
+ 0.64 0.64 0.36 57571429
+ 0.64 0.64 0.36 64642857
+ 0.64 0.64 0.36 71714286
+ 0.64 0.64 0.36 78785714
+ 0.64 0.64 0.36 85857143
+ 0.64 0.64 0.36 92928571
+ 0.64 0.64 0.36 100000000
+ 0.64 0.64 0.43 1000000
+ 0.64 0.64 0.43 8071429
+ 0.64 0.64 0.43 15142857
+ 0.64 0.64 0.43 22214286
+ 0.64 0.64 0.43 29285714
+ 0.64 0.64 0.43 36357143
+ 0.64 0.64 0.43 43428571
+ 0.64 0.64 0.43 50500000
+ 0.64 0.64 0.43 57571429
+ 0.64 0.64 0.43 64642857
+ 0.64 0.64 0.43 71714286
+ 0.64 0.64 0.43 78785714
+ 0.64 0.64 0.43 85857143
+ 0.64 0.64 0.43 92928571
+ 0.64 0.64 0.43 100000000
+ 0.64 0.64 0.50 1000000
+ 0.64 0.64 0.50 8071429
+ 0.64 0.64 0.50 15142857
+ 0.64 0.64 0.50 22214286
+ 0.64 0.64 0.50 29285714
+ 0.64 0.64 0.50 36357143
+ 0.64 0.64 0.50 43428571
+ 0.64 0.64 0.50 50500000
+ 0.64 0.64 0.50 57571429
+ 0.64 0.64 0.50 64642857
+ 0.64 0.64 0.50 71714286
+ 0.64 0.64 0.50 78785714
+ 0.64 0.64 0.50 85857143
+ 0.64 0.64 0.50 92928571
+ 0.64 0.64 0.50 100000000
+ 0.64 0.64 0.57 1000000
+ 0.64 0.64 0.57 8071429
+ 0.64 0.64 0.57 15142857
+ 0.64 0.64 0.57 22214286
+ 0.64 0.64 0.57 29285714
+ 0.64 0.64 0.57 36357143
+ 0.64 0.64 0.57 43428571
+ 0.64 0.64 0.57 50500000
+ 0.64 0.64 0.57 57571429
+ 0.64 0.64 0.57 64642857
+ 0.64 0.64 0.57 71714286
+ 0.64 0.64 0.57 78785714
+ 0.64 0.64 0.57 85857143
+ 0.64 0.64 0.57 92928571
+ 0.64 0.64 0.57 100000000
+ 0.64 0.64 0.64 1000000
+ 0.64 0.64 0.64 8071429
+ 0.64 0.64 0.64 15142857
+ 0.64 0.64 0.64 22214286
+ 0.64 0.64 0.64 29285714
+ 0.64 0.64 0.64 36357143
+ 0.64 0.64 0.64 43428571
+ 0.64 0.64 0.64 50500000
+ 0.64 0.64 0.64 57571429
+ 0.64 0.64 0.64 64642857
+ 0.64 0.64 0.64 71714286
+ 0.64 0.64 0.64 78785714
+ 0.64 0.64 0.64 85857143
+ 0.64 0.64 0.64 92928571
+ 0.64 0.64 0.64 100000000
+ 0.64 0.64 0.71 1000000
+ 0.64 0.64 0.71 8071429
+ 0.64 0.64 0.71 15142857
+ 0.64 0.64 0.71 22214286
+ 0.64 0.64 0.71 29285714
+ 0.64 0.64 0.71 36357143
+ 0.64 0.64 0.71 43428571
+ 0.64 0.64 0.71 50500000
+ 0.64 0.64 0.71 57571429
+ 0.64 0.64 0.71 64642857
+ 0.64 0.64 0.71 71714286
+ 0.64 0.64 0.71 78785714
+ 0.64 0.64 0.71 85857143
+ 0.64 0.64 0.71 92928571
+ 0.64 0.64 0.71 100000000
+ 0.64 0.64 0.79 1000000
+ 0.64 0.64 0.79 8071429
+ 0.64 0.64 0.79 15142857
+ 0.64 0.64 0.79 22214286
+ 0.64 0.64 0.79 29285714
+ 0.64 0.64 0.79 36357143
+ 0.64 0.64 0.79 43428571
+ 0.64 0.64 0.79 50500000
+ 0.64 0.64 0.79 57571429
+ 0.64 0.64 0.79 64642857
+ 0.64 0.64 0.79 71714286
+ 0.64 0.64 0.79 78785714
+ 0.64 0.64 0.79 85857143
+ 0.64 0.64 0.79 92928571
+ 0.64 0.64 0.79 100000000
+ 0.64 0.64 0.86 1000000
+ 0.64 0.64 0.86 8071429
+ 0.64 0.64 0.86 15142857
+ 0.64 0.64 0.86 22214286
+ 0.64 0.64 0.86 29285714
+ 0.64 0.64 0.86 36357143
+ 0.64 0.64 0.86 43428571
+ 0.64 0.64 0.86 50500000
+ 0.64 0.64 0.86 57571429
+ 0.64 0.64 0.86 64642857
+ 0.64 0.64 0.86 71714286
+ 0.64 0.64 0.86 78785714
+ 0.64 0.64 0.86 85857143
+ 0.64 0.64 0.86 92928571
+ 0.64 0.64 0.86 100000000
+ 0.64 0.64 0.93 1000000
+ 0.64 0.64 0.93 8071429
+ 0.64 0.64 0.93 15142857
+ 0.64 0.64 0.93 22214286
+ 0.64 0.64 0.93 29285714
+ 0.64 0.64 0.93 36357143
+ 0.64 0.64 0.93 43428571
+ 0.64 0.64 0.93 50500000
+ 0.64 0.64 0.93 57571429
+ 0.64 0.64 0.93 64642857
+ 0.64 0.64 0.93 71714286
+ 0.64 0.64 0.93 78785714
+ 0.64 0.64 0.93 85857143
+ 0.64 0.64 0.93 92928571
+ 0.64 0.64 0.93 100000000
+ 0.64 0.64 1.00 1000000
+ 0.64 0.64 1.00 8071429
+ 0.64 0.64 1.00 15142857
+ 0.64 0.64 1.00 22214286
+ 0.64 0.64 1.00 29285714
+ 0.64 0.64 1.00 36357143
+ 0.64 0.64 1.00 43428571
+ 0.64 0.64 1.00 50500000
+ 0.64 0.64 1.00 57571429
+ 0.64 0.64 1.00 64642857
+ 0.64 0.64 1.00 71714286
+ 0.64 0.64 1.00 78785714
+ 0.64 0.64 1.00 85857143
+ 0.64 0.64 1.00 92928571
+ 0.64 0.64 1.00 100000000
+ 0.64 0.71 0.00 1000000
+ 0.64 0.71 0.00 8071429
+ 0.64 0.71 0.00 15142857
+ 0.64 0.71 0.00 22214286
+ 0.64 0.71 0.00 29285714
+ 0.64 0.71 0.00 36357143
+ 0.64 0.71 0.00 43428571
+ 0.64 0.71 0.00 50500000
+ 0.64 0.71 0.00 57571429
+ 0.64 0.71 0.00 64642857
+ 0.64 0.71 0.00 71714286
+ 0.64 0.71 0.00 78785714
+ 0.64 0.71 0.00 85857143
+ 0.64 0.71 0.00 92928571
+ 0.64 0.71 0.00 100000000
+ 0.64 0.71 0.07 1000000
+ 0.64 0.71 0.07 8071429
+ 0.64 0.71 0.07 15142857
+ 0.64 0.71 0.07 22214286
+ 0.64 0.71 0.07 29285714
+ 0.64 0.71 0.07 36357143
+ 0.64 0.71 0.07 43428571
+ 0.64 0.71 0.07 50500000
+ 0.64 0.71 0.07 57571429
+ 0.64 0.71 0.07 64642857
+ 0.64 0.71 0.07 71714286
+ 0.64 0.71 0.07 78785714
+ 0.64 0.71 0.07 85857143
+ 0.64 0.71 0.07 92928571
+ 0.64 0.71 0.07 100000000
+ 0.64 0.71 0.14 1000000
+ 0.64 0.71 0.14 8071429
+ 0.64 0.71 0.14 15142857
+ 0.64 0.71 0.14 22214286
+ 0.64 0.71 0.14 29285714
+ 0.64 0.71 0.14 36357143
+ 0.64 0.71 0.14 43428571
+ 0.64 0.71 0.14 50500000
+ 0.64 0.71 0.14 57571429
+ 0.64 0.71 0.14 64642857
+ 0.64 0.71 0.14 71714286
+ 0.64 0.71 0.14 78785714
+ 0.64 0.71 0.14 85857143
+ 0.64 0.71 0.14 92928571
+ 0.64 0.71 0.14 100000000
+ 0.64 0.71 0.21 1000000
+ 0.64 0.71 0.21 8071429
+ 0.64 0.71 0.21 15142857
+ 0.64 0.71 0.21 22214286
+ 0.64 0.71 0.21 29285714
+ 0.64 0.71 0.21 36357143
+ 0.64 0.71 0.21 43428571
+ 0.64 0.71 0.21 50500000
+ 0.64 0.71 0.21 57571429
+ 0.64 0.71 0.21 64642857
+ 0.64 0.71 0.21 71714286
+ 0.64 0.71 0.21 78785714
+ 0.64 0.71 0.21 85857143
+ 0.64 0.71 0.21 92928571
+ 0.64 0.71 0.21 100000000
+ 0.64 0.71 0.29 1000000
+ 0.64 0.71 0.29 8071429
+ 0.64 0.71 0.29 15142857
+ 0.64 0.71 0.29 22214286
+ 0.64 0.71 0.29 29285714
+ 0.64 0.71 0.29 36357143
+ 0.64 0.71 0.29 43428571
+ 0.64 0.71 0.29 50500000
+ 0.64 0.71 0.29 57571429
+ 0.64 0.71 0.29 64642857
+ 0.64 0.71 0.29 71714286
+ 0.64 0.71 0.29 78785714
+ 0.64 0.71 0.29 85857143
+ 0.64 0.71 0.29 92928571
+ 0.64 0.71 0.29 100000000
+ 0.64 0.71 0.36 1000000
+ 0.64 0.71 0.36 8071429
+ 0.64 0.71 0.36 15142857
+ 0.64 0.71 0.36 22214286
+ 0.64 0.71 0.36 29285714
+ 0.64 0.71 0.36 36357143
+ 0.64 0.71 0.36 43428571
+ 0.64 0.71 0.36 50500000
+ 0.64 0.71 0.36 57571429
+ 0.64 0.71 0.36 64642857
+ 0.64 0.71 0.36 71714286
+ 0.64 0.71 0.36 78785714
+ 0.64 0.71 0.36 85857143
+ 0.64 0.71 0.36 92928571
+ 0.64 0.71 0.36 100000000
+ 0.64 0.71 0.43 1000000
+ 0.64 0.71 0.43 8071429
+ 0.64 0.71 0.43 15142857
+ 0.64 0.71 0.43 22214286
+ 0.64 0.71 0.43 29285714
+ 0.64 0.71 0.43 36357143
+ 0.64 0.71 0.43 43428571
+ 0.64 0.71 0.43 50500000
+ 0.64 0.71 0.43 57571429
+ 0.64 0.71 0.43 64642857
+ 0.64 0.71 0.43 71714286
+ 0.64 0.71 0.43 78785714
+ 0.64 0.71 0.43 85857143
+ 0.64 0.71 0.43 92928571
+ 0.64 0.71 0.43 100000000
+ 0.64 0.71 0.50 1000000
+ 0.64 0.71 0.50 8071429
+ 0.64 0.71 0.50 15142857
+ 0.64 0.71 0.50 22214286
+ 0.64 0.71 0.50 29285714
+ 0.64 0.71 0.50 36357143
+ 0.64 0.71 0.50 43428571
+ 0.64 0.71 0.50 50500000
+ 0.64 0.71 0.50 57571429
+ 0.64 0.71 0.50 64642857
+ 0.64 0.71 0.50 71714286
+ 0.64 0.71 0.50 78785714
+ 0.64 0.71 0.50 85857143
+ 0.64 0.71 0.50 92928571
+ 0.64 0.71 0.50 100000000
+ 0.64 0.71 0.57 1000000
+ 0.64 0.71 0.57 8071429
+ 0.64 0.71 0.57 15142857
+ 0.64 0.71 0.57 22214286
+ 0.64 0.71 0.57 29285714
+ 0.64 0.71 0.57 36357143
+ 0.64 0.71 0.57 43428571
+ 0.64 0.71 0.57 50500000
+ 0.64 0.71 0.57 57571429
+ 0.64 0.71 0.57 64642857
+ 0.64 0.71 0.57 71714286
+ 0.64 0.71 0.57 78785714
+ 0.64 0.71 0.57 85857143
+ 0.64 0.71 0.57 92928571
+ 0.64 0.71 0.57 100000000
+ 0.64 0.71 0.64 1000000
+ 0.64 0.71 0.64 8071429
+ 0.64 0.71 0.64 15142857
+ 0.64 0.71 0.64 22214286
+ 0.64 0.71 0.64 29285714
+ 0.64 0.71 0.64 36357143
+ 0.64 0.71 0.64 43428571
+ 0.64 0.71 0.64 50500000
+ 0.64 0.71 0.64 57571429
+ 0.64 0.71 0.64 64642857
+ 0.64 0.71 0.64 71714286
+ 0.64 0.71 0.64 78785714
+ 0.64 0.71 0.64 85857143
+ 0.64 0.71 0.64 92928571
+ 0.64 0.71 0.64 100000000
+ 0.64 0.71 0.71 1000000
+ 0.64 0.71 0.71 8071429
+ 0.64 0.71 0.71 15142857
+ 0.64 0.71 0.71 22214286
+ 0.64 0.71 0.71 29285714
+ 0.64 0.71 0.71 36357143
+ 0.64 0.71 0.71 43428571
+ 0.64 0.71 0.71 50500000
+ 0.64 0.71 0.71 57571429
+ 0.64 0.71 0.71 64642857
+ 0.64 0.71 0.71 71714286
+ 0.64 0.71 0.71 78785714
+ 0.64 0.71 0.71 85857143
+ 0.64 0.71 0.71 92928571
+ 0.64 0.71 0.71 100000000
+ 0.64 0.71 0.79 1000000
+ 0.64 0.71 0.79 8071429
+ 0.64 0.71 0.79 15142857
+ 0.64 0.71 0.79 22214286
+ 0.64 0.71 0.79 29285714
+ 0.64 0.71 0.79 36357143
+ 0.64 0.71 0.79 43428571
+ 0.64 0.71 0.79 50500000
+ 0.64 0.71 0.79 57571429
+ 0.64 0.71 0.79 64642857
+ 0.64 0.71 0.79 71714286
+ 0.64 0.71 0.79 78785714
+ 0.64 0.71 0.79 85857143
+ 0.64 0.71 0.79 92928571
+ 0.64 0.71 0.79 100000000
+ 0.64 0.71 0.86 1000000
+ 0.64 0.71 0.86 8071429
+ 0.64 0.71 0.86 15142857
+ 0.64 0.71 0.86 22214286
+ 0.64 0.71 0.86 29285714
+ 0.64 0.71 0.86 36357143
+ 0.64 0.71 0.86 43428571
+ 0.64 0.71 0.86 50500000
+ 0.64 0.71 0.86 57571429
+ 0.64 0.71 0.86 64642857
+ 0.64 0.71 0.86 71714286
+ 0.64 0.71 0.86 78785714
+ 0.64 0.71 0.86 85857143
+ 0.64 0.71 0.86 92928571
+ 0.64 0.71 0.86 100000000
+ 0.64 0.71 0.93 1000000
+ 0.64 0.71 0.93 8071429
+ 0.64 0.71 0.93 15142857
+ 0.64 0.71 0.93 22214286
+ 0.64 0.71 0.93 29285714
+ 0.64 0.71 0.93 36357143
+ 0.64 0.71 0.93 43428571
+ 0.64 0.71 0.93 50500000
+ 0.64 0.71 0.93 57571429
+ 0.64 0.71 0.93 64642857
+ 0.64 0.71 0.93 71714286
+ 0.64 0.71 0.93 78785714
+ 0.64 0.71 0.93 85857143
+ 0.64 0.71 0.93 92928571
+ 0.64 0.71 0.93 100000000
+ 0.64 0.71 1.00 1000000
+ 0.64 0.71 1.00 8071429
+ 0.64 0.71 1.00 15142857
+ 0.64 0.71 1.00 22214286
+ 0.64 0.71 1.00 29285714
+ 0.64 0.71 1.00 36357143
+ 0.64 0.71 1.00 43428571
+ 0.64 0.71 1.00 50500000
+ 0.64 0.71 1.00 57571429
+ 0.64 0.71 1.00 64642857
+ 0.64 0.71 1.00 71714286
+ 0.64 0.71 1.00 78785714
+ 0.64 0.71 1.00 85857143
+ 0.64 0.71 1.00 92928571
+ 0.64 0.71 1.00 100000000
+ 0.64 0.79 0.00 1000000
+ 0.64 0.79 0.00 8071429
+ 0.64 0.79 0.00 15142857
+ 0.64 0.79 0.00 22214286
+ 0.64 0.79 0.00 29285714
+ 0.64 0.79 0.00 36357143
+ 0.64 0.79 0.00 43428571
+ 0.64 0.79 0.00 50500000
+ 0.64 0.79 0.00 57571429
+ 0.64 0.79 0.00 64642857
+ 0.64 0.79 0.00 71714286
+ 0.64 0.79 0.00 78785714
+ 0.64 0.79 0.00 85857143
+ 0.64 0.79 0.00 92928571
+ 0.64 0.79 0.00 100000000
+ 0.64 0.79 0.07 1000000
+ 0.64 0.79 0.07 8071429
+ 0.64 0.79 0.07 15142857
+ 0.64 0.79 0.07 22214286
+ 0.64 0.79 0.07 29285714
+ 0.64 0.79 0.07 36357143
+ 0.64 0.79 0.07 43428571
+ 0.64 0.79 0.07 50500000
+ 0.64 0.79 0.07 57571429
+ 0.64 0.79 0.07 64642857
+ 0.64 0.79 0.07 71714286
+ 0.64 0.79 0.07 78785714
+ 0.64 0.79 0.07 85857143
+ 0.64 0.79 0.07 92928571
+ 0.64 0.79 0.07 100000000
+ 0.64 0.79 0.14 1000000
+ 0.64 0.79 0.14 8071429
+ 0.64 0.79 0.14 15142857
+ 0.64 0.79 0.14 22214286
+ 0.64 0.79 0.14 29285714
+ 0.64 0.79 0.14 36357143
+ 0.64 0.79 0.14 43428571
+ 0.64 0.79 0.14 50500000
+ 0.64 0.79 0.14 57571429
+ 0.64 0.79 0.14 64642857
+ 0.64 0.79 0.14 71714286
+ 0.64 0.79 0.14 78785714
+ 0.64 0.79 0.14 85857143
+ 0.64 0.79 0.14 92928571
+ 0.64 0.79 0.14 100000000
+ 0.64 0.79 0.21 1000000
+ 0.64 0.79 0.21 8071429
+ 0.64 0.79 0.21 15142857
+ 0.64 0.79 0.21 22214286
+ 0.64 0.79 0.21 29285714
+ 0.64 0.79 0.21 36357143
+ 0.64 0.79 0.21 43428571
+ 0.64 0.79 0.21 50500000
+ 0.64 0.79 0.21 57571429
+ 0.64 0.79 0.21 64642857
+ 0.64 0.79 0.21 71714286
+ 0.64 0.79 0.21 78785714
+ 0.64 0.79 0.21 85857143
+ 0.64 0.79 0.21 92928571
+ 0.64 0.79 0.21 100000000
+ 0.64 0.79 0.29 1000000
+ 0.64 0.79 0.29 8071429
+ 0.64 0.79 0.29 15142857
+ 0.64 0.79 0.29 22214286
+ 0.64 0.79 0.29 29285714
+ 0.64 0.79 0.29 36357143
+ 0.64 0.79 0.29 43428571
+ 0.64 0.79 0.29 50500000
+ 0.64 0.79 0.29 57571429
+ 0.64 0.79 0.29 64642857
+ 0.64 0.79 0.29 71714286
+ 0.64 0.79 0.29 78785714
+ 0.64 0.79 0.29 85857143
+ 0.64 0.79 0.29 92928571
+ 0.64 0.79 0.29 100000000
+ 0.64 0.79 0.36 1000000
+ 0.64 0.79 0.36 8071429
+ 0.64 0.79 0.36 15142857
+ 0.64 0.79 0.36 22214286
+ 0.64 0.79 0.36 29285714
+ 0.64 0.79 0.36 36357143
+ 0.64 0.79 0.36 43428571
+ 0.64 0.79 0.36 50500000
+ 0.64 0.79 0.36 57571429
+ 0.64 0.79 0.36 64642857
+ 0.64 0.79 0.36 71714286
+ 0.64 0.79 0.36 78785714
+ 0.64 0.79 0.36 85857143
+ 0.64 0.79 0.36 92928571
+ 0.64 0.79 0.36 100000000
+ 0.64 0.79 0.43 1000000
+ 0.64 0.79 0.43 8071429
+ 0.64 0.79 0.43 15142857
+ 0.64 0.79 0.43 22214286
+ 0.64 0.79 0.43 29285714
+ 0.64 0.79 0.43 36357143
+ 0.64 0.79 0.43 43428571
+ 0.64 0.79 0.43 50500000
+ 0.64 0.79 0.43 57571429
+ 0.64 0.79 0.43 64642857
+ 0.64 0.79 0.43 71714286
+ 0.64 0.79 0.43 78785714
+ 0.64 0.79 0.43 85857143
+ 0.64 0.79 0.43 92928571
+ 0.64 0.79 0.43 100000000
+ 0.64 0.79 0.50 1000000
+ 0.64 0.79 0.50 8071429
+ 0.64 0.79 0.50 15142857
+ 0.64 0.79 0.50 22214286
+ 0.64 0.79 0.50 29285714
+ 0.64 0.79 0.50 36357143
+ 0.64 0.79 0.50 43428571
+ 0.64 0.79 0.50 50500000
+ 0.64 0.79 0.50 57571429
+ 0.64 0.79 0.50 64642857
+ 0.64 0.79 0.50 71714286
+ 0.64 0.79 0.50 78785714
+ 0.64 0.79 0.50 85857143
+ 0.64 0.79 0.50 92928571
+ 0.64 0.79 0.50 100000000
+ 0.64 0.79 0.57 1000000
+ 0.64 0.79 0.57 8071429
+ 0.64 0.79 0.57 15142857
+ 0.64 0.79 0.57 22214286
+ 0.64 0.79 0.57 29285714
+ 0.64 0.79 0.57 36357143
+ 0.64 0.79 0.57 43428571
+ 0.64 0.79 0.57 50500000
+ 0.64 0.79 0.57 57571429
+ 0.64 0.79 0.57 64642857
+ 0.64 0.79 0.57 71714286
+ 0.64 0.79 0.57 78785714
+ 0.64 0.79 0.57 85857143
+ 0.64 0.79 0.57 92928571
+ 0.64 0.79 0.57 100000000
+ 0.64 0.79 0.64 1000000
+ 0.64 0.79 0.64 8071429
+ 0.64 0.79 0.64 15142857
+ 0.64 0.79 0.64 22214286
+ 0.64 0.79 0.64 29285714
+ 0.64 0.79 0.64 36357143
+ 0.64 0.79 0.64 43428571
+ 0.64 0.79 0.64 50500000
+ 0.64 0.79 0.64 57571429
+ 0.64 0.79 0.64 64642857
+ 0.64 0.79 0.64 71714286
+ 0.64 0.79 0.64 78785714
+ 0.64 0.79 0.64 85857143
+ 0.64 0.79 0.64 92928571
+ 0.64 0.79 0.64 100000000
+ 0.64 0.79 0.71 1000000
+ 0.64 0.79 0.71 8071429
+ 0.64 0.79 0.71 15142857
+ 0.64 0.79 0.71 22214286
+ 0.64 0.79 0.71 29285714
+ 0.64 0.79 0.71 36357143
+ 0.64 0.79 0.71 43428571
+ 0.64 0.79 0.71 50500000
+ 0.64 0.79 0.71 57571429
+ 0.64 0.79 0.71 64642857
+ 0.64 0.79 0.71 71714286
+ 0.64 0.79 0.71 78785714
+ 0.64 0.79 0.71 85857143
+ 0.64 0.79 0.71 92928571
+ 0.64 0.79 0.71 100000000
+ 0.64 0.79 0.79 1000000
+ 0.64 0.79 0.79 8071429
+ 0.64 0.79 0.79 15142857
+ 0.64 0.79 0.79 22214286
+ 0.64 0.79 0.79 29285714
+ 0.64 0.79 0.79 36357143
+ 0.64 0.79 0.79 43428571
+ 0.64 0.79 0.79 50500000
+ 0.64 0.79 0.79 57571429
+ 0.64 0.79 0.79 64642857
+ 0.64 0.79 0.79 71714286
+ 0.64 0.79 0.79 78785714
+ 0.64 0.79 0.79 85857143
+ 0.64 0.79 0.79 92928571
+ 0.64 0.79 0.79 100000000
+ 0.64 0.79 0.86 1000000
+ 0.64 0.79 0.86 8071429
+ 0.64 0.79 0.86 15142857
+ 0.64 0.79 0.86 22214286
+ 0.64 0.79 0.86 29285714
+ 0.64 0.79 0.86 36357143
+ 0.64 0.79 0.86 43428571
+ 0.64 0.79 0.86 50500000
+ 0.64 0.79 0.86 57571429
+ 0.64 0.79 0.86 64642857
+ 0.64 0.79 0.86 71714286
+ 0.64 0.79 0.86 78785714
+ 0.64 0.79 0.86 85857143
+ 0.64 0.79 0.86 92928571
+ 0.64 0.79 0.86 100000000
+ 0.64 0.79 0.93 1000000
+ 0.64 0.79 0.93 8071429
+ 0.64 0.79 0.93 15142857
+ 0.64 0.79 0.93 22214286
+ 0.64 0.79 0.93 29285714
+ 0.64 0.79 0.93 36357143
+ 0.64 0.79 0.93 43428571
+ 0.64 0.79 0.93 50500000
+ 0.64 0.79 0.93 57571429
+ 0.64 0.79 0.93 64642857
+ 0.64 0.79 0.93 71714286
+ 0.64 0.79 0.93 78785714
+ 0.64 0.79 0.93 85857143
+ 0.64 0.79 0.93 92928571
+ 0.64 0.79 0.93 100000000
+ 0.64 0.79 1.00 1000000
+ 0.64 0.79 1.00 8071429
+ 0.64 0.79 1.00 15142857
+ 0.64 0.79 1.00 22214286
+ 0.64 0.79 1.00 29285714
+ 0.64 0.79 1.00 36357143
+ 0.64 0.79 1.00 43428571
+ 0.64 0.79 1.00 50500000
+ 0.64 0.79 1.00 57571429
+ 0.64 0.79 1.00 64642857
+ 0.64 0.79 1.00 71714286
+ 0.64 0.79 1.00 78785714
+ 0.64 0.79 1.00 85857143
+ 0.64 0.79 1.00 92928571
+ 0.64 0.79 1.00 100000000
+ 0.64 0.86 0.00 1000000
+ 0.64 0.86 0.00 8071429
+ 0.64 0.86 0.00 15142857
+ 0.64 0.86 0.00 22214286
+ 0.64 0.86 0.00 29285714
+ 0.64 0.86 0.00 36357143
+ 0.64 0.86 0.00 43428571
+ 0.64 0.86 0.00 50500000
+ 0.64 0.86 0.00 57571429
+ 0.64 0.86 0.00 64642857
+ 0.64 0.86 0.00 71714286
+ 0.64 0.86 0.00 78785714
+ 0.64 0.86 0.00 85857143
+ 0.64 0.86 0.00 92928571
+ 0.64 0.86 0.00 100000000
+ 0.64 0.86 0.07 1000000
+ 0.64 0.86 0.07 8071429
+ 0.64 0.86 0.07 15142857
+ 0.64 0.86 0.07 22214286
+ 0.64 0.86 0.07 29285714
+ 0.64 0.86 0.07 36357143
+ 0.64 0.86 0.07 43428571
+ 0.64 0.86 0.07 50500000
+ 0.64 0.86 0.07 57571429
+ 0.64 0.86 0.07 64642857
+ 0.64 0.86 0.07 71714286
+ 0.64 0.86 0.07 78785714
+ 0.64 0.86 0.07 85857143
+ 0.64 0.86 0.07 92928571
+ 0.64 0.86 0.07 100000000
+ 0.64 0.86 0.14 1000000
+ 0.64 0.86 0.14 8071429
+ 0.64 0.86 0.14 15142857
+ 0.64 0.86 0.14 22214286
+ 0.64 0.86 0.14 29285714
+ 0.64 0.86 0.14 36357143
+ 0.64 0.86 0.14 43428571
+ 0.64 0.86 0.14 50500000
+ 0.64 0.86 0.14 57571429
+ 0.64 0.86 0.14 64642857
+ 0.64 0.86 0.14 71714286
+ 0.64 0.86 0.14 78785714
+ 0.64 0.86 0.14 85857143
+ 0.64 0.86 0.14 92928571
+ 0.64 0.86 0.14 100000000
+ 0.64 0.86 0.21 1000000
+ 0.64 0.86 0.21 8071429
+ 0.64 0.86 0.21 15142857
+ 0.64 0.86 0.21 22214286
+ 0.64 0.86 0.21 29285714
+ 0.64 0.86 0.21 36357143
+ 0.64 0.86 0.21 43428571
+ 0.64 0.86 0.21 50500000
+ 0.64 0.86 0.21 57571429
+ 0.64 0.86 0.21 64642857
+ 0.64 0.86 0.21 71714286
+ 0.64 0.86 0.21 78785714
+ 0.64 0.86 0.21 85857143
+ 0.64 0.86 0.21 92928571
+ 0.64 0.86 0.21 100000000
+ 0.64 0.86 0.29 1000000
+ 0.64 0.86 0.29 8071429
+ 0.64 0.86 0.29 15142857
+ 0.64 0.86 0.29 22214286
+ 0.64 0.86 0.29 29285714
+ 0.64 0.86 0.29 36357143
+ 0.64 0.86 0.29 43428571
+ 0.64 0.86 0.29 50500000
+ 0.64 0.86 0.29 57571429
+ 0.64 0.86 0.29 64642857
+ 0.64 0.86 0.29 71714286
+ 0.64 0.86 0.29 78785714
+ 0.64 0.86 0.29 85857143
+ 0.64 0.86 0.29 92928571
+ 0.64 0.86 0.29 100000000
+ 0.64 0.86 0.36 1000000
+ 0.64 0.86 0.36 8071429
+ 0.64 0.86 0.36 15142857
+ 0.64 0.86 0.36 22214286
+ 0.64 0.86 0.36 29285714
+ 0.64 0.86 0.36 36357143
+ 0.64 0.86 0.36 43428571
+ 0.64 0.86 0.36 50500000
+ 0.64 0.86 0.36 57571429
+ 0.64 0.86 0.36 64642857
+ 0.64 0.86 0.36 71714286
+ 0.64 0.86 0.36 78785714
+ 0.64 0.86 0.36 85857143
+ 0.64 0.86 0.36 92928571
+ 0.64 0.86 0.36 100000000
+ 0.64 0.86 0.43 1000000
+ 0.64 0.86 0.43 8071429
+ 0.64 0.86 0.43 15142857
+ 0.64 0.86 0.43 22214286
+ 0.64 0.86 0.43 29285714
+ 0.64 0.86 0.43 36357143
+ 0.64 0.86 0.43 43428571
+ 0.64 0.86 0.43 50500000
+ 0.64 0.86 0.43 57571429
+ 0.64 0.86 0.43 64642857
+ 0.64 0.86 0.43 71714286
+ 0.64 0.86 0.43 78785714
+ 0.64 0.86 0.43 85857143
+ 0.64 0.86 0.43 92928571
+ 0.64 0.86 0.43 100000000
+ 0.64 0.86 0.50 1000000
+ 0.64 0.86 0.50 8071429
+ 0.64 0.86 0.50 15142857
+ 0.64 0.86 0.50 22214286
+ 0.64 0.86 0.50 29285714
+ 0.64 0.86 0.50 36357143
+ 0.64 0.86 0.50 43428571
+ 0.64 0.86 0.50 50500000
+ 0.64 0.86 0.50 57571429
+ 0.64 0.86 0.50 64642857
+ 0.64 0.86 0.50 71714286
+ 0.64 0.86 0.50 78785714
+ 0.64 0.86 0.50 85857143
+ 0.64 0.86 0.50 92928571
+ 0.64 0.86 0.50 100000000
+ 0.64 0.86 0.57 1000000
+ 0.64 0.86 0.57 8071429
+ 0.64 0.86 0.57 15142857
+ 0.64 0.86 0.57 22214286
+ 0.64 0.86 0.57 29285714
+ 0.64 0.86 0.57 36357143
+ 0.64 0.86 0.57 43428571
+ 0.64 0.86 0.57 50500000
+ 0.64 0.86 0.57 57571429
+ 0.64 0.86 0.57 64642857
+ 0.64 0.86 0.57 71714286
+ 0.64 0.86 0.57 78785714
+ 0.64 0.86 0.57 85857143
+ 0.64 0.86 0.57 92928571
+ 0.64 0.86 0.57 100000000
+ 0.64 0.86 0.64 1000000
+ 0.64 0.86 0.64 8071429
+ 0.64 0.86 0.64 15142857
+ 0.64 0.86 0.64 22214286
+ 0.64 0.86 0.64 29285714
+ 0.64 0.86 0.64 36357143
+ 0.64 0.86 0.64 43428571
+ 0.64 0.86 0.64 50500000
+ 0.64 0.86 0.64 57571429
+ 0.64 0.86 0.64 64642857
+ 0.64 0.86 0.64 71714286
+ 0.64 0.86 0.64 78785714
+ 0.64 0.86 0.64 85857143
+ 0.64 0.86 0.64 92928571
+ 0.64 0.86 0.64 100000000
+ 0.64 0.86 0.71 1000000
+ 0.64 0.86 0.71 8071429
+ 0.64 0.86 0.71 15142857
+ 0.64 0.86 0.71 22214286
+ 0.64 0.86 0.71 29285714
+ 0.64 0.86 0.71 36357143
+ 0.64 0.86 0.71 43428571
+ 0.64 0.86 0.71 50500000
+ 0.64 0.86 0.71 57571429
+ 0.64 0.86 0.71 64642857
+ 0.64 0.86 0.71 71714286
+ 0.64 0.86 0.71 78785714
+ 0.64 0.86 0.71 85857143
+ 0.64 0.86 0.71 92928571
+ 0.64 0.86 0.71 100000000
+ 0.64 0.86 0.79 1000000
+ 0.64 0.86 0.79 8071429
+ 0.64 0.86 0.79 15142857
+ 0.64 0.86 0.79 22214286
+ 0.64 0.86 0.79 29285714
+ 0.64 0.86 0.79 36357143
+ 0.64 0.86 0.79 43428571
+ 0.64 0.86 0.79 50500000
+ 0.64 0.86 0.79 57571429
+ 0.64 0.86 0.79 64642857
+ 0.64 0.86 0.79 71714286
+ 0.64 0.86 0.79 78785714
+ 0.64 0.86 0.79 85857143
+ 0.64 0.86 0.79 92928571
+ 0.64 0.86 0.79 100000000
+ 0.64 0.86 0.86 1000000
+ 0.64 0.86 0.86 8071429
+ 0.64 0.86 0.86 15142857
+ 0.64 0.86 0.86 22214286
+ 0.64 0.86 0.86 29285714
+ 0.64 0.86 0.86 36357143
+ 0.64 0.86 0.86 43428571
+ 0.64 0.86 0.86 50500000
+ 0.64 0.86 0.86 57571429
+ 0.64 0.86 0.86 64642857
+ 0.64 0.86 0.86 71714286
+ 0.64 0.86 0.86 78785714
+ 0.64 0.86 0.86 85857143
+ 0.64 0.86 0.86 92928571
+ 0.64 0.86 0.86 100000000
+ 0.64 0.86 0.93 1000000
+ 0.64 0.86 0.93 8071429
+ 0.64 0.86 0.93 15142857
+ 0.64 0.86 0.93 22214286
+ 0.64 0.86 0.93 29285714
+ 0.64 0.86 0.93 36357143
+ 0.64 0.86 0.93 43428571
+ 0.64 0.86 0.93 50500000
+ 0.64 0.86 0.93 57571429
+ 0.64 0.86 0.93 64642857
+ 0.64 0.86 0.93 71714286
+ 0.64 0.86 0.93 78785714
+ 0.64 0.86 0.93 85857143
+ 0.64 0.86 0.93 92928571
+ 0.64 0.86 0.93 100000000
+ 0.64 0.86 1.00 1000000
+ 0.64 0.86 1.00 8071429
+ 0.64 0.86 1.00 15142857
+ 0.64 0.86 1.00 22214286
+ 0.64 0.86 1.00 29285714
+ 0.64 0.86 1.00 36357143
+ 0.64 0.86 1.00 43428571
+ 0.64 0.86 1.00 50500000
+ 0.64 0.86 1.00 57571429
+ 0.64 0.86 1.00 64642857
+ 0.64 0.86 1.00 71714286
+ 0.64 0.86 1.00 78785714
+ 0.64 0.86 1.00 85857143
+ 0.64 0.86 1.00 92928571
+ 0.64 0.86 1.00 100000000
+ 0.64 0.93 0.00 1000000
+ 0.64 0.93 0.00 8071429
+ 0.64 0.93 0.00 15142857
+ 0.64 0.93 0.00 22214286
+ 0.64 0.93 0.00 29285714
+ 0.64 0.93 0.00 36357143
+ 0.64 0.93 0.00 43428571
+ 0.64 0.93 0.00 50500000
+ 0.64 0.93 0.00 57571429
+ 0.64 0.93 0.00 64642857
+ 0.64 0.93 0.00 71714286
+ 0.64 0.93 0.00 78785714
+ 0.64 0.93 0.00 85857143
+ 0.64 0.93 0.00 92928571
+ 0.64 0.93 0.00 100000000
+ 0.64 0.93 0.07 1000000
+ 0.64 0.93 0.07 8071429
+ 0.64 0.93 0.07 15142857
+ 0.64 0.93 0.07 22214286
+ 0.64 0.93 0.07 29285714
+ 0.64 0.93 0.07 36357143
+ 0.64 0.93 0.07 43428571
+ 0.64 0.93 0.07 50500000
+ 0.64 0.93 0.07 57571429
+ 0.64 0.93 0.07 64642857
+ 0.64 0.93 0.07 71714286
+ 0.64 0.93 0.07 78785714
+ 0.64 0.93 0.07 85857143
+ 0.64 0.93 0.07 92928571
+ 0.64 0.93 0.07 100000000
+ 0.64 0.93 0.14 1000000
+ 0.64 0.93 0.14 8071429
+ 0.64 0.93 0.14 15142857
+ 0.64 0.93 0.14 22214286
+ 0.64 0.93 0.14 29285714
+ 0.64 0.93 0.14 36357143
+ 0.64 0.93 0.14 43428571
+ 0.64 0.93 0.14 50500000
+ 0.64 0.93 0.14 57571429
+ 0.64 0.93 0.14 64642857
+ 0.64 0.93 0.14 71714286
+ 0.64 0.93 0.14 78785714
+ 0.64 0.93 0.14 85857143
+ 0.64 0.93 0.14 92928571
+ 0.64 0.93 0.14 100000000
+ 0.64 0.93 0.21 1000000
+ 0.64 0.93 0.21 8071429
+ 0.64 0.93 0.21 15142857
+ 0.64 0.93 0.21 22214286
+ 0.64 0.93 0.21 29285714
+ 0.64 0.93 0.21 36357143
+ 0.64 0.93 0.21 43428571
+ 0.64 0.93 0.21 50500000
+ 0.64 0.93 0.21 57571429
+ 0.64 0.93 0.21 64642857
+ 0.64 0.93 0.21 71714286
+ 0.64 0.93 0.21 78785714
+ 0.64 0.93 0.21 85857143
+ 0.64 0.93 0.21 92928571
+ 0.64 0.93 0.21 100000000
+ 0.64 0.93 0.29 1000000
+ 0.64 0.93 0.29 8071429
+ 0.64 0.93 0.29 15142857
+ 0.64 0.93 0.29 22214286
+ 0.64 0.93 0.29 29285714
+ 0.64 0.93 0.29 36357143
+ 0.64 0.93 0.29 43428571
+ 0.64 0.93 0.29 50500000
+ 0.64 0.93 0.29 57571429
+ 0.64 0.93 0.29 64642857
+ 0.64 0.93 0.29 71714286
+ 0.64 0.93 0.29 78785714
+ 0.64 0.93 0.29 85857143
+ 0.64 0.93 0.29 92928571
+ 0.64 0.93 0.29 100000000
+ 0.64 0.93 0.36 1000000
+ 0.64 0.93 0.36 8071429
+ 0.64 0.93 0.36 15142857
+ 0.64 0.93 0.36 22214286
+ 0.64 0.93 0.36 29285714
+ 0.64 0.93 0.36 36357143
+ 0.64 0.93 0.36 43428571
+ 0.64 0.93 0.36 50500000
+ 0.64 0.93 0.36 57571429
+ 0.64 0.93 0.36 64642857
+ 0.64 0.93 0.36 71714286
+ 0.64 0.93 0.36 78785714
+ 0.64 0.93 0.36 85857143
+ 0.64 0.93 0.36 92928571
+ 0.64 0.93 0.36 100000000
+ 0.64 0.93 0.43 1000000
+ 0.64 0.93 0.43 8071429
+ 0.64 0.93 0.43 15142857
+ 0.64 0.93 0.43 22214286
+ 0.64 0.93 0.43 29285714
+ 0.64 0.93 0.43 36357143
+ 0.64 0.93 0.43 43428571
+ 0.64 0.93 0.43 50500000
+ 0.64 0.93 0.43 57571429
+ 0.64 0.93 0.43 64642857
+ 0.64 0.93 0.43 71714286
+ 0.64 0.93 0.43 78785714
+ 0.64 0.93 0.43 85857143
+ 0.64 0.93 0.43 92928571
+ 0.64 0.93 0.43 100000000
+ 0.64 0.93 0.50 1000000
+ 0.64 0.93 0.50 8071429
+ 0.64 0.93 0.50 15142857
+ 0.64 0.93 0.50 22214286
+ 0.64 0.93 0.50 29285714
+ 0.64 0.93 0.50 36357143
+ 0.64 0.93 0.50 43428571
+ 0.64 0.93 0.50 50500000
+ 0.64 0.93 0.50 57571429
+ 0.64 0.93 0.50 64642857
+ 0.64 0.93 0.50 71714286
+ 0.64 0.93 0.50 78785714
+ 0.64 0.93 0.50 85857143
+ 0.64 0.93 0.50 92928571
+ 0.64 0.93 0.50 100000000
+ 0.64 0.93 0.57 1000000
+ 0.64 0.93 0.57 8071429
+ 0.64 0.93 0.57 15142857
+ 0.64 0.93 0.57 22214286
+ 0.64 0.93 0.57 29285714
+ 0.64 0.93 0.57 36357143
+ 0.64 0.93 0.57 43428571
+ 0.64 0.93 0.57 50500000
+ 0.64 0.93 0.57 57571429
+ 0.64 0.93 0.57 64642857
+ 0.64 0.93 0.57 71714286
+ 0.64 0.93 0.57 78785714
+ 0.64 0.93 0.57 85857143
+ 0.64 0.93 0.57 92928571
+ 0.64 0.93 0.57 100000000
+ 0.64 0.93 0.64 1000000
+ 0.64 0.93 0.64 8071429
+ 0.64 0.93 0.64 15142857
+ 0.64 0.93 0.64 22214286
+ 0.64 0.93 0.64 29285714
+ 0.64 0.93 0.64 36357143
+ 0.64 0.93 0.64 43428571
+ 0.64 0.93 0.64 50500000
+ 0.64 0.93 0.64 57571429
+ 0.64 0.93 0.64 64642857
+ 0.64 0.93 0.64 71714286
+ 0.64 0.93 0.64 78785714
+ 0.64 0.93 0.64 85857143
+ 0.64 0.93 0.64 92928571
+ 0.64 0.93 0.64 100000000
+ 0.64 0.93 0.71 1000000
+ 0.64 0.93 0.71 8071429
+ 0.64 0.93 0.71 15142857
+ 0.64 0.93 0.71 22214286
+ 0.64 0.93 0.71 29285714
+ 0.64 0.93 0.71 36357143
+ 0.64 0.93 0.71 43428571
+ 0.64 0.93 0.71 50500000
+ 0.64 0.93 0.71 57571429
+ 0.64 0.93 0.71 64642857
+ 0.64 0.93 0.71 71714286
+ 0.64 0.93 0.71 78785714
+ 0.64 0.93 0.71 85857143
+ 0.64 0.93 0.71 92928571
+ 0.64 0.93 0.71 100000000
+ 0.64 0.93 0.79 1000000
+ 0.64 0.93 0.79 8071429
+ 0.64 0.93 0.79 15142857
+ 0.64 0.93 0.79 22214286
+ 0.64 0.93 0.79 29285714
+ 0.64 0.93 0.79 36357143
+ 0.64 0.93 0.79 43428571
+ 0.64 0.93 0.79 50500000
+ 0.64 0.93 0.79 57571429
+ 0.64 0.93 0.79 64642857
+ 0.64 0.93 0.79 71714286
+ 0.64 0.93 0.79 78785714
+ 0.64 0.93 0.79 85857143
+ 0.64 0.93 0.79 92928571
+ 0.64 0.93 0.79 100000000
+ 0.64 0.93 0.86 1000000
+ 0.64 0.93 0.86 8071429
+ 0.64 0.93 0.86 15142857
+ 0.64 0.93 0.86 22214286
+ 0.64 0.93 0.86 29285714
+ 0.64 0.93 0.86 36357143
+ 0.64 0.93 0.86 43428571
+ 0.64 0.93 0.86 50500000
+ 0.64 0.93 0.86 57571429
+ 0.64 0.93 0.86 64642857
+ 0.64 0.93 0.86 71714286
+ 0.64 0.93 0.86 78785714
+ 0.64 0.93 0.86 85857143
+ 0.64 0.93 0.86 92928571
+ 0.64 0.93 0.86 100000000
+ 0.64 0.93 0.93 1000000
+ 0.64 0.93 0.93 8071429
+ 0.64 0.93 0.93 15142857
+ 0.64 0.93 0.93 22214286
+ 0.64 0.93 0.93 29285714
+ 0.64 0.93 0.93 36357143
+ 0.64 0.93 0.93 43428571
+ 0.64 0.93 0.93 50500000
+ 0.64 0.93 0.93 57571429
+ 0.64 0.93 0.93 64642857
+ 0.64 0.93 0.93 71714286
+ 0.64 0.93 0.93 78785714
+ 0.64 0.93 0.93 85857143
+ 0.64 0.93 0.93 92928571
+ 0.64 0.93 0.93 100000000
+ 0.64 0.93 1.00 1000000
+ 0.64 0.93 1.00 8071429
+ 0.64 0.93 1.00 15142857
+ 0.64 0.93 1.00 22214286
+ 0.64 0.93 1.00 29285714
+ 0.64 0.93 1.00 36357143
+ 0.64 0.93 1.00 43428571
+ 0.64 0.93 1.00 50500000
+ 0.64 0.93 1.00 57571429
+ 0.64 0.93 1.00 64642857
+ 0.64 0.93 1.00 71714286
+ 0.64 0.93 1.00 78785714
+ 0.64 0.93 1.00 85857143
+ 0.64 0.93 1.00 92928571
+ 0.64 0.93 1.00 100000000
+ 0.64 1.00 0.00 1000000
+ 0.64 1.00 0.00 8071429
+ 0.64 1.00 0.00 15142857
+ 0.64 1.00 0.00 22214286
+ 0.64 1.00 0.00 29285714
+ 0.64 1.00 0.00 36357143
+ 0.64 1.00 0.00 43428571
+ 0.64 1.00 0.00 50500000
+ 0.64 1.00 0.00 57571429
+ 0.64 1.00 0.00 64642857
+ 0.64 1.00 0.00 71714286
+ 0.64 1.00 0.00 78785714
+ 0.64 1.00 0.00 85857143
+ 0.64 1.00 0.00 92928571
+ 0.64 1.00 0.00 100000000
+ 0.64 1.00 0.07 1000000
+ 0.64 1.00 0.07 8071429
+ 0.64 1.00 0.07 15142857
+ 0.64 1.00 0.07 22214286
+ 0.64 1.00 0.07 29285714
+ 0.64 1.00 0.07 36357143
+ 0.64 1.00 0.07 43428571
+ 0.64 1.00 0.07 50500000
+ 0.64 1.00 0.07 57571429
+ 0.64 1.00 0.07 64642857
+ 0.64 1.00 0.07 71714286
+ 0.64 1.00 0.07 78785714
+ 0.64 1.00 0.07 85857143
+ 0.64 1.00 0.07 92928571
+ 0.64 1.00 0.07 100000000
+ 0.64 1.00 0.14 1000000
+ 0.64 1.00 0.14 8071429
+ 0.64 1.00 0.14 15142857
+ 0.64 1.00 0.14 22214286
+ 0.64 1.00 0.14 29285714
+ 0.64 1.00 0.14 36357143
+ 0.64 1.00 0.14 43428571
+ 0.64 1.00 0.14 50500000
+ 0.64 1.00 0.14 57571429
+ 0.64 1.00 0.14 64642857
+ 0.64 1.00 0.14 71714286
+ 0.64 1.00 0.14 78785714
+ 0.64 1.00 0.14 85857143
+ 0.64 1.00 0.14 92928571
+ 0.64 1.00 0.14 100000000
+ 0.64 1.00 0.21 1000000
+ 0.64 1.00 0.21 8071429
+ 0.64 1.00 0.21 15142857
+ 0.64 1.00 0.21 22214286
+ 0.64 1.00 0.21 29285714
+ 0.64 1.00 0.21 36357143
+ 0.64 1.00 0.21 43428571
+ 0.64 1.00 0.21 50500000
+ 0.64 1.00 0.21 57571429
+ 0.64 1.00 0.21 64642857
+ 0.64 1.00 0.21 71714286
+ 0.64 1.00 0.21 78785714
+ 0.64 1.00 0.21 85857143
+ 0.64 1.00 0.21 92928571
+ 0.64 1.00 0.21 100000000
+ 0.64 1.00 0.29 1000000
+ 0.64 1.00 0.29 8071429
+ 0.64 1.00 0.29 15142857
+ 0.64 1.00 0.29 22214286
+ 0.64 1.00 0.29 29285714
+ 0.64 1.00 0.29 36357143
+ 0.64 1.00 0.29 43428571
+ 0.64 1.00 0.29 50500000
+ 0.64 1.00 0.29 57571429
+ 0.64 1.00 0.29 64642857
+ 0.64 1.00 0.29 71714286
+ 0.64 1.00 0.29 78785714
+ 0.64 1.00 0.29 85857143
+ 0.64 1.00 0.29 92928571
+ 0.64 1.00 0.29 100000000
+ 0.64 1.00 0.36 1000000
+ 0.64 1.00 0.36 8071429
+ 0.64 1.00 0.36 15142857
+ 0.64 1.00 0.36 22214286
+ 0.64 1.00 0.36 29285714
+ 0.64 1.00 0.36 36357143
+ 0.64 1.00 0.36 43428571
+ 0.64 1.00 0.36 50500000
+ 0.64 1.00 0.36 57571429
+ 0.64 1.00 0.36 64642857
+ 0.64 1.00 0.36 71714286
+ 0.64 1.00 0.36 78785714
+ 0.64 1.00 0.36 85857143
+ 0.64 1.00 0.36 92928571
+ 0.64 1.00 0.36 100000000
+ 0.64 1.00 0.43 1000000
+ 0.64 1.00 0.43 8071429
+ 0.64 1.00 0.43 15142857
+ 0.64 1.00 0.43 22214286
+ 0.64 1.00 0.43 29285714
+ 0.64 1.00 0.43 36357143
+ 0.64 1.00 0.43 43428571
+ 0.64 1.00 0.43 50500000
+ 0.64 1.00 0.43 57571429
+ 0.64 1.00 0.43 64642857
+ 0.64 1.00 0.43 71714286
+ 0.64 1.00 0.43 78785714
+ 0.64 1.00 0.43 85857143
+ 0.64 1.00 0.43 92928571
+ 0.64 1.00 0.43 100000000
+ 0.64 1.00 0.50 1000000
+ 0.64 1.00 0.50 8071429
+ 0.64 1.00 0.50 15142857
+ 0.64 1.00 0.50 22214286
+ 0.64 1.00 0.50 29285714
+ 0.64 1.00 0.50 36357143
+ 0.64 1.00 0.50 43428571
+ 0.64 1.00 0.50 50500000
+ 0.64 1.00 0.50 57571429
+ 0.64 1.00 0.50 64642857
+ 0.64 1.00 0.50 71714286
+ 0.64 1.00 0.50 78785714
+ 0.64 1.00 0.50 85857143
+ 0.64 1.00 0.50 92928571
+ 0.64 1.00 0.50 100000000
+ 0.64 1.00 0.57 1000000
+ 0.64 1.00 0.57 8071429
+ 0.64 1.00 0.57 15142857
+ 0.64 1.00 0.57 22214286
+ 0.64 1.00 0.57 29285714
+ 0.64 1.00 0.57 36357143
+ 0.64 1.00 0.57 43428571
+ 0.64 1.00 0.57 50500000
+ 0.64 1.00 0.57 57571429
+ 0.64 1.00 0.57 64642857
+ 0.64 1.00 0.57 71714286
+ 0.64 1.00 0.57 78785714
+ 0.64 1.00 0.57 85857143
+ 0.64 1.00 0.57 92928571
+ 0.64 1.00 0.57 100000000
+ 0.64 1.00 0.64 1000000
+ 0.64 1.00 0.64 8071429
+ 0.64 1.00 0.64 15142857
+ 0.64 1.00 0.64 22214286
+ 0.64 1.00 0.64 29285714
+ 0.64 1.00 0.64 36357143
+ 0.64 1.00 0.64 43428571
+ 0.64 1.00 0.64 50500000
+ 0.64 1.00 0.64 57571429
+ 0.64 1.00 0.64 64642857
+ 0.64 1.00 0.64 71714286
+ 0.64 1.00 0.64 78785714
+ 0.64 1.00 0.64 85857143
+ 0.64 1.00 0.64 92928571
+ 0.64 1.00 0.64 100000000
+ 0.64 1.00 0.71 1000000
+ 0.64 1.00 0.71 8071429
+ 0.64 1.00 0.71 15142857
+ 0.64 1.00 0.71 22214286
+ 0.64 1.00 0.71 29285714
+ 0.64 1.00 0.71 36357143
+ 0.64 1.00 0.71 43428571
+ 0.64 1.00 0.71 50500000
+ 0.64 1.00 0.71 57571429
+ 0.64 1.00 0.71 64642857
+ 0.64 1.00 0.71 71714286
+ 0.64 1.00 0.71 78785714
+ 0.64 1.00 0.71 85857143
+ 0.64 1.00 0.71 92928571
+ 0.64 1.00 0.71 100000000
+ 0.64 1.00 0.79 1000000
+ 0.64 1.00 0.79 8071429
+ 0.64 1.00 0.79 15142857
+ 0.64 1.00 0.79 22214286
+ 0.64 1.00 0.79 29285714
+ 0.64 1.00 0.79 36357143
+ 0.64 1.00 0.79 43428571
+ 0.64 1.00 0.79 50500000
+ 0.64 1.00 0.79 57571429
+ 0.64 1.00 0.79 64642857
+ 0.64 1.00 0.79 71714286
+ 0.64 1.00 0.79 78785714
+ 0.64 1.00 0.79 85857143
+ 0.64 1.00 0.79 92928571
+ 0.64 1.00 0.79 100000000
+ 0.64 1.00 0.86 1000000
+ 0.64 1.00 0.86 8071429
+ 0.64 1.00 0.86 15142857
+ 0.64 1.00 0.86 22214286
+ 0.64 1.00 0.86 29285714
+ 0.64 1.00 0.86 36357143
+ 0.64 1.00 0.86 43428571
+ 0.64 1.00 0.86 50500000
+ 0.64 1.00 0.86 57571429
+ 0.64 1.00 0.86 64642857
+ 0.64 1.00 0.86 71714286
+ 0.64 1.00 0.86 78785714
+ 0.64 1.00 0.86 85857143
+ 0.64 1.00 0.86 92928571
+ 0.64 1.00 0.86 100000000
+ 0.64 1.00 0.93 1000000
+ 0.64 1.00 0.93 8071429
+ 0.64 1.00 0.93 15142857
+ 0.64 1.00 0.93 22214286
+ 0.64 1.00 0.93 29285714
+ 0.64 1.00 0.93 36357143
+ 0.64 1.00 0.93 43428571
+ 0.64 1.00 0.93 50500000
+ 0.64 1.00 0.93 57571429
+ 0.64 1.00 0.93 64642857
+ 0.64 1.00 0.93 71714286
+ 0.64 1.00 0.93 78785714
+ 0.64 1.00 0.93 85857143
+ 0.64 1.00 0.93 92928571
+ 0.64 1.00 0.93 100000000
+ 0.64 1.00 1.00 1000000
+ 0.64 1.00 1.00 8071429
+ 0.64 1.00 1.00 15142857
+ 0.64 1.00 1.00 22214286
+ 0.64 1.00 1.00 29285714
+ 0.64 1.00 1.00 36357143
+ 0.64 1.00 1.00 43428571
+ 0.64 1.00 1.00 50500000
+ 0.64 1.00 1.00 57571429
+ 0.64 1.00 1.00 64642857
+ 0.64 1.00 1.00 71714286
+ 0.64 1.00 1.00 78785714
+ 0.64 1.00 1.00 85857143
+ 0.64 1.00 1.00 92928571
+ 0.64 1.00 1.00 100000000
+ 0.71 0.00 0.00 1000000
+ 0.71 0.00 0.00 8071429
+ 0.71 0.00 0.00 15142857
+ 0.71 0.00 0.00 22214286
+ 0.71 0.00 0.00 29285714
+ 0.71 0.00 0.00 36357143
+ 0.71 0.00 0.00 43428571
+ 0.71 0.00 0.00 50500000
+ 0.71 0.00 0.00 57571429
+ 0.71 0.00 0.00 64642857
+ 0.71 0.00 0.00 71714286
+ 0.71 0.00 0.00 78785714
+ 0.71 0.00 0.00 85857143
+ 0.71 0.00 0.00 92928571
+ 0.71 0.00 0.00 100000000
+ 0.71 0.00 0.07 1000000
+ 0.71 0.00 0.07 8071429
+ 0.71 0.00 0.07 15142857
+ 0.71 0.00 0.07 22214286
+ 0.71 0.00 0.07 29285714
+ 0.71 0.00 0.07 36357143
+ 0.71 0.00 0.07 43428571
+ 0.71 0.00 0.07 50500000
+ 0.71 0.00 0.07 57571429
+ 0.71 0.00 0.07 64642857
+ 0.71 0.00 0.07 71714286
+ 0.71 0.00 0.07 78785714
+ 0.71 0.00 0.07 85857143
+ 0.71 0.00 0.07 92928571
+ 0.71 0.00 0.07 100000000
+ 0.71 0.00 0.14 1000000
+ 0.71 0.00 0.14 8071429
+ 0.71 0.00 0.14 15142857
+ 0.71 0.00 0.14 22214286
+ 0.71 0.00 0.14 29285714
+ 0.71 0.00 0.14 36357143
+ 0.71 0.00 0.14 43428571
+ 0.71 0.00 0.14 50500000
+ 0.71 0.00 0.14 57571429
+ 0.71 0.00 0.14 64642857
+ 0.71 0.00 0.14 71714286
+ 0.71 0.00 0.14 78785714
+ 0.71 0.00 0.14 85857143
+ 0.71 0.00 0.14 92928571
+ 0.71 0.00 0.14 100000000
+ 0.71 0.00 0.21 1000000
+ 0.71 0.00 0.21 8071429
+ 0.71 0.00 0.21 15142857
+ 0.71 0.00 0.21 22214286
+ 0.71 0.00 0.21 29285714
+ 0.71 0.00 0.21 36357143
+ 0.71 0.00 0.21 43428571
+ 0.71 0.00 0.21 50500000
+ 0.71 0.00 0.21 57571429
+ 0.71 0.00 0.21 64642857
+ 0.71 0.00 0.21 71714286
+ 0.71 0.00 0.21 78785714
+ 0.71 0.00 0.21 85857143
+ 0.71 0.00 0.21 92928571
+ 0.71 0.00 0.21 100000000
+ 0.71 0.00 0.29 1000000
+ 0.71 0.00 0.29 8071429
+ 0.71 0.00 0.29 15142857
+ 0.71 0.00 0.29 22214286
+ 0.71 0.00 0.29 29285714
+ 0.71 0.00 0.29 36357143
+ 0.71 0.00 0.29 43428571
+ 0.71 0.00 0.29 50500000
+ 0.71 0.00 0.29 57571429
+ 0.71 0.00 0.29 64642857
+ 0.71 0.00 0.29 71714286
+ 0.71 0.00 0.29 78785714
+ 0.71 0.00 0.29 85857143
+ 0.71 0.00 0.29 92928571
+ 0.71 0.00 0.29 100000000
+ 0.71 0.00 0.36 1000000
+ 0.71 0.00 0.36 8071429
+ 0.71 0.00 0.36 15142857
+ 0.71 0.00 0.36 22214286
+ 0.71 0.00 0.36 29285714
+ 0.71 0.00 0.36 36357143
+ 0.71 0.00 0.36 43428571
+ 0.71 0.00 0.36 50500000
+ 0.71 0.00 0.36 57571429
+ 0.71 0.00 0.36 64642857
+ 0.71 0.00 0.36 71714286
+ 0.71 0.00 0.36 78785714
+ 0.71 0.00 0.36 85857143
+ 0.71 0.00 0.36 92928571
+ 0.71 0.00 0.36 100000000
+ 0.71 0.00 0.43 1000000
+ 0.71 0.00 0.43 8071429
+ 0.71 0.00 0.43 15142857
+ 0.71 0.00 0.43 22214286
+ 0.71 0.00 0.43 29285714
+ 0.71 0.00 0.43 36357143
+ 0.71 0.00 0.43 43428571
+ 0.71 0.00 0.43 50500000
+ 0.71 0.00 0.43 57571429
+ 0.71 0.00 0.43 64642857
+ 0.71 0.00 0.43 71714286
+ 0.71 0.00 0.43 78785714
+ 0.71 0.00 0.43 85857143
+ 0.71 0.00 0.43 92928571
+ 0.71 0.00 0.43 100000000
+ 0.71 0.00 0.50 1000000
+ 0.71 0.00 0.50 8071429
+ 0.71 0.00 0.50 15142857
+ 0.71 0.00 0.50 22214286
+ 0.71 0.00 0.50 29285714
+ 0.71 0.00 0.50 36357143
+ 0.71 0.00 0.50 43428571
+ 0.71 0.00 0.50 50500000
+ 0.71 0.00 0.50 57571429
+ 0.71 0.00 0.50 64642857
+ 0.71 0.00 0.50 71714286
+ 0.71 0.00 0.50 78785714
+ 0.71 0.00 0.50 85857143
+ 0.71 0.00 0.50 92928571
+ 0.71 0.00 0.50 100000000
+ 0.71 0.00 0.57 1000000
+ 0.71 0.00 0.57 8071429
+ 0.71 0.00 0.57 15142857
+ 0.71 0.00 0.57 22214286
+ 0.71 0.00 0.57 29285714
+ 0.71 0.00 0.57 36357143
+ 0.71 0.00 0.57 43428571
+ 0.71 0.00 0.57 50500000
+ 0.71 0.00 0.57 57571429
+ 0.71 0.00 0.57 64642857
+ 0.71 0.00 0.57 71714286
+ 0.71 0.00 0.57 78785714
+ 0.71 0.00 0.57 85857143
+ 0.71 0.00 0.57 92928571
+ 0.71 0.00 0.57 100000000
+ 0.71 0.00 0.64 1000000
+ 0.71 0.00 0.64 8071429
+ 0.71 0.00 0.64 15142857
+ 0.71 0.00 0.64 22214286
+ 0.71 0.00 0.64 29285714
+ 0.71 0.00 0.64 36357143
+ 0.71 0.00 0.64 43428571
+ 0.71 0.00 0.64 50500000
+ 0.71 0.00 0.64 57571429
+ 0.71 0.00 0.64 64642857
+ 0.71 0.00 0.64 71714286
+ 0.71 0.00 0.64 78785714
+ 0.71 0.00 0.64 85857143
+ 0.71 0.00 0.64 92928571
+ 0.71 0.00 0.64 100000000
+ 0.71 0.00 0.71 1000000
+ 0.71 0.00 0.71 8071429
+ 0.71 0.00 0.71 15142857
+ 0.71 0.00 0.71 22214286
+ 0.71 0.00 0.71 29285714
+ 0.71 0.00 0.71 36357143
+ 0.71 0.00 0.71 43428571
+ 0.71 0.00 0.71 50500000
+ 0.71 0.00 0.71 57571429
+ 0.71 0.00 0.71 64642857
+ 0.71 0.00 0.71 71714286
+ 0.71 0.00 0.71 78785714
+ 0.71 0.00 0.71 85857143
+ 0.71 0.00 0.71 92928571
+ 0.71 0.00 0.71 100000000
+ 0.71 0.00 0.79 1000000
+ 0.71 0.00 0.79 8071429
+ 0.71 0.00 0.79 15142857
+ 0.71 0.00 0.79 22214286
+ 0.71 0.00 0.79 29285714
+ 0.71 0.00 0.79 36357143
+ 0.71 0.00 0.79 43428571
+ 0.71 0.00 0.79 50500000
+ 0.71 0.00 0.79 57571429
+ 0.71 0.00 0.79 64642857
+ 0.71 0.00 0.79 71714286
+ 0.71 0.00 0.79 78785714
+ 0.71 0.00 0.79 85857143
+ 0.71 0.00 0.79 92928571
+ 0.71 0.00 0.79 100000000
+ 0.71 0.00 0.86 1000000
+ 0.71 0.00 0.86 8071429
+ 0.71 0.00 0.86 15142857
+ 0.71 0.00 0.86 22214286
+ 0.71 0.00 0.86 29285714
+ 0.71 0.00 0.86 36357143
+ 0.71 0.00 0.86 43428571
+ 0.71 0.00 0.86 50500000
+ 0.71 0.00 0.86 57571429
+ 0.71 0.00 0.86 64642857
+ 0.71 0.00 0.86 71714286
+ 0.71 0.00 0.86 78785714
+ 0.71 0.00 0.86 85857143
+ 0.71 0.00 0.86 92928571
+ 0.71 0.00 0.86 100000000
+ 0.71 0.00 0.93 1000000
+ 0.71 0.00 0.93 8071429
+ 0.71 0.00 0.93 15142857
+ 0.71 0.00 0.93 22214286
+ 0.71 0.00 0.93 29285714
+ 0.71 0.00 0.93 36357143
+ 0.71 0.00 0.93 43428571
+ 0.71 0.00 0.93 50500000
+ 0.71 0.00 0.93 57571429
+ 0.71 0.00 0.93 64642857
+ 0.71 0.00 0.93 71714286
+ 0.71 0.00 0.93 78785714
+ 0.71 0.00 0.93 85857143
+ 0.71 0.00 0.93 92928571
+ 0.71 0.00 0.93 100000000
+ 0.71 0.00 1.00 1000000
+ 0.71 0.00 1.00 8071429
+ 0.71 0.00 1.00 15142857
+ 0.71 0.00 1.00 22214286
+ 0.71 0.00 1.00 29285714
+ 0.71 0.00 1.00 36357143
+ 0.71 0.00 1.00 43428571
+ 0.71 0.00 1.00 50500000
+ 0.71 0.00 1.00 57571429
+ 0.71 0.00 1.00 64642857
+ 0.71 0.00 1.00 71714286
+ 0.71 0.00 1.00 78785714
+ 0.71 0.00 1.00 85857143
+ 0.71 0.00 1.00 92928571
+ 0.71 0.00 1.00 100000000
+ 0.71 0.07 0.00 1000000
+ 0.71 0.07 0.00 8071429
+ 0.71 0.07 0.00 15142857
+ 0.71 0.07 0.00 22214286
+ 0.71 0.07 0.00 29285714
+ 0.71 0.07 0.00 36357143
+ 0.71 0.07 0.00 43428571
+ 0.71 0.07 0.00 50500000
+ 0.71 0.07 0.00 57571429
+ 0.71 0.07 0.00 64642857
+ 0.71 0.07 0.00 71714286
+ 0.71 0.07 0.00 78785714
+ 0.71 0.07 0.00 85857143
+ 0.71 0.07 0.00 92928571
+ 0.71 0.07 0.00 100000000
+ 0.71 0.07 0.07 1000000
+ 0.71 0.07 0.07 8071429
+ 0.71 0.07 0.07 15142857
+ 0.71 0.07 0.07 22214286
+ 0.71 0.07 0.07 29285714
+ 0.71 0.07 0.07 36357143
+ 0.71 0.07 0.07 43428571
+ 0.71 0.07 0.07 50500000
+ 0.71 0.07 0.07 57571429
+ 0.71 0.07 0.07 64642857
+ 0.71 0.07 0.07 71714286
+ 0.71 0.07 0.07 78785714
+ 0.71 0.07 0.07 85857143
+ 0.71 0.07 0.07 92928571
+ 0.71 0.07 0.07 100000000
+ 0.71 0.07 0.14 1000000
+ 0.71 0.07 0.14 8071429
+ 0.71 0.07 0.14 15142857
+ 0.71 0.07 0.14 22214286
+ 0.71 0.07 0.14 29285714
+ 0.71 0.07 0.14 36357143
+ 0.71 0.07 0.14 43428571
+ 0.71 0.07 0.14 50500000
+ 0.71 0.07 0.14 57571429
+ 0.71 0.07 0.14 64642857
+ 0.71 0.07 0.14 71714286
+ 0.71 0.07 0.14 78785714
+ 0.71 0.07 0.14 85857143
+ 0.71 0.07 0.14 92928571
+ 0.71 0.07 0.14 100000000
+ 0.71 0.07 0.21 1000000
+ 0.71 0.07 0.21 8071429
+ 0.71 0.07 0.21 15142857
+ 0.71 0.07 0.21 22214286
+ 0.71 0.07 0.21 29285714
+ 0.71 0.07 0.21 36357143
+ 0.71 0.07 0.21 43428571
+ 0.71 0.07 0.21 50500000
+ 0.71 0.07 0.21 57571429
+ 0.71 0.07 0.21 64642857
+ 0.71 0.07 0.21 71714286
+ 0.71 0.07 0.21 78785714
+ 0.71 0.07 0.21 85857143
+ 0.71 0.07 0.21 92928571
+ 0.71 0.07 0.21 100000000
+ 0.71 0.07 0.29 1000000
+ 0.71 0.07 0.29 8071429
+ 0.71 0.07 0.29 15142857
+ 0.71 0.07 0.29 22214286
+ 0.71 0.07 0.29 29285714
+ 0.71 0.07 0.29 36357143
+ 0.71 0.07 0.29 43428571
+ 0.71 0.07 0.29 50500000
+ 0.71 0.07 0.29 57571429
+ 0.71 0.07 0.29 64642857
+ 0.71 0.07 0.29 71714286
+ 0.71 0.07 0.29 78785714
+ 0.71 0.07 0.29 85857143
+ 0.71 0.07 0.29 92928571
+ 0.71 0.07 0.29 100000000
+ 0.71 0.07 0.36 1000000
+ 0.71 0.07 0.36 8071429
+ 0.71 0.07 0.36 15142857
+ 0.71 0.07 0.36 22214286
+ 0.71 0.07 0.36 29285714
+ 0.71 0.07 0.36 36357143
+ 0.71 0.07 0.36 43428571
+ 0.71 0.07 0.36 50500000
+ 0.71 0.07 0.36 57571429
+ 0.71 0.07 0.36 64642857
+ 0.71 0.07 0.36 71714286
+ 0.71 0.07 0.36 78785714
+ 0.71 0.07 0.36 85857143
+ 0.71 0.07 0.36 92928571
+ 0.71 0.07 0.36 100000000
+ 0.71 0.07 0.43 1000000
+ 0.71 0.07 0.43 8071429
+ 0.71 0.07 0.43 15142857
+ 0.71 0.07 0.43 22214286
+ 0.71 0.07 0.43 29285714
+ 0.71 0.07 0.43 36357143
+ 0.71 0.07 0.43 43428571
+ 0.71 0.07 0.43 50500000
+ 0.71 0.07 0.43 57571429
+ 0.71 0.07 0.43 64642857
+ 0.71 0.07 0.43 71714286
+ 0.71 0.07 0.43 78785714
+ 0.71 0.07 0.43 85857143
+ 0.71 0.07 0.43 92928571
+ 0.71 0.07 0.43 100000000
+ 0.71 0.07 0.50 1000000
+ 0.71 0.07 0.50 8071429
+ 0.71 0.07 0.50 15142857
+ 0.71 0.07 0.50 22214286
+ 0.71 0.07 0.50 29285714
+ 0.71 0.07 0.50 36357143
+ 0.71 0.07 0.50 43428571
+ 0.71 0.07 0.50 50500000
+ 0.71 0.07 0.50 57571429
+ 0.71 0.07 0.50 64642857
+ 0.71 0.07 0.50 71714286
+ 0.71 0.07 0.50 78785714
+ 0.71 0.07 0.50 85857143
+ 0.71 0.07 0.50 92928571
+ 0.71 0.07 0.50 100000000
+ 0.71 0.07 0.57 1000000
+ 0.71 0.07 0.57 8071429
+ 0.71 0.07 0.57 15142857
+ 0.71 0.07 0.57 22214286
+ 0.71 0.07 0.57 29285714
+ 0.71 0.07 0.57 36357143
+ 0.71 0.07 0.57 43428571
+ 0.71 0.07 0.57 50500000
+ 0.71 0.07 0.57 57571429
+ 0.71 0.07 0.57 64642857
+ 0.71 0.07 0.57 71714286
+ 0.71 0.07 0.57 78785714
+ 0.71 0.07 0.57 85857143
+ 0.71 0.07 0.57 92928571
+ 0.71 0.07 0.57 100000000
+ 0.71 0.07 0.64 1000000
+ 0.71 0.07 0.64 8071429
+ 0.71 0.07 0.64 15142857
+ 0.71 0.07 0.64 22214286
+ 0.71 0.07 0.64 29285714
+ 0.71 0.07 0.64 36357143
+ 0.71 0.07 0.64 43428571
+ 0.71 0.07 0.64 50500000
+ 0.71 0.07 0.64 57571429
+ 0.71 0.07 0.64 64642857
+ 0.71 0.07 0.64 71714286
+ 0.71 0.07 0.64 78785714
+ 0.71 0.07 0.64 85857143
+ 0.71 0.07 0.64 92928571
+ 0.71 0.07 0.64 100000000
+ 0.71 0.07 0.71 1000000
+ 0.71 0.07 0.71 8071429
+ 0.71 0.07 0.71 15142857
+ 0.71 0.07 0.71 22214286
+ 0.71 0.07 0.71 29285714
+ 0.71 0.07 0.71 36357143
+ 0.71 0.07 0.71 43428571
+ 0.71 0.07 0.71 50500000
+ 0.71 0.07 0.71 57571429
+ 0.71 0.07 0.71 64642857
+ 0.71 0.07 0.71 71714286
+ 0.71 0.07 0.71 78785714
+ 0.71 0.07 0.71 85857143
+ 0.71 0.07 0.71 92928571
+ 0.71 0.07 0.71 100000000
+ 0.71 0.07 0.79 1000000
+ 0.71 0.07 0.79 8071429
+ 0.71 0.07 0.79 15142857
+ 0.71 0.07 0.79 22214286
+ 0.71 0.07 0.79 29285714
+ 0.71 0.07 0.79 36357143
+ 0.71 0.07 0.79 43428571
+ 0.71 0.07 0.79 50500000
+ 0.71 0.07 0.79 57571429
+ 0.71 0.07 0.79 64642857
+ 0.71 0.07 0.79 71714286
+ 0.71 0.07 0.79 78785714
+ 0.71 0.07 0.79 85857143
+ 0.71 0.07 0.79 92928571
+ 0.71 0.07 0.79 100000000
+ 0.71 0.07 0.86 1000000
+ 0.71 0.07 0.86 8071429
+ 0.71 0.07 0.86 15142857
+ 0.71 0.07 0.86 22214286
+ 0.71 0.07 0.86 29285714
+ 0.71 0.07 0.86 36357143
+ 0.71 0.07 0.86 43428571
+ 0.71 0.07 0.86 50500000
+ 0.71 0.07 0.86 57571429
+ 0.71 0.07 0.86 64642857
+ 0.71 0.07 0.86 71714286
+ 0.71 0.07 0.86 78785714
+ 0.71 0.07 0.86 85857143
+ 0.71 0.07 0.86 92928571
+ 0.71 0.07 0.86 100000000
+ 0.71 0.07 0.93 1000000
+ 0.71 0.07 0.93 8071429
+ 0.71 0.07 0.93 15142857
+ 0.71 0.07 0.93 22214286
+ 0.71 0.07 0.93 29285714
+ 0.71 0.07 0.93 36357143
+ 0.71 0.07 0.93 43428571
+ 0.71 0.07 0.93 50500000
+ 0.71 0.07 0.93 57571429
+ 0.71 0.07 0.93 64642857
+ 0.71 0.07 0.93 71714286
+ 0.71 0.07 0.93 78785714
+ 0.71 0.07 0.93 85857143
+ 0.71 0.07 0.93 92928571
+ 0.71 0.07 0.93 100000000
+ 0.71 0.07 1.00 1000000
+ 0.71 0.07 1.00 8071429
+ 0.71 0.07 1.00 15142857
+ 0.71 0.07 1.00 22214286
+ 0.71 0.07 1.00 29285714
+ 0.71 0.07 1.00 36357143
+ 0.71 0.07 1.00 43428571
+ 0.71 0.07 1.00 50500000
+ 0.71 0.07 1.00 57571429
+ 0.71 0.07 1.00 64642857
+ 0.71 0.07 1.00 71714286
+ 0.71 0.07 1.00 78785714
+ 0.71 0.07 1.00 85857143
+ 0.71 0.07 1.00 92928571
+ 0.71 0.07 1.00 100000000
+ 0.71 0.14 0.00 1000000
+ 0.71 0.14 0.00 8071429
+ 0.71 0.14 0.00 15142857
+ 0.71 0.14 0.00 22214286
+ 0.71 0.14 0.00 29285714
+ 0.71 0.14 0.00 36357143
+ 0.71 0.14 0.00 43428571
+ 0.71 0.14 0.00 50500000
+ 0.71 0.14 0.00 57571429
+ 0.71 0.14 0.00 64642857
+ 0.71 0.14 0.00 71714286
+ 0.71 0.14 0.00 78785714
+ 0.71 0.14 0.00 85857143
+ 0.71 0.14 0.00 92928571
+ 0.71 0.14 0.00 100000000
+ 0.71 0.14 0.07 1000000
+ 0.71 0.14 0.07 8071429
+ 0.71 0.14 0.07 15142857
+ 0.71 0.14 0.07 22214286
+ 0.71 0.14 0.07 29285714
+ 0.71 0.14 0.07 36357143
+ 0.71 0.14 0.07 43428571
+ 0.71 0.14 0.07 50500000
+ 0.71 0.14 0.07 57571429
+ 0.71 0.14 0.07 64642857
+ 0.71 0.14 0.07 71714286
+ 0.71 0.14 0.07 78785714
+ 0.71 0.14 0.07 85857143
+ 0.71 0.14 0.07 92928571
+ 0.71 0.14 0.07 100000000
+ 0.71 0.14 0.14 1000000
+ 0.71 0.14 0.14 8071429
+ 0.71 0.14 0.14 15142857
+ 0.71 0.14 0.14 22214286
+ 0.71 0.14 0.14 29285714
+ 0.71 0.14 0.14 36357143
+ 0.71 0.14 0.14 43428571
+ 0.71 0.14 0.14 50500000
+ 0.71 0.14 0.14 57571429
+ 0.71 0.14 0.14 64642857
+ 0.71 0.14 0.14 71714286
+ 0.71 0.14 0.14 78785714
+ 0.71 0.14 0.14 85857143
+ 0.71 0.14 0.14 92928571
+ 0.71 0.14 0.14 100000000
+ 0.71 0.14 0.21 1000000
+ 0.71 0.14 0.21 8071429
+ 0.71 0.14 0.21 15142857
+ 0.71 0.14 0.21 22214286
+ 0.71 0.14 0.21 29285714
+ 0.71 0.14 0.21 36357143
+ 0.71 0.14 0.21 43428571
+ 0.71 0.14 0.21 50500000
+ 0.71 0.14 0.21 57571429
+ 0.71 0.14 0.21 64642857
+ 0.71 0.14 0.21 71714286
+ 0.71 0.14 0.21 78785714
+ 0.71 0.14 0.21 85857143
+ 0.71 0.14 0.21 92928571
+ 0.71 0.14 0.21 100000000
+ 0.71 0.14 0.29 1000000
+ 0.71 0.14 0.29 8071429
+ 0.71 0.14 0.29 15142857
+ 0.71 0.14 0.29 22214286
+ 0.71 0.14 0.29 29285714
+ 0.71 0.14 0.29 36357143
+ 0.71 0.14 0.29 43428571
+ 0.71 0.14 0.29 50500000
+ 0.71 0.14 0.29 57571429
+ 0.71 0.14 0.29 64642857
+ 0.71 0.14 0.29 71714286
+ 0.71 0.14 0.29 78785714
+ 0.71 0.14 0.29 85857143
+ 0.71 0.14 0.29 92928571
+ 0.71 0.14 0.29 100000000
+ 0.71 0.14 0.36 1000000
+ 0.71 0.14 0.36 8071429
+ 0.71 0.14 0.36 15142857
+ 0.71 0.14 0.36 22214286
+ 0.71 0.14 0.36 29285714
+ 0.71 0.14 0.36 36357143
+ 0.71 0.14 0.36 43428571
+ 0.71 0.14 0.36 50500000
+ 0.71 0.14 0.36 57571429
+ 0.71 0.14 0.36 64642857
+ 0.71 0.14 0.36 71714286
+ 0.71 0.14 0.36 78785714
+ 0.71 0.14 0.36 85857143
+ 0.71 0.14 0.36 92928571
+ 0.71 0.14 0.36 100000000
+ 0.71 0.14 0.43 1000000
+ 0.71 0.14 0.43 8071429
+ 0.71 0.14 0.43 15142857
+ 0.71 0.14 0.43 22214286
+ 0.71 0.14 0.43 29285714
+ 0.71 0.14 0.43 36357143
+ 0.71 0.14 0.43 43428571
+ 0.71 0.14 0.43 50500000
+ 0.71 0.14 0.43 57571429
+ 0.71 0.14 0.43 64642857
+ 0.71 0.14 0.43 71714286
+ 0.71 0.14 0.43 78785714
+ 0.71 0.14 0.43 85857143
+ 0.71 0.14 0.43 92928571
+ 0.71 0.14 0.43 100000000
+ 0.71 0.14 0.50 1000000
+ 0.71 0.14 0.50 8071429
+ 0.71 0.14 0.50 15142857
+ 0.71 0.14 0.50 22214286
+ 0.71 0.14 0.50 29285714
+ 0.71 0.14 0.50 36357143
+ 0.71 0.14 0.50 43428571
+ 0.71 0.14 0.50 50500000
+ 0.71 0.14 0.50 57571429
+ 0.71 0.14 0.50 64642857
+ 0.71 0.14 0.50 71714286
+ 0.71 0.14 0.50 78785714
+ 0.71 0.14 0.50 85857143
+ 0.71 0.14 0.50 92928571
+ 0.71 0.14 0.50 100000000
+ 0.71 0.14 0.57 1000000
+ 0.71 0.14 0.57 8071429
+ 0.71 0.14 0.57 15142857
+ 0.71 0.14 0.57 22214286
+ 0.71 0.14 0.57 29285714
+ 0.71 0.14 0.57 36357143
+ 0.71 0.14 0.57 43428571
+ 0.71 0.14 0.57 50500000
+ 0.71 0.14 0.57 57571429
+ 0.71 0.14 0.57 64642857
+ 0.71 0.14 0.57 71714286
+ 0.71 0.14 0.57 78785714
+ 0.71 0.14 0.57 85857143
+ 0.71 0.14 0.57 92928571
+ 0.71 0.14 0.57 100000000
+ 0.71 0.14 0.64 1000000
+ 0.71 0.14 0.64 8071429
+ 0.71 0.14 0.64 15142857
+ 0.71 0.14 0.64 22214286
+ 0.71 0.14 0.64 29285714
+ 0.71 0.14 0.64 36357143
+ 0.71 0.14 0.64 43428571
+ 0.71 0.14 0.64 50500000
+ 0.71 0.14 0.64 57571429
+ 0.71 0.14 0.64 64642857
+ 0.71 0.14 0.64 71714286
+ 0.71 0.14 0.64 78785714
+ 0.71 0.14 0.64 85857143
+ 0.71 0.14 0.64 92928571
+ 0.71 0.14 0.64 100000000
+ 0.71 0.14 0.71 1000000
+ 0.71 0.14 0.71 8071429
+ 0.71 0.14 0.71 15142857
+ 0.71 0.14 0.71 22214286
+ 0.71 0.14 0.71 29285714
+ 0.71 0.14 0.71 36357143
+ 0.71 0.14 0.71 43428571
+ 0.71 0.14 0.71 50500000
+ 0.71 0.14 0.71 57571429
+ 0.71 0.14 0.71 64642857
+ 0.71 0.14 0.71 71714286
+ 0.71 0.14 0.71 78785714
+ 0.71 0.14 0.71 85857143
+ 0.71 0.14 0.71 92928571
+ 0.71 0.14 0.71 100000000
+ 0.71 0.14 0.79 1000000
+ 0.71 0.14 0.79 8071429
+ 0.71 0.14 0.79 15142857
+ 0.71 0.14 0.79 22214286
+ 0.71 0.14 0.79 29285714
+ 0.71 0.14 0.79 36357143
+ 0.71 0.14 0.79 43428571
+ 0.71 0.14 0.79 50500000
+ 0.71 0.14 0.79 57571429
+ 0.71 0.14 0.79 64642857
+ 0.71 0.14 0.79 71714286
+ 0.71 0.14 0.79 78785714
+ 0.71 0.14 0.79 85857143
+ 0.71 0.14 0.79 92928571
+ 0.71 0.14 0.79 100000000
+ 0.71 0.14 0.86 1000000
+ 0.71 0.14 0.86 8071429
+ 0.71 0.14 0.86 15142857
+ 0.71 0.14 0.86 22214286
+ 0.71 0.14 0.86 29285714
+ 0.71 0.14 0.86 36357143
+ 0.71 0.14 0.86 43428571
+ 0.71 0.14 0.86 50500000
+ 0.71 0.14 0.86 57571429
+ 0.71 0.14 0.86 64642857
+ 0.71 0.14 0.86 71714286
+ 0.71 0.14 0.86 78785714
+ 0.71 0.14 0.86 85857143
+ 0.71 0.14 0.86 92928571
+ 0.71 0.14 0.86 100000000
+ 0.71 0.14 0.93 1000000
+ 0.71 0.14 0.93 8071429
+ 0.71 0.14 0.93 15142857
+ 0.71 0.14 0.93 22214286
+ 0.71 0.14 0.93 29285714
+ 0.71 0.14 0.93 36357143
+ 0.71 0.14 0.93 43428571
+ 0.71 0.14 0.93 50500000
+ 0.71 0.14 0.93 57571429
+ 0.71 0.14 0.93 64642857
+ 0.71 0.14 0.93 71714286
+ 0.71 0.14 0.93 78785714
+ 0.71 0.14 0.93 85857143
+ 0.71 0.14 0.93 92928571
+ 0.71 0.14 0.93 100000000
+ 0.71 0.14 1.00 1000000
+ 0.71 0.14 1.00 8071429
+ 0.71 0.14 1.00 15142857
+ 0.71 0.14 1.00 22214286
+ 0.71 0.14 1.00 29285714
+ 0.71 0.14 1.00 36357143
+ 0.71 0.14 1.00 43428571
+ 0.71 0.14 1.00 50500000
+ 0.71 0.14 1.00 57571429
+ 0.71 0.14 1.00 64642857
+ 0.71 0.14 1.00 71714286
+ 0.71 0.14 1.00 78785714
+ 0.71 0.14 1.00 85857143
+ 0.71 0.14 1.00 92928571
+ 0.71 0.14 1.00 100000000
+ 0.71 0.21 0.00 1000000
+ 0.71 0.21 0.00 8071429
+ 0.71 0.21 0.00 15142857
+ 0.71 0.21 0.00 22214286
+ 0.71 0.21 0.00 29285714
+ 0.71 0.21 0.00 36357143
+ 0.71 0.21 0.00 43428571
+ 0.71 0.21 0.00 50500000
+ 0.71 0.21 0.00 57571429
+ 0.71 0.21 0.00 64642857
+ 0.71 0.21 0.00 71714286
+ 0.71 0.21 0.00 78785714
+ 0.71 0.21 0.00 85857143
+ 0.71 0.21 0.00 92928571
+ 0.71 0.21 0.00 100000000
+ 0.71 0.21 0.07 1000000
+ 0.71 0.21 0.07 8071429
+ 0.71 0.21 0.07 15142857
+ 0.71 0.21 0.07 22214286
+ 0.71 0.21 0.07 29285714
+ 0.71 0.21 0.07 36357143
+ 0.71 0.21 0.07 43428571
+ 0.71 0.21 0.07 50500000
+ 0.71 0.21 0.07 57571429
+ 0.71 0.21 0.07 64642857
+ 0.71 0.21 0.07 71714286
+ 0.71 0.21 0.07 78785714
+ 0.71 0.21 0.07 85857143
+ 0.71 0.21 0.07 92928571
+ 0.71 0.21 0.07 100000000
+ 0.71 0.21 0.14 1000000
+ 0.71 0.21 0.14 8071429
+ 0.71 0.21 0.14 15142857
+ 0.71 0.21 0.14 22214286
+ 0.71 0.21 0.14 29285714
+ 0.71 0.21 0.14 36357143
+ 0.71 0.21 0.14 43428571
+ 0.71 0.21 0.14 50500000
+ 0.71 0.21 0.14 57571429
+ 0.71 0.21 0.14 64642857
+ 0.71 0.21 0.14 71714286
+ 0.71 0.21 0.14 78785714
+ 0.71 0.21 0.14 85857143
+ 0.71 0.21 0.14 92928571
+ 0.71 0.21 0.14 100000000
+ 0.71 0.21 0.21 1000000
+ 0.71 0.21 0.21 8071429
+ 0.71 0.21 0.21 15142857
+ 0.71 0.21 0.21 22214286
+ 0.71 0.21 0.21 29285714
+ 0.71 0.21 0.21 36357143
+ 0.71 0.21 0.21 43428571
+ 0.71 0.21 0.21 50500000
+ 0.71 0.21 0.21 57571429
+ 0.71 0.21 0.21 64642857
+ 0.71 0.21 0.21 71714286
+ 0.71 0.21 0.21 78785714
+ 0.71 0.21 0.21 85857143
+ 0.71 0.21 0.21 92928571
+ 0.71 0.21 0.21 100000000
+ 0.71 0.21 0.29 1000000
+ 0.71 0.21 0.29 8071429
+ 0.71 0.21 0.29 15142857
+ 0.71 0.21 0.29 22214286
+ 0.71 0.21 0.29 29285714
+ 0.71 0.21 0.29 36357143
+ 0.71 0.21 0.29 43428571
+ 0.71 0.21 0.29 50500000
+ 0.71 0.21 0.29 57571429
+ 0.71 0.21 0.29 64642857
+ 0.71 0.21 0.29 71714286
+ 0.71 0.21 0.29 78785714
+ 0.71 0.21 0.29 85857143
+ 0.71 0.21 0.29 92928571
+ 0.71 0.21 0.29 100000000
+ 0.71 0.21 0.36 1000000
+ 0.71 0.21 0.36 8071429
+ 0.71 0.21 0.36 15142857
+ 0.71 0.21 0.36 22214286
+ 0.71 0.21 0.36 29285714
+ 0.71 0.21 0.36 36357143
+ 0.71 0.21 0.36 43428571
+ 0.71 0.21 0.36 50500000
+ 0.71 0.21 0.36 57571429
+ 0.71 0.21 0.36 64642857
+ 0.71 0.21 0.36 71714286
+ 0.71 0.21 0.36 78785714
+ 0.71 0.21 0.36 85857143
+ 0.71 0.21 0.36 92928571
+ 0.71 0.21 0.36 100000000
+ 0.71 0.21 0.43 1000000
+ 0.71 0.21 0.43 8071429
+ 0.71 0.21 0.43 15142857
+ 0.71 0.21 0.43 22214286
+ 0.71 0.21 0.43 29285714
+ 0.71 0.21 0.43 36357143
+ 0.71 0.21 0.43 43428571
+ 0.71 0.21 0.43 50500000
+ 0.71 0.21 0.43 57571429
+ 0.71 0.21 0.43 64642857
+ 0.71 0.21 0.43 71714286
+ 0.71 0.21 0.43 78785714
+ 0.71 0.21 0.43 85857143
+ 0.71 0.21 0.43 92928571
+ 0.71 0.21 0.43 100000000
+ 0.71 0.21 0.50 1000000
+ 0.71 0.21 0.50 8071429
+ 0.71 0.21 0.50 15142857
+ 0.71 0.21 0.50 22214286
+ 0.71 0.21 0.50 29285714
+ 0.71 0.21 0.50 36357143
+ 0.71 0.21 0.50 43428571
+ 0.71 0.21 0.50 50500000
+ 0.71 0.21 0.50 57571429
+ 0.71 0.21 0.50 64642857
+ 0.71 0.21 0.50 71714286
+ 0.71 0.21 0.50 78785714
+ 0.71 0.21 0.50 85857143
+ 0.71 0.21 0.50 92928571
+ 0.71 0.21 0.50 100000000
+ 0.71 0.21 0.57 1000000
+ 0.71 0.21 0.57 8071429
+ 0.71 0.21 0.57 15142857
+ 0.71 0.21 0.57 22214286
+ 0.71 0.21 0.57 29285714
+ 0.71 0.21 0.57 36357143
+ 0.71 0.21 0.57 43428571
+ 0.71 0.21 0.57 50500000
+ 0.71 0.21 0.57 57571429
+ 0.71 0.21 0.57 64642857
+ 0.71 0.21 0.57 71714286
+ 0.71 0.21 0.57 78785714
+ 0.71 0.21 0.57 85857143
+ 0.71 0.21 0.57 92928571
+ 0.71 0.21 0.57 100000000
+ 0.71 0.21 0.64 1000000
+ 0.71 0.21 0.64 8071429
+ 0.71 0.21 0.64 15142857
+ 0.71 0.21 0.64 22214286
+ 0.71 0.21 0.64 29285714
+ 0.71 0.21 0.64 36357143
+ 0.71 0.21 0.64 43428571
+ 0.71 0.21 0.64 50500000
+ 0.71 0.21 0.64 57571429
+ 0.71 0.21 0.64 64642857
+ 0.71 0.21 0.64 71714286
+ 0.71 0.21 0.64 78785714
+ 0.71 0.21 0.64 85857143
+ 0.71 0.21 0.64 92928571
+ 0.71 0.21 0.64 100000000
+ 0.71 0.21 0.71 1000000
+ 0.71 0.21 0.71 8071429
+ 0.71 0.21 0.71 15142857
+ 0.71 0.21 0.71 22214286
+ 0.71 0.21 0.71 29285714
+ 0.71 0.21 0.71 36357143
+ 0.71 0.21 0.71 43428571
+ 0.71 0.21 0.71 50500000
+ 0.71 0.21 0.71 57571429
+ 0.71 0.21 0.71 64642857
+ 0.71 0.21 0.71 71714286
+ 0.71 0.21 0.71 78785714
+ 0.71 0.21 0.71 85857143
+ 0.71 0.21 0.71 92928571
+ 0.71 0.21 0.71 100000000
+ 0.71 0.21 0.79 1000000
+ 0.71 0.21 0.79 8071429
+ 0.71 0.21 0.79 15142857
+ 0.71 0.21 0.79 22214286
+ 0.71 0.21 0.79 29285714
+ 0.71 0.21 0.79 36357143
+ 0.71 0.21 0.79 43428571
+ 0.71 0.21 0.79 50500000
+ 0.71 0.21 0.79 57571429
+ 0.71 0.21 0.79 64642857
+ 0.71 0.21 0.79 71714286
+ 0.71 0.21 0.79 78785714
+ 0.71 0.21 0.79 85857143
+ 0.71 0.21 0.79 92928571
+ 0.71 0.21 0.79 100000000
+ 0.71 0.21 0.86 1000000
+ 0.71 0.21 0.86 8071429
+ 0.71 0.21 0.86 15142857
+ 0.71 0.21 0.86 22214286
+ 0.71 0.21 0.86 29285714
+ 0.71 0.21 0.86 36357143
+ 0.71 0.21 0.86 43428571
+ 0.71 0.21 0.86 50500000
+ 0.71 0.21 0.86 57571429
+ 0.71 0.21 0.86 64642857
+ 0.71 0.21 0.86 71714286
+ 0.71 0.21 0.86 78785714
+ 0.71 0.21 0.86 85857143
+ 0.71 0.21 0.86 92928571
+ 0.71 0.21 0.86 100000000
+ 0.71 0.21 0.93 1000000
+ 0.71 0.21 0.93 8071429
+ 0.71 0.21 0.93 15142857
+ 0.71 0.21 0.93 22214286
+ 0.71 0.21 0.93 29285714
+ 0.71 0.21 0.93 36357143
+ 0.71 0.21 0.93 43428571
+ 0.71 0.21 0.93 50500000
+ 0.71 0.21 0.93 57571429
+ 0.71 0.21 0.93 64642857
+ 0.71 0.21 0.93 71714286
+ 0.71 0.21 0.93 78785714
+ 0.71 0.21 0.93 85857143
+ 0.71 0.21 0.93 92928571
+ 0.71 0.21 0.93 100000000
+ 0.71 0.21 1.00 1000000
+ 0.71 0.21 1.00 8071429
+ 0.71 0.21 1.00 15142857
+ 0.71 0.21 1.00 22214286
+ 0.71 0.21 1.00 29285714
+ 0.71 0.21 1.00 36357143
+ 0.71 0.21 1.00 43428571
+ 0.71 0.21 1.00 50500000
+ 0.71 0.21 1.00 57571429
+ 0.71 0.21 1.00 64642857
+ 0.71 0.21 1.00 71714286
+ 0.71 0.21 1.00 78785714
+ 0.71 0.21 1.00 85857143
+ 0.71 0.21 1.00 92928571
+ 0.71 0.21 1.00 100000000
+ 0.71 0.29 0.00 1000000
+ 0.71 0.29 0.00 8071429
+ 0.71 0.29 0.00 15142857
+ 0.71 0.29 0.00 22214286
+ 0.71 0.29 0.00 29285714
+ 0.71 0.29 0.00 36357143
+ 0.71 0.29 0.00 43428571
+ 0.71 0.29 0.00 50500000
+ 0.71 0.29 0.00 57571429
+ 0.71 0.29 0.00 64642857
+ 0.71 0.29 0.00 71714286
+ 0.71 0.29 0.00 78785714
+ 0.71 0.29 0.00 85857143
+ 0.71 0.29 0.00 92928571
+ 0.71 0.29 0.00 100000000
+ 0.71 0.29 0.07 1000000
+ 0.71 0.29 0.07 8071429
+ 0.71 0.29 0.07 15142857
+ 0.71 0.29 0.07 22214286
+ 0.71 0.29 0.07 29285714
+ 0.71 0.29 0.07 36357143
+ 0.71 0.29 0.07 43428571
+ 0.71 0.29 0.07 50500000
+ 0.71 0.29 0.07 57571429
+ 0.71 0.29 0.07 64642857
+ 0.71 0.29 0.07 71714286
+ 0.71 0.29 0.07 78785714
+ 0.71 0.29 0.07 85857143
+ 0.71 0.29 0.07 92928571
+ 0.71 0.29 0.07 100000000
+ 0.71 0.29 0.14 1000000
+ 0.71 0.29 0.14 8071429
+ 0.71 0.29 0.14 15142857
+ 0.71 0.29 0.14 22214286
+ 0.71 0.29 0.14 29285714
+ 0.71 0.29 0.14 36357143
+ 0.71 0.29 0.14 43428571
+ 0.71 0.29 0.14 50500000
+ 0.71 0.29 0.14 57571429
+ 0.71 0.29 0.14 64642857
+ 0.71 0.29 0.14 71714286
+ 0.71 0.29 0.14 78785714
+ 0.71 0.29 0.14 85857143
+ 0.71 0.29 0.14 92928571
+ 0.71 0.29 0.14 100000000
+ 0.71 0.29 0.21 1000000
+ 0.71 0.29 0.21 8071429
+ 0.71 0.29 0.21 15142857
+ 0.71 0.29 0.21 22214286
+ 0.71 0.29 0.21 29285714
+ 0.71 0.29 0.21 36357143
+ 0.71 0.29 0.21 43428571
+ 0.71 0.29 0.21 50500000
+ 0.71 0.29 0.21 57571429
+ 0.71 0.29 0.21 64642857
+ 0.71 0.29 0.21 71714286
+ 0.71 0.29 0.21 78785714
+ 0.71 0.29 0.21 85857143
+ 0.71 0.29 0.21 92928571
+ 0.71 0.29 0.21 100000000
+ 0.71 0.29 0.29 1000000
+ 0.71 0.29 0.29 8071429
+ 0.71 0.29 0.29 15142857
+ 0.71 0.29 0.29 22214286
+ 0.71 0.29 0.29 29285714
+ 0.71 0.29 0.29 36357143
+ 0.71 0.29 0.29 43428571
+ 0.71 0.29 0.29 50500000
+ 0.71 0.29 0.29 57571429
+ 0.71 0.29 0.29 64642857
+ 0.71 0.29 0.29 71714286
+ 0.71 0.29 0.29 78785714
+ 0.71 0.29 0.29 85857143
+ 0.71 0.29 0.29 92928571
+ 0.71 0.29 0.29 100000000
+ 0.71 0.29 0.36 1000000
+ 0.71 0.29 0.36 8071429
+ 0.71 0.29 0.36 15142857
+ 0.71 0.29 0.36 22214286
+ 0.71 0.29 0.36 29285714
+ 0.71 0.29 0.36 36357143
+ 0.71 0.29 0.36 43428571
+ 0.71 0.29 0.36 50500000
+ 0.71 0.29 0.36 57571429
+ 0.71 0.29 0.36 64642857
+ 0.71 0.29 0.36 71714286
+ 0.71 0.29 0.36 78785714
+ 0.71 0.29 0.36 85857143
+ 0.71 0.29 0.36 92928571
+ 0.71 0.29 0.36 100000000
+ 0.71 0.29 0.43 1000000
+ 0.71 0.29 0.43 8071429
+ 0.71 0.29 0.43 15142857
+ 0.71 0.29 0.43 22214286
+ 0.71 0.29 0.43 29285714
+ 0.71 0.29 0.43 36357143
+ 0.71 0.29 0.43 43428571
+ 0.71 0.29 0.43 50500000
+ 0.71 0.29 0.43 57571429
+ 0.71 0.29 0.43 64642857
+ 0.71 0.29 0.43 71714286
+ 0.71 0.29 0.43 78785714
+ 0.71 0.29 0.43 85857143
+ 0.71 0.29 0.43 92928571
+ 0.71 0.29 0.43 100000000
+ 0.71 0.29 0.50 1000000
+ 0.71 0.29 0.50 8071429
+ 0.71 0.29 0.50 15142857
+ 0.71 0.29 0.50 22214286
+ 0.71 0.29 0.50 29285714
+ 0.71 0.29 0.50 36357143
+ 0.71 0.29 0.50 43428571
+ 0.71 0.29 0.50 50500000
+ 0.71 0.29 0.50 57571429
+ 0.71 0.29 0.50 64642857
+ 0.71 0.29 0.50 71714286
+ 0.71 0.29 0.50 78785714
+ 0.71 0.29 0.50 85857143
+ 0.71 0.29 0.50 92928571
+ 0.71 0.29 0.50 100000000
+ 0.71 0.29 0.57 1000000
+ 0.71 0.29 0.57 8071429
+ 0.71 0.29 0.57 15142857
+ 0.71 0.29 0.57 22214286
+ 0.71 0.29 0.57 29285714
+ 0.71 0.29 0.57 36357143
+ 0.71 0.29 0.57 43428571
+ 0.71 0.29 0.57 50500000
+ 0.71 0.29 0.57 57571429
+ 0.71 0.29 0.57 64642857
+ 0.71 0.29 0.57 71714286
+ 0.71 0.29 0.57 78785714
+ 0.71 0.29 0.57 85857143
+ 0.71 0.29 0.57 92928571
+ 0.71 0.29 0.57 100000000
+ 0.71 0.29 0.64 1000000
+ 0.71 0.29 0.64 8071429
+ 0.71 0.29 0.64 15142857
+ 0.71 0.29 0.64 22214286
+ 0.71 0.29 0.64 29285714
+ 0.71 0.29 0.64 36357143
+ 0.71 0.29 0.64 43428571
+ 0.71 0.29 0.64 50500000
+ 0.71 0.29 0.64 57571429
+ 0.71 0.29 0.64 64642857
+ 0.71 0.29 0.64 71714286
+ 0.71 0.29 0.64 78785714
+ 0.71 0.29 0.64 85857143
+ 0.71 0.29 0.64 92928571
+ 0.71 0.29 0.64 100000000
+ 0.71 0.29 0.71 1000000
+ 0.71 0.29 0.71 8071429
+ 0.71 0.29 0.71 15142857
+ 0.71 0.29 0.71 22214286
+ 0.71 0.29 0.71 29285714
+ 0.71 0.29 0.71 36357143
+ 0.71 0.29 0.71 43428571
+ 0.71 0.29 0.71 50500000
+ 0.71 0.29 0.71 57571429
+ 0.71 0.29 0.71 64642857
+ 0.71 0.29 0.71 71714286
+ 0.71 0.29 0.71 78785714
+ 0.71 0.29 0.71 85857143
+ 0.71 0.29 0.71 92928571
+ 0.71 0.29 0.71 100000000
+ 0.71 0.29 0.79 1000000
+ 0.71 0.29 0.79 8071429
+ 0.71 0.29 0.79 15142857
+ 0.71 0.29 0.79 22214286
+ 0.71 0.29 0.79 29285714
+ 0.71 0.29 0.79 36357143
+ 0.71 0.29 0.79 43428571
+ 0.71 0.29 0.79 50500000
+ 0.71 0.29 0.79 57571429
+ 0.71 0.29 0.79 64642857
+ 0.71 0.29 0.79 71714286
+ 0.71 0.29 0.79 78785714
+ 0.71 0.29 0.79 85857143
+ 0.71 0.29 0.79 92928571
+ 0.71 0.29 0.79 100000000
+ 0.71 0.29 0.86 1000000
+ 0.71 0.29 0.86 8071429
+ 0.71 0.29 0.86 15142857
+ 0.71 0.29 0.86 22214286
+ 0.71 0.29 0.86 29285714
+ 0.71 0.29 0.86 36357143
+ 0.71 0.29 0.86 43428571
+ 0.71 0.29 0.86 50500000
+ 0.71 0.29 0.86 57571429
+ 0.71 0.29 0.86 64642857
+ 0.71 0.29 0.86 71714286
+ 0.71 0.29 0.86 78785714
+ 0.71 0.29 0.86 85857143
+ 0.71 0.29 0.86 92928571
+ 0.71 0.29 0.86 100000000
+ 0.71 0.29 0.93 1000000
+ 0.71 0.29 0.93 8071429
+ 0.71 0.29 0.93 15142857
+ 0.71 0.29 0.93 22214286
+ 0.71 0.29 0.93 29285714
+ 0.71 0.29 0.93 36357143
+ 0.71 0.29 0.93 43428571
+ 0.71 0.29 0.93 50500000
+ 0.71 0.29 0.93 57571429
+ 0.71 0.29 0.93 64642857
+ 0.71 0.29 0.93 71714286
+ 0.71 0.29 0.93 78785714
+ 0.71 0.29 0.93 85857143
+ 0.71 0.29 0.93 92928571
+ 0.71 0.29 0.93 100000000
+ 0.71 0.29 1.00 1000000
+ 0.71 0.29 1.00 8071429
+ 0.71 0.29 1.00 15142857
+ 0.71 0.29 1.00 22214286
+ 0.71 0.29 1.00 29285714
+ 0.71 0.29 1.00 36357143
+ 0.71 0.29 1.00 43428571
+ 0.71 0.29 1.00 50500000
+ 0.71 0.29 1.00 57571429
+ 0.71 0.29 1.00 64642857
+ 0.71 0.29 1.00 71714286
+ 0.71 0.29 1.00 78785714
+ 0.71 0.29 1.00 85857143
+ 0.71 0.29 1.00 92928571
+ 0.71 0.29 1.00 100000000
+ 0.71 0.36 0.00 1000000
+ 0.71 0.36 0.00 8071429
+ 0.71 0.36 0.00 15142857
+ 0.71 0.36 0.00 22214286
+ 0.71 0.36 0.00 29285714
+ 0.71 0.36 0.00 36357143
+ 0.71 0.36 0.00 43428571
+ 0.71 0.36 0.00 50500000
+ 0.71 0.36 0.00 57571429
+ 0.71 0.36 0.00 64642857
+ 0.71 0.36 0.00 71714286
+ 0.71 0.36 0.00 78785714
+ 0.71 0.36 0.00 85857143
+ 0.71 0.36 0.00 92928571
+ 0.71 0.36 0.00 100000000
+ 0.71 0.36 0.07 1000000
+ 0.71 0.36 0.07 8071429
+ 0.71 0.36 0.07 15142857
+ 0.71 0.36 0.07 22214286
+ 0.71 0.36 0.07 29285714
+ 0.71 0.36 0.07 36357143
+ 0.71 0.36 0.07 43428571
+ 0.71 0.36 0.07 50500000
+ 0.71 0.36 0.07 57571429
+ 0.71 0.36 0.07 64642857
+ 0.71 0.36 0.07 71714286
+ 0.71 0.36 0.07 78785714
+ 0.71 0.36 0.07 85857143
+ 0.71 0.36 0.07 92928571
+ 0.71 0.36 0.07 100000000
+ 0.71 0.36 0.14 1000000
+ 0.71 0.36 0.14 8071429
+ 0.71 0.36 0.14 15142857
+ 0.71 0.36 0.14 22214286
+ 0.71 0.36 0.14 29285714
+ 0.71 0.36 0.14 36357143
+ 0.71 0.36 0.14 43428571
+ 0.71 0.36 0.14 50500000
+ 0.71 0.36 0.14 57571429
+ 0.71 0.36 0.14 64642857
+ 0.71 0.36 0.14 71714286
+ 0.71 0.36 0.14 78785714
+ 0.71 0.36 0.14 85857143
+ 0.71 0.36 0.14 92928571
+ 0.71 0.36 0.14 100000000
+ 0.71 0.36 0.21 1000000
+ 0.71 0.36 0.21 8071429
+ 0.71 0.36 0.21 15142857
+ 0.71 0.36 0.21 22214286
+ 0.71 0.36 0.21 29285714
+ 0.71 0.36 0.21 36357143
+ 0.71 0.36 0.21 43428571
+ 0.71 0.36 0.21 50500000
+ 0.71 0.36 0.21 57571429
+ 0.71 0.36 0.21 64642857
+ 0.71 0.36 0.21 71714286
+ 0.71 0.36 0.21 78785714
+ 0.71 0.36 0.21 85857143
+ 0.71 0.36 0.21 92928571
+ 0.71 0.36 0.21 100000000
+ 0.71 0.36 0.29 1000000
+ 0.71 0.36 0.29 8071429
+ 0.71 0.36 0.29 15142857
+ 0.71 0.36 0.29 22214286
+ 0.71 0.36 0.29 29285714
+ 0.71 0.36 0.29 36357143
+ 0.71 0.36 0.29 43428571
+ 0.71 0.36 0.29 50500000
+ 0.71 0.36 0.29 57571429
+ 0.71 0.36 0.29 64642857
+ 0.71 0.36 0.29 71714286
+ 0.71 0.36 0.29 78785714
+ 0.71 0.36 0.29 85857143
+ 0.71 0.36 0.29 92928571
+ 0.71 0.36 0.29 100000000
+ 0.71 0.36 0.36 1000000
+ 0.71 0.36 0.36 8071429
+ 0.71 0.36 0.36 15142857
+ 0.71 0.36 0.36 22214286
+ 0.71 0.36 0.36 29285714
+ 0.71 0.36 0.36 36357143
+ 0.71 0.36 0.36 43428571
+ 0.71 0.36 0.36 50500000
+ 0.71 0.36 0.36 57571429
+ 0.71 0.36 0.36 64642857
+ 0.71 0.36 0.36 71714286
+ 0.71 0.36 0.36 78785714
+ 0.71 0.36 0.36 85857143
+ 0.71 0.36 0.36 92928571
+ 0.71 0.36 0.36 100000000
+ 0.71 0.36 0.43 1000000
+ 0.71 0.36 0.43 8071429
+ 0.71 0.36 0.43 15142857
+ 0.71 0.36 0.43 22214286
+ 0.71 0.36 0.43 29285714
+ 0.71 0.36 0.43 36357143
+ 0.71 0.36 0.43 43428571
+ 0.71 0.36 0.43 50500000
+ 0.71 0.36 0.43 57571429
+ 0.71 0.36 0.43 64642857
+ 0.71 0.36 0.43 71714286
+ 0.71 0.36 0.43 78785714
+ 0.71 0.36 0.43 85857143
+ 0.71 0.36 0.43 92928571
+ 0.71 0.36 0.43 100000000
+ 0.71 0.36 0.50 1000000
+ 0.71 0.36 0.50 8071429
+ 0.71 0.36 0.50 15142857
+ 0.71 0.36 0.50 22214286
+ 0.71 0.36 0.50 29285714
+ 0.71 0.36 0.50 36357143
+ 0.71 0.36 0.50 43428571
+ 0.71 0.36 0.50 50500000
+ 0.71 0.36 0.50 57571429
+ 0.71 0.36 0.50 64642857
+ 0.71 0.36 0.50 71714286
+ 0.71 0.36 0.50 78785714
+ 0.71 0.36 0.50 85857143
+ 0.71 0.36 0.50 92928571
+ 0.71 0.36 0.50 100000000
+ 0.71 0.36 0.57 1000000
+ 0.71 0.36 0.57 8071429
+ 0.71 0.36 0.57 15142857
+ 0.71 0.36 0.57 22214286
+ 0.71 0.36 0.57 29285714
+ 0.71 0.36 0.57 36357143
+ 0.71 0.36 0.57 43428571
+ 0.71 0.36 0.57 50500000
+ 0.71 0.36 0.57 57571429
+ 0.71 0.36 0.57 64642857
+ 0.71 0.36 0.57 71714286
+ 0.71 0.36 0.57 78785714
+ 0.71 0.36 0.57 85857143
+ 0.71 0.36 0.57 92928571
+ 0.71 0.36 0.57 100000000
+ 0.71 0.36 0.64 1000000
+ 0.71 0.36 0.64 8071429
+ 0.71 0.36 0.64 15142857
+ 0.71 0.36 0.64 22214286
+ 0.71 0.36 0.64 29285714
+ 0.71 0.36 0.64 36357143
+ 0.71 0.36 0.64 43428571
+ 0.71 0.36 0.64 50500000
+ 0.71 0.36 0.64 57571429
+ 0.71 0.36 0.64 64642857
+ 0.71 0.36 0.64 71714286
+ 0.71 0.36 0.64 78785714
+ 0.71 0.36 0.64 85857143
+ 0.71 0.36 0.64 92928571
+ 0.71 0.36 0.64 100000000
+ 0.71 0.36 0.71 1000000
+ 0.71 0.36 0.71 8071429
+ 0.71 0.36 0.71 15142857
+ 0.71 0.36 0.71 22214286
+ 0.71 0.36 0.71 29285714
+ 0.71 0.36 0.71 36357143
+ 0.71 0.36 0.71 43428571
+ 0.71 0.36 0.71 50500000
+ 0.71 0.36 0.71 57571429
+ 0.71 0.36 0.71 64642857
+ 0.71 0.36 0.71 71714286
+ 0.71 0.36 0.71 78785714
+ 0.71 0.36 0.71 85857143
+ 0.71 0.36 0.71 92928571
+ 0.71 0.36 0.71 100000000
+ 0.71 0.36 0.79 1000000
+ 0.71 0.36 0.79 8071429
+ 0.71 0.36 0.79 15142857
+ 0.71 0.36 0.79 22214286
+ 0.71 0.36 0.79 29285714
+ 0.71 0.36 0.79 36357143
+ 0.71 0.36 0.79 43428571
+ 0.71 0.36 0.79 50500000
+ 0.71 0.36 0.79 57571429
+ 0.71 0.36 0.79 64642857
+ 0.71 0.36 0.79 71714286
+ 0.71 0.36 0.79 78785714
+ 0.71 0.36 0.79 85857143
+ 0.71 0.36 0.79 92928571
+ 0.71 0.36 0.79 100000000
+ 0.71 0.36 0.86 1000000
+ 0.71 0.36 0.86 8071429
+ 0.71 0.36 0.86 15142857
+ 0.71 0.36 0.86 22214286
+ 0.71 0.36 0.86 29285714
+ 0.71 0.36 0.86 36357143
+ 0.71 0.36 0.86 43428571
+ 0.71 0.36 0.86 50500000
+ 0.71 0.36 0.86 57571429
+ 0.71 0.36 0.86 64642857
+ 0.71 0.36 0.86 71714286
+ 0.71 0.36 0.86 78785714
+ 0.71 0.36 0.86 85857143
+ 0.71 0.36 0.86 92928571
+ 0.71 0.36 0.86 100000000
+ 0.71 0.36 0.93 1000000
+ 0.71 0.36 0.93 8071429
+ 0.71 0.36 0.93 15142857
+ 0.71 0.36 0.93 22214286
+ 0.71 0.36 0.93 29285714
+ 0.71 0.36 0.93 36357143
+ 0.71 0.36 0.93 43428571
+ 0.71 0.36 0.93 50500000
+ 0.71 0.36 0.93 57571429
+ 0.71 0.36 0.93 64642857
+ 0.71 0.36 0.93 71714286
+ 0.71 0.36 0.93 78785714
+ 0.71 0.36 0.93 85857143
+ 0.71 0.36 0.93 92928571
+ 0.71 0.36 0.93 100000000
+ 0.71 0.36 1.00 1000000
+ 0.71 0.36 1.00 8071429
+ 0.71 0.36 1.00 15142857
+ 0.71 0.36 1.00 22214286
+ 0.71 0.36 1.00 29285714
+ 0.71 0.36 1.00 36357143
+ 0.71 0.36 1.00 43428571
+ 0.71 0.36 1.00 50500000
+ 0.71 0.36 1.00 57571429
+ 0.71 0.36 1.00 64642857
+ 0.71 0.36 1.00 71714286
+ 0.71 0.36 1.00 78785714
+ 0.71 0.36 1.00 85857143
+ 0.71 0.36 1.00 92928571
+ 0.71 0.36 1.00 100000000
+ 0.71 0.43 0.00 1000000
+ 0.71 0.43 0.00 8071429
+ 0.71 0.43 0.00 15142857
+ 0.71 0.43 0.00 22214286
+ 0.71 0.43 0.00 29285714
+ 0.71 0.43 0.00 36357143
+ 0.71 0.43 0.00 43428571
+ 0.71 0.43 0.00 50500000
+ 0.71 0.43 0.00 57571429
+ 0.71 0.43 0.00 64642857
+ 0.71 0.43 0.00 71714286
+ 0.71 0.43 0.00 78785714
+ 0.71 0.43 0.00 85857143
+ 0.71 0.43 0.00 92928571
+ 0.71 0.43 0.00 100000000
+ 0.71 0.43 0.07 1000000
+ 0.71 0.43 0.07 8071429
+ 0.71 0.43 0.07 15142857
+ 0.71 0.43 0.07 22214286
+ 0.71 0.43 0.07 29285714
+ 0.71 0.43 0.07 36357143
+ 0.71 0.43 0.07 43428571
+ 0.71 0.43 0.07 50500000
+ 0.71 0.43 0.07 57571429
+ 0.71 0.43 0.07 64642857
+ 0.71 0.43 0.07 71714286
+ 0.71 0.43 0.07 78785714
+ 0.71 0.43 0.07 85857143
+ 0.71 0.43 0.07 92928571
+ 0.71 0.43 0.07 100000000
+ 0.71 0.43 0.14 1000000
+ 0.71 0.43 0.14 8071429
+ 0.71 0.43 0.14 15142857
+ 0.71 0.43 0.14 22214286
+ 0.71 0.43 0.14 29285714
+ 0.71 0.43 0.14 36357143
+ 0.71 0.43 0.14 43428571
+ 0.71 0.43 0.14 50500000
+ 0.71 0.43 0.14 57571429
+ 0.71 0.43 0.14 64642857
+ 0.71 0.43 0.14 71714286
+ 0.71 0.43 0.14 78785714
+ 0.71 0.43 0.14 85857143
+ 0.71 0.43 0.14 92928571
+ 0.71 0.43 0.14 100000000
+ 0.71 0.43 0.21 1000000
+ 0.71 0.43 0.21 8071429
+ 0.71 0.43 0.21 15142857
+ 0.71 0.43 0.21 22214286
+ 0.71 0.43 0.21 29285714
+ 0.71 0.43 0.21 36357143
+ 0.71 0.43 0.21 43428571
+ 0.71 0.43 0.21 50500000
+ 0.71 0.43 0.21 57571429
+ 0.71 0.43 0.21 64642857
+ 0.71 0.43 0.21 71714286
+ 0.71 0.43 0.21 78785714
+ 0.71 0.43 0.21 85857143
+ 0.71 0.43 0.21 92928571
+ 0.71 0.43 0.21 100000000
+ 0.71 0.43 0.29 1000000
+ 0.71 0.43 0.29 8071429
+ 0.71 0.43 0.29 15142857
+ 0.71 0.43 0.29 22214286
+ 0.71 0.43 0.29 29285714
+ 0.71 0.43 0.29 36357143
+ 0.71 0.43 0.29 43428571
+ 0.71 0.43 0.29 50500000
+ 0.71 0.43 0.29 57571429
+ 0.71 0.43 0.29 64642857
+ 0.71 0.43 0.29 71714286
+ 0.71 0.43 0.29 78785714
+ 0.71 0.43 0.29 85857143
+ 0.71 0.43 0.29 92928571
+ 0.71 0.43 0.29 100000000
+ 0.71 0.43 0.36 1000000
+ 0.71 0.43 0.36 8071429
+ 0.71 0.43 0.36 15142857
+ 0.71 0.43 0.36 22214286
+ 0.71 0.43 0.36 29285714
+ 0.71 0.43 0.36 36357143
+ 0.71 0.43 0.36 43428571
+ 0.71 0.43 0.36 50500000
+ 0.71 0.43 0.36 57571429
+ 0.71 0.43 0.36 64642857
+ 0.71 0.43 0.36 71714286
+ 0.71 0.43 0.36 78785714
+ 0.71 0.43 0.36 85857143
+ 0.71 0.43 0.36 92928571
+ 0.71 0.43 0.36 100000000
+ 0.71 0.43 0.43 1000000
+ 0.71 0.43 0.43 8071429
+ 0.71 0.43 0.43 15142857
+ 0.71 0.43 0.43 22214286
+ 0.71 0.43 0.43 29285714
+ 0.71 0.43 0.43 36357143
+ 0.71 0.43 0.43 43428571
+ 0.71 0.43 0.43 50500000
+ 0.71 0.43 0.43 57571429
+ 0.71 0.43 0.43 64642857
+ 0.71 0.43 0.43 71714286
+ 0.71 0.43 0.43 78785714
+ 0.71 0.43 0.43 85857143
+ 0.71 0.43 0.43 92928571
+ 0.71 0.43 0.43 100000000
+ 0.71 0.43 0.50 1000000
+ 0.71 0.43 0.50 8071429
+ 0.71 0.43 0.50 15142857
+ 0.71 0.43 0.50 22214286
+ 0.71 0.43 0.50 29285714
+ 0.71 0.43 0.50 36357143
+ 0.71 0.43 0.50 43428571
+ 0.71 0.43 0.50 50500000
+ 0.71 0.43 0.50 57571429
+ 0.71 0.43 0.50 64642857
+ 0.71 0.43 0.50 71714286
+ 0.71 0.43 0.50 78785714
+ 0.71 0.43 0.50 85857143
+ 0.71 0.43 0.50 92928571
+ 0.71 0.43 0.50 100000000
+ 0.71 0.43 0.57 1000000
+ 0.71 0.43 0.57 8071429
+ 0.71 0.43 0.57 15142857
+ 0.71 0.43 0.57 22214286
+ 0.71 0.43 0.57 29285714
+ 0.71 0.43 0.57 36357143
+ 0.71 0.43 0.57 43428571
+ 0.71 0.43 0.57 50500000
+ 0.71 0.43 0.57 57571429
+ 0.71 0.43 0.57 64642857
+ 0.71 0.43 0.57 71714286
+ 0.71 0.43 0.57 78785714
+ 0.71 0.43 0.57 85857143
+ 0.71 0.43 0.57 92928571
+ 0.71 0.43 0.57 100000000
+ 0.71 0.43 0.64 1000000
+ 0.71 0.43 0.64 8071429
+ 0.71 0.43 0.64 15142857
+ 0.71 0.43 0.64 22214286
+ 0.71 0.43 0.64 29285714
+ 0.71 0.43 0.64 36357143
+ 0.71 0.43 0.64 43428571
+ 0.71 0.43 0.64 50500000
+ 0.71 0.43 0.64 57571429
+ 0.71 0.43 0.64 64642857
+ 0.71 0.43 0.64 71714286
+ 0.71 0.43 0.64 78785714
+ 0.71 0.43 0.64 85857143
+ 0.71 0.43 0.64 92928571
+ 0.71 0.43 0.64 100000000
+ 0.71 0.43 0.71 1000000
+ 0.71 0.43 0.71 8071429
+ 0.71 0.43 0.71 15142857
+ 0.71 0.43 0.71 22214286
+ 0.71 0.43 0.71 29285714
+ 0.71 0.43 0.71 36357143
+ 0.71 0.43 0.71 43428571
+ 0.71 0.43 0.71 50500000
+ 0.71 0.43 0.71 57571429
+ 0.71 0.43 0.71 64642857
+ 0.71 0.43 0.71 71714286
+ 0.71 0.43 0.71 78785714
+ 0.71 0.43 0.71 85857143
+ 0.71 0.43 0.71 92928571
+ 0.71 0.43 0.71 100000000
+ 0.71 0.43 0.79 1000000
+ 0.71 0.43 0.79 8071429
+ 0.71 0.43 0.79 15142857
+ 0.71 0.43 0.79 22214286
+ 0.71 0.43 0.79 29285714
+ 0.71 0.43 0.79 36357143
+ 0.71 0.43 0.79 43428571
+ 0.71 0.43 0.79 50500000
+ 0.71 0.43 0.79 57571429
+ 0.71 0.43 0.79 64642857
+ 0.71 0.43 0.79 71714286
+ 0.71 0.43 0.79 78785714
+ 0.71 0.43 0.79 85857143
+ 0.71 0.43 0.79 92928571
+ 0.71 0.43 0.79 100000000
+ 0.71 0.43 0.86 1000000
+ 0.71 0.43 0.86 8071429
+ 0.71 0.43 0.86 15142857
+ 0.71 0.43 0.86 22214286
+ 0.71 0.43 0.86 29285714
+ 0.71 0.43 0.86 36357143
+ 0.71 0.43 0.86 43428571
+ 0.71 0.43 0.86 50500000
+ 0.71 0.43 0.86 57571429
+ 0.71 0.43 0.86 64642857
+ 0.71 0.43 0.86 71714286
+ 0.71 0.43 0.86 78785714
+ 0.71 0.43 0.86 85857143
+ 0.71 0.43 0.86 92928571
+ 0.71 0.43 0.86 100000000
+ 0.71 0.43 0.93 1000000
+ 0.71 0.43 0.93 8071429
+ 0.71 0.43 0.93 15142857
+ 0.71 0.43 0.93 22214286
+ 0.71 0.43 0.93 29285714
+ 0.71 0.43 0.93 36357143
+ 0.71 0.43 0.93 43428571
+ 0.71 0.43 0.93 50500000
+ 0.71 0.43 0.93 57571429
+ 0.71 0.43 0.93 64642857
+ 0.71 0.43 0.93 71714286
+ 0.71 0.43 0.93 78785714
+ 0.71 0.43 0.93 85857143
+ 0.71 0.43 0.93 92928571
+ 0.71 0.43 0.93 100000000
+ 0.71 0.43 1.00 1000000
+ 0.71 0.43 1.00 8071429
+ 0.71 0.43 1.00 15142857
+ 0.71 0.43 1.00 22214286
+ 0.71 0.43 1.00 29285714
+ 0.71 0.43 1.00 36357143
+ 0.71 0.43 1.00 43428571
+ 0.71 0.43 1.00 50500000
+ 0.71 0.43 1.00 57571429
+ 0.71 0.43 1.00 64642857
+ 0.71 0.43 1.00 71714286
+ 0.71 0.43 1.00 78785714
+ 0.71 0.43 1.00 85857143
+ 0.71 0.43 1.00 92928571
+ 0.71 0.43 1.00 100000000
+ 0.71 0.50 0.00 1000000
+ 0.71 0.50 0.00 8071429
+ 0.71 0.50 0.00 15142857
+ 0.71 0.50 0.00 22214286
+ 0.71 0.50 0.00 29285714
+ 0.71 0.50 0.00 36357143
+ 0.71 0.50 0.00 43428571
+ 0.71 0.50 0.00 50500000
+ 0.71 0.50 0.00 57571429
+ 0.71 0.50 0.00 64642857
+ 0.71 0.50 0.00 71714286
+ 0.71 0.50 0.00 78785714
+ 0.71 0.50 0.00 85857143
+ 0.71 0.50 0.00 92928571
+ 0.71 0.50 0.00 100000000
+ 0.71 0.50 0.07 1000000
+ 0.71 0.50 0.07 8071429
+ 0.71 0.50 0.07 15142857
+ 0.71 0.50 0.07 22214286
+ 0.71 0.50 0.07 29285714
+ 0.71 0.50 0.07 36357143
+ 0.71 0.50 0.07 43428571
+ 0.71 0.50 0.07 50500000
+ 0.71 0.50 0.07 57571429
+ 0.71 0.50 0.07 64642857
+ 0.71 0.50 0.07 71714286
+ 0.71 0.50 0.07 78785714
+ 0.71 0.50 0.07 85857143
+ 0.71 0.50 0.07 92928571
+ 0.71 0.50 0.07 100000000
+ 0.71 0.50 0.14 1000000
+ 0.71 0.50 0.14 8071429
+ 0.71 0.50 0.14 15142857
+ 0.71 0.50 0.14 22214286
+ 0.71 0.50 0.14 29285714
+ 0.71 0.50 0.14 36357143
+ 0.71 0.50 0.14 43428571
+ 0.71 0.50 0.14 50500000
+ 0.71 0.50 0.14 57571429
+ 0.71 0.50 0.14 64642857
+ 0.71 0.50 0.14 71714286
+ 0.71 0.50 0.14 78785714
+ 0.71 0.50 0.14 85857143
+ 0.71 0.50 0.14 92928571
+ 0.71 0.50 0.14 100000000
+ 0.71 0.50 0.21 1000000
+ 0.71 0.50 0.21 8071429
+ 0.71 0.50 0.21 15142857
+ 0.71 0.50 0.21 22214286
+ 0.71 0.50 0.21 29285714
+ 0.71 0.50 0.21 36357143
+ 0.71 0.50 0.21 43428571
+ 0.71 0.50 0.21 50500000
+ 0.71 0.50 0.21 57571429
+ 0.71 0.50 0.21 64642857
+ 0.71 0.50 0.21 71714286
+ 0.71 0.50 0.21 78785714
+ 0.71 0.50 0.21 85857143
+ 0.71 0.50 0.21 92928571
+ 0.71 0.50 0.21 100000000
+ 0.71 0.50 0.29 1000000
+ 0.71 0.50 0.29 8071429
+ 0.71 0.50 0.29 15142857
+ 0.71 0.50 0.29 22214286
+ 0.71 0.50 0.29 29285714
+ 0.71 0.50 0.29 36357143
+ 0.71 0.50 0.29 43428571
+ 0.71 0.50 0.29 50500000
+ 0.71 0.50 0.29 57571429
+ 0.71 0.50 0.29 64642857
+ 0.71 0.50 0.29 71714286
+ 0.71 0.50 0.29 78785714
+ 0.71 0.50 0.29 85857143
+ 0.71 0.50 0.29 92928571
+ 0.71 0.50 0.29 100000000
+ 0.71 0.50 0.36 1000000
+ 0.71 0.50 0.36 8071429
+ 0.71 0.50 0.36 15142857
+ 0.71 0.50 0.36 22214286
+ 0.71 0.50 0.36 29285714
+ 0.71 0.50 0.36 36357143
+ 0.71 0.50 0.36 43428571
+ 0.71 0.50 0.36 50500000
+ 0.71 0.50 0.36 57571429
+ 0.71 0.50 0.36 64642857
+ 0.71 0.50 0.36 71714286
+ 0.71 0.50 0.36 78785714
+ 0.71 0.50 0.36 85857143
+ 0.71 0.50 0.36 92928571
+ 0.71 0.50 0.36 100000000
+ 0.71 0.50 0.43 1000000
+ 0.71 0.50 0.43 8071429
+ 0.71 0.50 0.43 15142857
+ 0.71 0.50 0.43 22214286
+ 0.71 0.50 0.43 29285714
+ 0.71 0.50 0.43 36357143
+ 0.71 0.50 0.43 43428571
+ 0.71 0.50 0.43 50500000
+ 0.71 0.50 0.43 57571429
+ 0.71 0.50 0.43 64642857
+ 0.71 0.50 0.43 71714286
+ 0.71 0.50 0.43 78785714
+ 0.71 0.50 0.43 85857143
+ 0.71 0.50 0.43 92928571
+ 0.71 0.50 0.43 100000000
+ 0.71 0.50 0.50 1000000
+ 0.71 0.50 0.50 8071429
+ 0.71 0.50 0.50 15142857
+ 0.71 0.50 0.50 22214286
+ 0.71 0.50 0.50 29285714
+ 0.71 0.50 0.50 36357143
+ 0.71 0.50 0.50 43428571
+ 0.71 0.50 0.50 50500000
+ 0.71 0.50 0.50 57571429
+ 0.71 0.50 0.50 64642857
+ 0.71 0.50 0.50 71714286
+ 0.71 0.50 0.50 78785714
+ 0.71 0.50 0.50 85857143
+ 0.71 0.50 0.50 92928571
+ 0.71 0.50 0.50 100000000
+ 0.71 0.50 0.57 1000000
+ 0.71 0.50 0.57 8071429
+ 0.71 0.50 0.57 15142857
+ 0.71 0.50 0.57 22214286
+ 0.71 0.50 0.57 29285714
+ 0.71 0.50 0.57 36357143
+ 0.71 0.50 0.57 43428571
+ 0.71 0.50 0.57 50500000
+ 0.71 0.50 0.57 57571429
+ 0.71 0.50 0.57 64642857
+ 0.71 0.50 0.57 71714286
+ 0.71 0.50 0.57 78785714
+ 0.71 0.50 0.57 85857143
+ 0.71 0.50 0.57 92928571
+ 0.71 0.50 0.57 100000000
+ 0.71 0.50 0.64 1000000
+ 0.71 0.50 0.64 8071429
+ 0.71 0.50 0.64 15142857
+ 0.71 0.50 0.64 22214286
+ 0.71 0.50 0.64 29285714
+ 0.71 0.50 0.64 36357143
+ 0.71 0.50 0.64 43428571
+ 0.71 0.50 0.64 50500000
+ 0.71 0.50 0.64 57571429
+ 0.71 0.50 0.64 64642857
+ 0.71 0.50 0.64 71714286
+ 0.71 0.50 0.64 78785714
+ 0.71 0.50 0.64 85857143
+ 0.71 0.50 0.64 92928571
+ 0.71 0.50 0.64 100000000
+ 0.71 0.50 0.71 1000000
+ 0.71 0.50 0.71 8071429
+ 0.71 0.50 0.71 15142857
+ 0.71 0.50 0.71 22214286
+ 0.71 0.50 0.71 29285714
+ 0.71 0.50 0.71 36357143
+ 0.71 0.50 0.71 43428571
+ 0.71 0.50 0.71 50500000
+ 0.71 0.50 0.71 57571429
+ 0.71 0.50 0.71 64642857
+ 0.71 0.50 0.71 71714286
+ 0.71 0.50 0.71 78785714
+ 0.71 0.50 0.71 85857143
+ 0.71 0.50 0.71 92928571
+ 0.71 0.50 0.71 100000000
+ 0.71 0.50 0.79 1000000
+ 0.71 0.50 0.79 8071429
+ 0.71 0.50 0.79 15142857
+ 0.71 0.50 0.79 22214286
+ 0.71 0.50 0.79 29285714
+ 0.71 0.50 0.79 36357143
+ 0.71 0.50 0.79 43428571
+ 0.71 0.50 0.79 50500000
+ 0.71 0.50 0.79 57571429
+ 0.71 0.50 0.79 64642857
+ 0.71 0.50 0.79 71714286
+ 0.71 0.50 0.79 78785714
+ 0.71 0.50 0.79 85857143
+ 0.71 0.50 0.79 92928571
+ 0.71 0.50 0.79 100000000
+ 0.71 0.50 0.86 1000000
+ 0.71 0.50 0.86 8071429
+ 0.71 0.50 0.86 15142857
+ 0.71 0.50 0.86 22214286
+ 0.71 0.50 0.86 29285714
+ 0.71 0.50 0.86 36357143
+ 0.71 0.50 0.86 43428571
+ 0.71 0.50 0.86 50500000
+ 0.71 0.50 0.86 57571429
+ 0.71 0.50 0.86 64642857
+ 0.71 0.50 0.86 71714286
+ 0.71 0.50 0.86 78785714
+ 0.71 0.50 0.86 85857143
+ 0.71 0.50 0.86 92928571
+ 0.71 0.50 0.86 100000000
+ 0.71 0.50 0.93 1000000
+ 0.71 0.50 0.93 8071429
+ 0.71 0.50 0.93 15142857
+ 0.71 0.50 0.93 22214286
+ 0.71 0.50 0.93 29285714
+ 0.71 0.50 0.93 36357143
+ 0.71 0.50 0.93 43428571
+ 0.71 0.50 0.93 50500000
+ 0.71 0.50 0.93 57571429
+ 0.71 0.50 0.93 64642857
+ 0.71 0.50 0.93 71714286
+ 0.71 0.50 0.93 78785714
+ 0.71 0.50 0.93 85857143
+ 0.71 0.50 0.93 92928571
+ 0.71 0.50 0.93 100000000
+ 0.71 0.50 1.00 1000000
+ 0.71 0.50 1.00 8071429
+ 0.71 0.50 1.00 15142857
+ 0.71 0.50 1.00 22214286
+ 0.71 0.50 1.00 29285714
+ 0.71 0.50 1.00 36357143
+ 0.71 0.50 1.00 43428571
+ 0.71 0.50 1.00 50500000
+ 0.71 0.50 1.00 57571429
+ 0.71 0.50 1.00 64642857
+ 0.71 0.50 1.00 71714286
+ 0.71 0.50 1.00 78785714
+ 0.71 0.50 1.00 85857143
+ 0.71 0.50 1.00 92928571
+ 0.71 0.50 1.00 100000000
+ 0.71 0.57 0.00 1000000
+ 0.71 0.57 0.00 8071429
+ 0.71 0.57 0.00 15142857
+ 0.71 0.57 0.00 22214286
+ 0.71 0.57 0.00 29285714
+ 0.71 0.57 0.00 36357143
+ 0.71 0.57 0.00 43428571
+ 0.71 0.57 0.00 50500000
+ 0.71 0.57 0.00 57571429
+ 0.71 0.57 0.00 64642857
+ 0.71 0.57 0.00 71714286
+ 0.71 0.57 0.00 78785714
+ 0.71 0.57 0.00 85857143
+ 0.71 0.57 0.00 92928571
+ 0.71 0.57 0.00 100000000
+ 0.71 0.57 0.07 1000000
+ 0.71 0.57 0.07 8071429
+ 0.71 0.57 0.07 15142857
+ 0.71 0.57 0.07 22214286
+ 0.71 0.57 0.07 29285714
+ 0.71 0.57 0.07 36357143
+ 0.71 0.57 0.07 43428571
+ 0.71 0.57 0.07 50500000
+ 0.71 0.57 0.07 57571429
+ 0.71 0.57 0.07 64642857
+ 0.71 0.57 0.07 71714286
+ 0.71 0.57 0.07 78785714
+ 0.71 0.57 0.07 85857143
+ 0.71 0.57 0.07 92928571
+ 0.71 0.57 0.07 100000000
+ 0.71 0.57 0.14 1000000
+ 0.71 0.57 0.14 8071429
+ 0.71 0.57 0.14 15142857
+ 0.71 0.57 0.14 22214286
+ 0.71 0.57 0.14 29285714
+ 0.71 0.57 0.14 36357143
+ 0.71 0.57 0.14 43428571
+ 0.71 0.57 0.14 50500000
+ 0.71 0.57 0.14 57571429
+ 0.71 0.57 0.14 64642857
+ 0.71 0.57 0.14 71714286
+ 0.71 0.57 0.14 78785714
+ 0.71 0.57 0.14 85857143
+ 0.71 0.57 0.14 92928571
+ 0.71 0.57 0.14 100000000
+ 0.71 0.57 0.21 1000000
+ 0.71 0.57 0.21 8071429
+ 0.71 0.57 0.21 15142857
+ 0.71 0.57 0.21 22214286
+ 0.71 0.57 0.21 29285714
+ 0.71 0.57 0.21 36357143
+ 0.71 0.57 0.21 43428571
+ 0.71 0.57 0.21 50500000
+ 0.71 0.57 0.21 57571429
+ 0.71 0.57 0.21 64642857
+ 0.71 0.57 0.21 71714286
+ 0.71 0.57 0.21 78785714
+ 0.71 0.57 0.21 85857143
+ 0.71 0.57 0.21 92928571
+ 0.71 0.57 0.21 100000000
+ 0.71 0.57 0.29 1000000
+ 0.71 0.57 0.29 8071429
+ 0.71 0.57 0.29 15142857
+ 0.71 0.57 0.29 22214286
+ 0.71 0.57 0.29 29285714
+ 0.71 0.57 0.29 36357143
+ 0.71 0.57 0.29 43428571
+ 0.71 0.57 0.29 50500000
+ 0.71 0.57 0.29 57571429
+ 0.71 0.57 0.29 64642857
+ 0.71 0.57 0.29 71714286
+ 0.71 0.57 0.29 78785714
+ 0.71 0.57 0.29 85857143
+ 0.71 0.57 0.29 92928571
+ 0.71 0.57 0.29 100000000
+ 0.71 0.57 0.36 1000000
+ 0.71 0.57 0.36 8071429
+ 0.71 0.57 0.36 15142857
+ 0.71 0.57 0.36 22214286
+ 0.71 0.57 0.36 29285714
+ 0.71 0.57 0.36 36357143
+ 0.71 0.57 0.36 43428571
+ 0.71 0.57 0.36 50500000
+ 0.71 0.57 0.36 57571429
+ 0.71 0.57 0.36 64642857
+ 0.71 0.57 0.36 71714286
+ 0.71 0.57 0.36 78785714
+ 0.71 0.57 0.36 85857143
+ 0.71 0.57 0.36 92928571
+ 0.71 0.57 0.36 100000000
+ 0.71 0.57 0.43 1000000
+ 0.71 0.57 0.43 8071429
+ 0.71 0.57 0.43 15142857
+ 0.71 0.57 0.43 22214286
+ 0.71 0.57 0.43 29285714
+ 0.71 0.57 0.43 36357143
+ 0.71 0.57 0.43 43428571
+ 0.71 0.57 0.43 50500000
+ 0.71 0.57 0.43 57571429
+ 0.71 0.57 0.43 64642857
+ 0.71 0.57 0.43 71714286
+ 0.71 0.57 0.43 78785714
+ 0.71 0.57 0.43 85857143
+ 0.71 0.57 0.43 92928571
+ 0.71 0.57 0.43 100000000
+ 0.71 0.57 0.50 1000000
+ 0.71 0.57 0.50 8071429
+ 0.71 0.57 0.50 15142857
+ 0.71 0.57 0.50 22214286
+ 0.71 0.57 0.50 29285714
+ 0.71 0.57 0.50 36357143
+ 0.71 0.57 0.50 43428571
+ 0.71 0.57 0.50 50500000
+ 0.71 0.57 0.50 57571429
+ 0.71 0.57 0.50 64642857
+ 0.71 0.57 0.50 71714286
+ 0.71 0.57 0.50 78785714
+ 0.71 0.57 0.50 85857143
+ 0.71 0.57 0.50 92928571
+ 0.71 0.57 0.50 100000000
+ 0.71 0.57 0.57 1000000
+ 0.71 0.57 0.57 8071429
+ 0.71 0.57 0.57 15142857
+ 0.71 0.57 0.57 22214286
+ 0.71 0.57 0.57 29285714
+ 0.71 0.57 0.57 36357143
+ 0.71 0.57 0.57 43428571
+ 0.71 0.57 0.57 50500000
+ 0.71 0.57 0.57 57571429
+ 0.71 0.57 0.57 64642857
+ 0.71 0.57 0.57 71714286
+ 0.71 0.57 0.57 78785714
+ 0.71 0.57 0.57 85857143
+ 0.71 0.57 0.57 92928571
+ 0.71 0.57 0.57 100000000
+ 0.71 0.57 0.64 1000000
+ 0.71 0.57 0.64 8071429
+ 0.71 0.57 0.64 15142857
+ 0.71 0.57 0.64 22214286
+ 0.71 0.57 0.64 29285714
+ 0.71 0.57 0.64 36357143
+ 0.71 0.57 0.64 43428571
+ 0.71 0.57 0.64 50500000
+ 0.71 0.57 0.64 57571429
+ 0.71 0.57 0.64 64642857
+ 0.71 0.57 0.64 71714286
+ 0.71 0.57 0.64 78785714
+ 0.71 0.57 0.64 85857143
+ 0.71 0.57 0.64 92928571
+ 0.71 0.57 0.64 100000000
+ 0.71 0.57 0.71 1000000
+ 0.71 0.57 0.71 8071429
+ 0.71 0.57 0.71 15142857
+ 0.71 0.57 0.71 22214286
+ 0.71 0.57 0.71 29285714
+ 0.71 0.57 0.71 36357143
+ 0.71 0.57 0.71 43428571
+ 0.71 0.57 0.71 50500000
+ 0.71 0.57 0.71 57571429
+ 0.71 0.57 0.71 64642857
+ 0.71 0.57 0.71 71714286
+ 0.71 0.57 0.71 78785714
+ 0.71 0.57 0.71 85857143
+ 0.71 0.57 0.71 92928571
+ 0.71 0.57 0.71 100000000
+ 0.71 0.57 0.79 1000000
+ 0.71 0.57 0.79 8071429
+ 0.71 0.57 0.79 15142857
+ 0.71 0.57 0.79 22214286
+ 0.71 0.57 0.79 29285714
+ 0.71 0.57 0.79 36357143
+ 0.71 0.57 0.79 43428571
+ 0.71 0.57 0.79 50500000
+ 0.71 0.57 0.79 57571429
+ 0.71 0.57 0.79 64642857
+ 0.71 0.57 0.79 71714286
+ 0.71 0.57 0.79 78785714
+ 0.71 0.57 0.79 85857143
+ 0.71 0.57 0.79 92928571
+ 0.71 0.57 0.79 100000000
+ 0.71 0.57 0.86 1000000
+ 0.71 0.57 0.86 8071429
+ 0.71 0.57 0.86 15142857
+ 0.71 0.57 0.86 22214286
+ 0.71 0.57 0.86 29285714
+ 0.71 0.57 0.86 36357143
+ 0.71 0.57 0.86 43428571
+ 0.71 0.57 0.86 50500000
+ 0.71 0.57 0.86 57571429
+ 0.71 0.57 0.86 64642857
+ 0.71 0.57 0.86 71714286
+ 0.71 0.57 0.86 78785714
+ 0.71 0.57 0.86 85857143
+ 0.71 0.57 0.86 92928571
+ 0.71 0.57 0.86 100000000
+ 0.71 0.57 0.93 1000000
+ 0.71 0.57 0.93 8071429
+ 0.71 0.57 0.93 15142857
+ 0.71 0.57 0.93 22214286
+ 0.71 0.57 0.93 29285714
+ 0.71 0.57 0.93 36357143
+ 0.71 0.57 0.93 43428571
+ 0.71 0.57 0.93 50500000
+ 0.71 0.57 0.93 57571429
+ 0.71 0.57 0.93 64642857
+ 0.71 0.57 0.93 71714286
+ 0.71 0.57 0.93 78785714
+ 0.71 0.57 0.93 85857143
+ 0.71 0.57 0.93 92928571
+ 0.71 0.57 0.93 100000000
+ 0.71 0.57 1.00 1000000
+ 0.71 0.57 1.00 8071429
+ 0.71 0.57 1.00 15142857
+ 0.71 0.57 1.00 22214286
+ 0.71 0.57 1.00 29285714
+ 0.71 0.57 1.00 36357143
+ 0.71 0.57 1.00 43428571
+ 0.71 0.57 1.00 50500000
+ 0.71 0.57 1.00 57571429
+ 0.71 0.57 1.00 64642857
+ 0.71 0.57 1.00 71714286
+ 0.71 0.57 1.00 78785714
+ 0.71 0.57 1.00 85857143
+ 0.71 0.57 1.00 92928571
+ 0.71 0.57 1.00 100000000
+ 0.71 0.64 0.00 1000000
+ 0.71 0.64 0.00 8071429
+ 0.71 0.64 0.00 15142857
+ 0.71 0.64 0.00 22214286
+ 0.71 0.64 0.00 29285714
+ 0.71 0.64 0.00 36357143
+ 0.71 0.64 0.00 43428571
+ 0.71 0.64 0.00 50500000
+ 0.71 0.64 0.00 57571429
+ 0.71 0.64 0.00 64642857
+ 0.71 0.64 0.00 71714286
+ 0.71 0.64 0.00 78785714
+ 0.71 0.64 0.00 85857143
+ 0.71 0.64 0.00 92928571
+ 0.71 0.64 0.00 100000000
+ 0.71 0.64 0.07 1000000
+ 0.71 0.64 0.07 8071429
+ 0.71 0.64 0.07 15142857
+ 0.71 0.64 0.07 22214286
+ 0.71 0.64 0.07 29285714
+ 0.71 0.64 0.07 36357143
+ 0.71 0.64 0.07 43428571
+ 0.71 0.64 0.07 50500000
+ 0.71 0.64 0.07 57571429
+ 0.71 0.64 0.07 64642857
+ 0.71 0.64 0.07 71714286
+ 0.71 0.64 0.07 78785714
+ 0.71 0.64 0.07 85857143
+ 0.71 0.64 0.07 92928571
+ 0.71 0.64 0.07 100000000
+ 0.71 0.64 0.14 1000000
+ 0.71 0.64 0.14 8071429
+ 0.71 0.64 0.14 15142857
+ 0.71 0.64 0.14 22214286
+ 0.71 0.64 0.14 29285714
+ 0.71 0.64 0.14 36357143
+ 0.71 0.64 0.14 43428571
+ 0.71 0.64 0.14 50500000
+ 0.71 0.64 0.14 57571429
+ 0.71 0.64 0.14 64642857
+ 0.71 0.64 0.14 71714286
+ 0.71 0.64 0.14 78785714
+ 0.71 0.64 0.14 85857143
+ 0.71 0.64 0.14 92928571
+ 0.71 0.64 0.14 100000000
+ 0.71 0.64 0.21 1000000
+ 0.71 0.64 0.21 8071429
+ 0.71 0.64 0.21 15142857
+ 0.71 0.64 0.21 22214286
+ 0.71 0.64 0.21 29285714
+ 0.71 0.64 0.21 36357143
+ 0.71 0.64 0.21 43428571
+ 0.71 0.64 0.21 50500000
+ 0.71 0.64 0.21 57571429
+ 0.71 0.64 0.21 64642857
+ 0.71 0.64 0.21 71714286
+ 0.71 0.64 0.21 78785714
+ 0.71 0.64 0.21 85857143
+ 0.71 0.64 0.21 92928571
+ 0.71 0.64 0.21 100000000
+ 0.71 0.64 0.29 1000000
+ 0.71 0.64 0.29 8071429
+ 0.71 0.64 0.29 15142857
+ 0.71 0.64 0.29 22214286
+ 0.71 0.64 0.29 29285714
+ 0.71 0.64 0.29 36357143
+ 0.71 0.64 0.29 43428571
+ 0.71 0.64 0.29 50500000
+ 0.71 0.64 0.29 57571429
+ 0.71 0.64 0.29 64642857
+ 0.71 0.64 0.29 71714286
+ 0.71 0.64 0.29 78785714
+ 0.71 0.64 0.29 85857143
+ 0.71 0.64 0.29 92928571
+ 0.71 0.64 0.29 100000000
+ 0.71 0.64 0.36 1000000
+ 0.71 0.64 0.36 8071429
+ 0.71 0.64 0.36 15142857
+ 0.71 0.64 0.36 22214286
+ 0.71 0.64 0.36 29285714
+ 0.71 0.64 0.36 36357143
+ 0.71 0.64 0.36 43428571
+ 0.71 0.64 0.36 50500000
+ 0.71 0.64 0.36 57571429
+ 0.71 0.64 0.36 64642857
+ 0.71 0.64 0.36 71714286
+ 0.71 0.64 0.36 78785714
+ 0.71 0.64 0.36 85857143
+ 0.71 0.64 0.36 92928571
+ 0.71 0.64 0.36 100000000
+ 0.71 0.64 0.43 1000000
+ 0.71 0.64 0.43 8071429
+ 0.71 0.64 0.43 15142857
+ 0.71 0.64 0.43 22214286
+ 0.71 0.64 0.43 29285714
+ 0.71 0.64 0.43 36357143
+ 0.71 0.64 0.43 43428571
+ 0.71 0.64 0.43 50500000
+ 0.71 0.64 0.43 57571429
+ 0.71 0.64 0.43 64642857
+ 0.71 0.64 0.43 71714286
+ 0.71 0.64 0.43 78785714
+ 0.71 0.64 0.43 85857143
+ 0.71 0.64 0.43 92928571
+ 0.71 0.64 0.43 100000000
+ 0.71 0.64 0.50 1000000
+ 0.71 0.64 0.50 8071429
+ 0.71 0.64 0.50 15142857
+ 0.71 0.64 0.50 22214286
+ 0.71 0.64 0.50 29285714
+ 0.71 0.64 0.50 36357143
+ 0.71 0.64 0.50 43428571
+ 0.71 0.64 0.50 50500000
+ 0.71 0.64 0.50 57571429
+ 0.71 0.64 0.50 64642857
+ 0.71 0.64 0.50 71714286
+ 0.71 0.64 0.50 78785714
+ 0.71 0.64 0.50 85857143
+ 0.71 0.64 0.50 92928571
+ 0.71 0.64 0.50 100000000
+ 0.71 0.64 0.57 1000000
+ 0.71 0.64 0.57 8071429
+ 0.71 0.64 0.57 15142857
+ 0.71 0.64 0.57 22214286
+ 0.71 0.64 0.57 29285714
+ 0.71 0.64 0.57 36357143
+ 0.71 0.64 0.57 43428571
+ 0.71 0.64 0.57 50500000
+ 0.71 0.64 0.57 57571429
+ 0.71 0.64 0.57 64642857
+ 0.71 0.64 0.57 71714286
+ 0.71 0.64 0.57 78785714
+ 0.71 0.64 0.57 85857143
+ 0.71 0.64 0.57 92928571
+ 0.71 0.64 0.57 100000000
+ 0.71 0.64 0.64 1000000
+ 0.71 0.64 0.64 8071429
+ 0.71 0.64 0.64 15142857
+ 0.71 0.64 0.64 22214286
+ 0.71 0.64 0.64 29285714
+ 0.71 0.64 0.64 36357143
+ 0.71 0.64 0.64 43428571
+ 0.71 0.64 0.64 50500000
+ 0.71 0.64 0.64 57571429
+ 0.71 0.64 0.64 64642857
+ 0.71 0.64 0.64 71714286
+ 0.71 0.64 0.64 78785714
+ 0.71 0.64 0.64 85857143
+ 0.71 0.64 0.64 92928571
+ 0.71 0.64 0.64 100000000
+ 0.71 0.64 0.71 1000000
+ 0.71 0.64 0.71 8071429
+ 0.71 0.64 0.71 15142857
+ 0.71 0.64 0.71 22214286
+ 0.71 0.64 0.71 29285714
+ 0.71 0.64 0.71 36357143
+ 0.71 0.64 0.71 43428571
+ 0.71 0.64 0.71 50500000
+ 0.71 0.64 0.71 57571429
+ 0.71 0.64 0.71 64642857
+ 0.71 0.64 0.71 71714286
+ 0.71 0.64 0.71 78785714
+ 0.71 0.64 0.71 85857143
+ 0.71 0.64 0.71 92928571
+ 0.71 0.64 0.71 100000000
+ 0.71 0.64 0.79 1000000
+ 0.71 0.64 0.79 8071429
+ 0.71 0.64 0.79 15142857
+ 0.71 0.64 0.79 22214286
+ 0.71 0.64 0.79 29285714
+ 0.71 0.64 0.79 36357143
+ 0.71 0.64 0.79 43428571
+ 0.71 0.64 0.79 50500000
+ 0.71 0.64 0.79 57571429
+ 0.71 0.64 0.79 64642857
+ 0.71 0.64 0.79 71714286
+ 0.71 0.64 0.79 78785714
+ 0.71 0.64 0.79 85857143
+ 0.71 0.64 0.79 92928571
+ 0.71 0.64 0.79 100000000
+ 0.71 0.64 0.86 1000000
+ 0.71 0.64 0.86 8071429
+ 0.71 0.64 0.86 15142857
+ 0.71 0.64 0.86 22214286
+ 0.71 0.64 0.86 29285714
+ 0.71 0.64 0.86 36357143
+ 0.71 0.64 0.86 43428571
+ 0.71 0.64 0.86 50500000
+ 0.71 0.64 0.86 57571429
+ 0.71 0.64 0.86 64642857
+ 0.71 0.64 0.86 71714286
+ 0.71 0.64 0.86 78785714
+ 0.71 0.64 0.86 85857143
+ 0.71 0.64 0.86 92928571
+ 0.71 0.64 0.86 100000000
+ 0.71 0.64 0.93 1000000
+ 0.71 0.64 0.93 8071429
+ 0.71 0.64 0.93 15142857
+ 0.71 0.64 0.93 22214286
+ 0.71 0.64 0.93 29285714
+ 0.71 0.64 0.93 36357143
+ 0.71 0.64 0.93 43428571
+ 0.71 0.64 0.93 50500000
+ 0.71 0.64 0.93 57571429
+ 0.71 0.64 0.93 64642857
+ 0.71 0.64 0.93 71714286
+ 0.71 0.64 0.93 78785714
+ 0.71 0.64 0.93 85857143
+ 0.71 0.64 0.93 92928571
+ 0.71 0.64 0.93 100000000
+ 0.71 0.64 1.00 1000000
+ 0.71 0.64 1.00 8071429
+ 0.71 0.64 1.00 15142857
+ 0.71 0.64 1.00 22214286
+ 0.71 0.64 1.00 29285714
+ 0.71 0.64 1.00 36357143
+ 0.71 0.64 1.00 43428571
+ 0.71 0.64 1.00 50500000
+ 0.71 0.64 1.00 57571429
+ 0.71 0.64 1.00 64642857
+ 0.71 0.64 1.00 71714286
+ 0.71 0.64 1.00 78785714
+ 0.71 0.64 1.00 85857143
+ 0.71 0.64 1.00 92928571
+ 0.71 0.64 1.00 100000000
+ 0.71 0.71 0.00 1000000
+ 0.71 0.71 0.00 8071429
+ 0.71 0.71 0.00 15142857
+ 0.71 0.71 0.00 22214286
+ 0.71 0.71 0.00 29285714
+ 0.71 0.71 0.00 36357143
+ 0.71 0.71 0.00 43428571
+ 0.71 0.71 0.00 50500000
+ 0.71 0.71 0.00 57571429
+ 0.71 0.71 0.00 64642857
+ 0.71 0.71 0.00 71714286
+ 0.71 0.71 0.00 78785714
+ 0.71 0.71 0.00 85857143
+ 0.71 0.71 0.00 92928571
+ 0.71 0.71 0.00 100000000
+ 0.71 0.71 0.07 1000000
+ 0.71 0.71 0.07 8071429
+ 0.71 0.71 0.07 15142857
+ 0.71 0.71 0.07 22214286
+ 0.71 0.71 0.07 29285714
+ 0.71 0.71 0.07 36357143
+ 0.71 0.71 0.07 43428571
+ 0.71 0.71 0.07 50500000
+ 0.71 0.71 0.07 57571429
+ 0.71 0.71 0.07 64642857
+ 0.71 0.71 0.07 71714286
+ 0.71 0.71 0.07 78785714
+ 0.71 0.71 0.07 85857143
+ 0.71 0.71 0.07 92928571
+ 0.71 0.71 0.07 100000000
+ 0.71 0.71 0.14 1000000
+ 0.71 0.71 0.14 8071429
+ 0.71 0.71 0.14 15142857
+ 0.71 0.71 0.14 22214286
+ 0.71 0.71 0.14 29285714
+ 0.71 0.71 0.14 36357143
+ 0.71 0.71 0.14 43428571
+ 0.71 0.71 0.14 50500000
+ 0.71 0.71 0.14 57571429
+ 0.71 0.71 0.14 64642857
+ 0.71 0.71 0.14 71714286
+ 0.71 0.71 0.14 78785714
+ 0.71 0.71 0.14 85857143
+ 0.71 0.71 0.14 92928571
+ 0.71 0.71 0.14 100000000
+ 0.71 0.71 0.21 1000000
+ 0.71 0.71 0.21 8071429
+ 0.71 0.71 0.21 15142857
+ 0.71 0.71 0.21 22214286
+ 0.71 0.71 0.21 29285714
+ 0.71 0.71 0.21 36357143
+ 0.71 0.71 0.21 43428571
+ 0.71 0.71 0.21 50500000
+ 0.71 0.71 0.21 57571429
+ 0.71 0.71 0.21 64642857
+ 0.71 0.71 0.21 71714286
+ 0.71 0.71 0.21 78785714
+ 0.71 0.71 0.21 85857143
+ 0.71 0.71 0.21 92928571
+ 0.71 0.71 0.21 100000000
+ 0.71 0.71 0.29 1000000
+ 0.71 0.71 0.29 8071429
+ 0.71 0.71 0.29 15142857
+ 0.71 0.71 0.29 22214286
+ 0.71 0.71 0.29 29285714
+ 0.71 0.71 0.29 36357143
+ 0.71 0.71 0.29 43428571
+ 0.71 0.71 0.29 50500000
+ 0.71 0.71 0.29 57571429
+ 0.71 0.71 0.29 64642857
+ 0.71 0.71 0.29 71714286
+ 0.71 0.71 0.29 78785714
+ 0.71 0.71 0.29 85857143
+ 0.71 0.71 0.29 92928571
+ 0.71 0.71 0.29 100000000
+ 0.71 0.71 0.36 1000000
+ 0.71 0.71 0.36 8071429
+ 0.71 0.71 0.36 15142857
+ 0.71 0.71 0.36 22214286
+ 0.71 0.71 0.36 29285714
+ 0.71 0.71 0.36 36357143
+ 0.71 0.71 0.36 43428571
+ 0.71 0.71 0.36 50500000
+ 0.71 0.71 0.36 57571429
+ 0.71 0.71 0.36 64642857
+ 0.71 0.71 0.36 71714286
+ 0.71 0.71 0.36 78785714
+ 0.71 0.71 0.36 85857143
+ 0.71 0.71 0.36 92928571
+ 0.71 0.71 0.36 100000000
+ 0.71 0.71 0.43 1000000
+ 0.71 0.71 0.43 8071429
+ 0.71 0.71 0.43 15142857
+ 0.71 0.71 0.43 22214286
+ 0.71 0.71 0.43 29285714
+ 0.71 0.71 0.43 36357143
+ 0.71 0.71 0.43 43428571
+ 0.71 0.71 0.43 50500000
+ 0.71 0.71 0.43 57571429
+ 0.71 0.71 0.43 64642857
+ 0.71 0.71 0.43 71714286
+ 0.71 0.71 0.43 78785714
+ 0.71 0.71 0.43 85857143
+ 0.71 0.71 0.43 92928571
+ 0.71 0.71 0.43 100000000
+ 0.71 0.71 0.50 1000000
+ 0.71 0.71 0.50 8071429
+ 0.71 0.71 0.50 15142857
+ 0.71 0.71 0.50 22214286
+ 0.71 0.71 0.50 29285714
+ 0.71 0.71 0.50 36357143
+ 0.71 0.71 0.50 43428571
+ 0.71 0.71 0.50 50500000
+ 0.71 0.71 0.50 57571429
+ 0.71 0.71 0.50 64642857
+ 0.71 0.71 0.50 71714286
+ 0.71 0.71 0.50 78785714
+ 0.71 0.71 0.50 85857143
+ 0.71 0.71 0.50 92928571
+ 0.71 0.71 0.50 100000000
+ 0.71 0.71 0.57 1000000
+ 0.71 0.71 0.57 8071429
+ 0.71 0.71 0.57 15142857
+ 0.71 0.71 0.57 22214286
+ 0.71 0.71 0.57 29285714
+ 0.71 0.71 0.57 36357143
+ 0.71 0.71 0.57 43428571
+ 0.71 0.71 0.57 50500000
+ 0.71 0.71 0.57 57571429
+ 0.71 0.71 0.57 64642857
+ 0.71 0.71 0.57 71714286
+ 0.71 0.71 0.57 78785714
+ 0.71 0.71 0.57 85857143
+ 0.71 0.71 0.57 92928571
+ 0.71 0.71 0.57 100000000
+ 0.71 0.71 0.64 1000000
+ 0.71 0.71 0.64 8071429
+ 0.71 0.71 0.64 15142857
+ 0.71 0.71 0.64 22214286
+ 0.71 0.71 0.64 29285714
+ 0.71 0.71 0.64 36357143
+ 0.71 0.71 0.64 43428571
+ 0.71 0.71 0.64 50500000
+ 0.71 0.71 0.64 57571429
+ 0.71 0.71 0.64 64642857
+ 0.71 0.71 0.64 71714286
+ 0.71 0.71 0.64 78785714
+ 0.71 0.71 0.64 85857143
+ 0.71 0.71 0.64 92928571
+ 0.71 0.71 0.64 100000000
+ 0.71 0.71 0.71 1000000
+ 0.71 0.71 0.71 8071429
+ 0.71 0.71 0.71 15142857
+ 0.71 0.71 0.71 22214286
+ 0.71 0.71 0.71 29285714
+ 0.71 0.71 0.71 36357143
+ 0.71 0.71 0.71 43428571
+ 0.71 0.71 0.71 50500000
+ 0.71 0.71 0.71 57571429
+ 0.71 0.71 0.71 64642857
+ 0.71 0.71 0.71 71714286
+ 0.71 0.71 0.71 78785714
+ 0.71 0.71 0.71 85857143
+ 0.71 0.71 0.71 92928571
+ 0.71 0.71 0.71 100000000
+ 0.71 0.71 0.79 1000000
+ 0.71 0.71 0.79 8071429
+ 0.71 0.71 0.79 15142857
+ 0.71 0.71 0.79 22214286
+ 0.71 0.71 0.79 29285714
+ 0.71 0.71 0.79 36357143
+ 0.71 0.71 0.79 43428571
+ 0.71 0.71 0.79 50500000
+ 0.71 0.71 0.79 57571429
+ 0.71 0.71 0.79 64642857
+ 0.71 0.71 0.79 71714286
+ 0.71 0.71 0.79 78785714
+ 0.71 0.71 0.79 85857143
+ 0.71 0.71 0.79 92928571
+ 0.71 0.71 0.79 100000000
+ 0.71 0.71 0.86 1000000
+ 0.71 0.71 0.86 8071429
+ 0.71 0.71 0.86 15142857
+ 0.71 0.71 0.86 22214286
+ 0.71 0.71 0.86 29285714
+ 0.71 0.71 0.86 36357143
+ 0.71 0.71 0.86 43428571
+ 0.71 0.71 0.86 50500000
+ 0.71 0.71 0.86 57571429
+ 0.71 0.71 0.86 64642857
+ 0.71 0.71 0.86 71714286
+ 0.71 0.71 0.86 78785714
+ 0.71 0.71 0.86 85857143
+ 0.71 0.71 0.86 92928571
+ 0.71 0.71 0.86 100000000
+ 0.71 0.71 0.93 1000000
+ 0.71 0.71 0.93 8071429
+ 0.71 0.71 0.93 15142857
+ 0.71 0.71 0.93 22214286
+ 0.71 0.71 0.93 29285714
+ 0.71 0.71 0.93 36357143
+ 0.71 0.71 0.93 43428571
+ 0.71 0.71 0.93 50500000
+ 0.71 0.71 0.93 57571429
+ 0.71 0.71 0.93 64642857
+ 0.71 0.71 0.93 71714286
+ 0.71 0.71 0.93 78785714
+ 0.71 0.71 0.93 85857143
+ 0.71 0.71 0.93 92928571
+ 0.71 0.71 0.93 100000000
+ 0.71 0.71 1.00 1000000
+ 0.71 0.71 1.00 8071429
+ 0.71 0.71 1.00 15142857
+ 0.71 0.71 1.00 22214286
+ 0.71 0.71 1.00 29285714
+ 0.71 0.71 1.00 36357143
+ 0.71 0.71 1.00 43428571
+ 0.71 0.71 1.00 50500000
+ 0.71 0.71 1.00 57571429
+ 0.71 0.71 1.00 64642857
+ 0.71 0.71 1.00 71714286
+ 0.71 0.71 1.00 78785714
+ 0.71 0.71 1.00 85857143
+ 0.71 0.71 1.00 92928571
+ 0.71 0.71 1.00 100000000
+ 0.71 0.79 0.00 1000000
+ 0.71 0.79 0.00 8071429
+ 0.71 0.79 0.00 15142857
+ 0.71 0.79 0.00 22214286
+ 0.71 0.79 0.00 29285714
+ 0.71 0.79 0.00 36357143
+ 0.71 0.79 0.00 43428571
+ 0.71 0.79 0.00 50500000
+ 0.71 0.79 0.00 57571429
+ 0.71 0.79 0.00 64642857
+ 0.71 0.79 0.00 71714286
+ 0.71 0.79 0.00 78785714
+ 0.71 0.79 0.00 85857143
+ 0.71 0.79 0.00 92928571
+ 0.71 0.79 0.00 100000000
+ 0.71 0.79 0.07 1000000
+ 0.71 0.79 0.07 8071429
+ 0.71 0.79 0.07 15142857
+ 0.71 0.79 0.07 22214286
+ 0.71 0.79 0.07 29285714
+ 0.71 0.79 0.07 36357143
+ 0.71 0.79 0.07 43428571
+ 0.71 0.79 0.07 50500000
+ 0.71 0.79 0.07 57571429
+ 0.71 0.79 0.07 64642857
+ 0.71 0.79 0.07 71714286
+ 0.71 0.79 0.07 78785714
+ 0.71 0.79 0.07 85857143
+ 0.71 0.79 0.07 92928571
+ 0.71 0.79 0.07 100000000
+ 0.71 0.79 0.14 1000000
+ 0.71 0.79 0.14 8071429
+ 0.71 0.79 0.14 15142857
+ 0.71 0.79 0.14 22214286
+ 0.71 0.79 0.14 29285714
+ 0.71 0.79 0.14 36357143
+ 0.71 0.79 0.14 43428571
+ 0.71 0.79 0.14 50500000
+ 0.71 0.79 0.14 57571429
+ 0.71 0.79 0.14 64642857
+ 0.71 0.79 0.14 71714286
+ 0.71 0.79 0.14 78785714
+ 0.71 0.79 0.14 85857143
+ 0.71 0.79 0.14 92928571
+ 0.71 0.79 0.14 100000000
+ 0.71 0.79 0.21 1000000
+ 0.71 0.79 0.21 8071429
+ 0.71 0.79 0.21 15142857
+ 0.71 0.79 0.21 22214286
+ 0.71 0.79 0.21 29285714
+ 0.71 0.79 0.21 36357143
+ 0.71 0.79 0.21 43428571
+ 0.71 0.79 0.21 50500000
+ 0.71 0.79 0.21 57571429
+ 0.71 0.79 0.21 64642857
+ 0.71 0.79 0.21 71714286
+ 0.71 0.79 0.21 78785714
+ 0.71 0.79 0.21 85857143
+ 0.71 0.79 0.21 92928571
+ 0.71 0.79 0.21 100000000
+ 0.71 0.79 0.29 1000000
+ 0.71 0.79 0.29 8071429
+ 0.71 0.79 0.29 15142857
+ 0.71 0.79 0.29 22214286
+ 0.71 0.79 0.29 29285714
+ 0.71 0.79 0.29 36357143
+ 0.71 0.79 0.29 43428571
+ 0.71 0.79 0.29 50500000
+ 0.71 0.79 0.29 57571429
+ 0.71 0.79 0.29 64642857
+ 0.71 0.79 0.29 71714286
+ 0.71 0.79 0.29 78785714
+ 0.71 0.79 0.29 85857143
+ 0.71 0.79 0.29 92928571
+ 0.71 0.79 0.29 100000000
+ 0.71 0.79 0.36 1000000
+ 0.71 0.79 0.36 8071429
+ 0.71 0.79 0.36 15142857
+ 0.71 0.79 0.36 22214286
+ 0.71 0.79 0.36 29285714
+ 0.71 0.79 0.36 36357143
+ 0.71 0.79 0.36 43428571
+ 0.71 0.79 0.36 50500000
+ 0.71 0.79 0.36 57571429
+ 0.71 0.79 0.36 64642857
+ 0.71 0.79 0.36 71714286
+ 0.71 0.79 0.36 78785714
+ 0.71 0.79 0.36 85857143
+ 0.71 0.79 0.36 92928571
+ 0.71 0.79 0.36 100000000
+ 0.71 0.79 0.43 1000000
+ 0.71 0.79 0.43 8071429
+ 0.71 0.79 0.43 15142857
+ 0.71 0.79 0.43 22214286
+ 0.71 0.79 0.43 29285714
+ 0.71 0.79 0.43 36357143
+ 0.71 0.79 0.43 43428571
+ 0.71 0.79 0.43 50500000
+ 0.71 0.79 0.43 57571429
+ 0.71 0.79 0.43 64642857
+ 0.71 0.79 0.43 71714286
+ 0.71 0.79 0.43 78785714
+ 0.71 0.79 0.43 85857143
+ 0.71 0.79 0.43 92928571
+ 0.71 0.79 0.43 100000000
+ 0.71 0.79 0.50 1000000
+ 0.71 0.79 0.50 8071429
+ 0.71 0.79 0.50 15142857
+ 0.71 0.79 0.50 22214286
+ 0.71 0.79 0.50 29285714
+ 0.71 0.79 0.50 36357143
+ 0.71 0.79 0.50 43428571
+ 0.71 0.79 0.50 50500000
+ 0.71 0.79 0.50 57571429
+ 0.71 0.79 0.50 64642857
+ 0.71 0.79 0.50 71714286
+ 0.71 0.79 0.50 78785714
+ 0.71 0.79 0.50 85857143
+ 0.71 0.79 0.50 92928571
+ 0.71 0.79 0.50 100000000
+ 0.71 0.79 0.57 1000000
+ 0.71 0.79 0.57 8071429
+ 0.71 0.79 0.57 15142857
+ 0.71 0.79 0.57 22214286
+ 0.71 0.79 0.57 29285714
+ 0.71 0.79 0.57 36357143
+ 0.71 0.79 0.57 43428571
+ 0.71 0.79 0.57 50500000
+ 0.71 0.79 0.57 57571429
+ 0.71 0.79 0.57 64642857
+ 0.71 0.79 0.57 71714286
+ 0.71 0.79 0.57 78785714
+ 0.71 0.79 0.57 85857143
+ 0.71 0.79 0.57 92928571
+ 0.71 0.79 0.57 100000000
+ 0.71 0.79 0.64 1000000
+ 0.71 0.79 0.64 8071429
+ 0.71 0.79 0.64 15142857
+ 0.71 0.79 0.64 22214286
+ 0.71 0.79 0.64 29285714
+ 0.71 0.79 0.64 36357143
+ 0.71 0.79 0.64 43428571
+ 0.71 0.79 0.64 50500000
+ 0.71 0.79 0.64 57571429
+ 0.71 0.79 0.64 64642857
+ 0.71 0.79 0.64 71714286
+ 0.71 0.79 0.64 78785714
+ 0.71 0.79 0.64 85857143
+ 0.71 0.79 0.64 92928571
+ 0.71 0.79 0.64 100000000
+ 0.71 0.79 0.71 1000000
+ 0.71 0.79 0.71 8071429
+ 0.71 0.79 0.71 15142857
+ 0.71 0.79 0.71 22214286
+ 0.71 0.79 0.71 29285714
+ 0.71 0.79 0.71 36357143
+ 0.71 0.79 0.71 43428571
+ 0.71 0.79 0.71 50500000
+ 0.71 0.79 0.71 57571429
+ 0.71 0.79 0.71 64642857
+ 0.71 0.79 0.71 71714286
+ 0.71 0.79 0.71 78785714
+ 0.71 0.79 0.71 85857143
+ 0.71 0.79 0.71 92928571
+ 0.71 0.79 0.71 100000000
+ 0.71 0.79 0.79 1000000
+ 0.71 0.79 0.79 8071429
+ 0.71 0.79 0.79 15142857
+ 0.71 0.79 0.79 22214286
+ 0.71 0.79 0.79 29285714
+ 0.71 0.79 0.79 36357143
+ 0.71 0.79 0.79 43428571
+ 0.71 0.79 0.79 50500000
+ 0.71 0.79 0.79 57571429
+ 0.71 0.79 0.79 64642857
+ 0.71 0.79 0.79 71714286
+ 0.71 0.79 0.79 78785714
+ 0.71 0.79 0.79 85857143
+ 0.71 0.79 0.79 92928571
+ 0.71 0.79 0.79 100000000
+ 0.71 0.79 0.86 1000000
+ 0.71 0.79 0.86 8071429
+ 0.71 0.79 0.86 15142857
+ 0.71 0.79 0.86 22214286
+ 0.71 0.79 0.86 29285714
+ 0.71 0.79 0.86 36357143
+ 0.71 0.79 0.86 43428571
+ 0.71 0.79 0.86 50500000
+ 0.71 0.79 0.86 57571429
+ 0.71 0.79 0.86 64642857
+ 0.71 0.79 0.86 71714286
+ 0.71 0.79 0.86 78785714
+ 0.71 0.79 0.86 85857143
+ 0.71 0.79 0.86 92928571
+ 0.71 0.79 0.86 100000000
+ 0.71 0.79 0.93 1000000
+ 0.71 0.79 0.93 8071429
+ 0.71 0.79 0.93 15142857
+ 0.71 0.79 0.93 22214286
+ 0.71 0.79 0.93 29285714
+ 0.71 0.79 0.93 36357143
+ 0.71 0.79 0.93 43428571
+ 0.71 0.79 0.93 50500000
+ 0.71 0.79 0.93 57571429
+ 0.71 0.79 0.93 64642857
+ 0.71 0.79 0.93 71714286
+ 0.71 0.79 0.93 78785714
+ 0.71 0.79 0.93 85857143
+ 0.71 0.79 0.93 92928571
+ 0.71 0.79 0.93 100000000
+ 0.71 0.79 1.00 1000000
+ 0.71 0.79 1.00 8071429
+ 0.71 0.79 1.00 15142857
+ 0.71 0.79 1.00 22214286
+ 0.71 0.79 1.00 29285714
+ 0.71 0.79 1.00 36357143
+ 0.71 0.79 1.00 43428571
+ 0.71 0.79 1.00 50500000
+ 0.71 0.79 1.00 57571429
+ 0.71 0.79 1.00 64642857
+ 0.71 0.79 1.00 71714286
+ 0.71 0.79 1.00 78785714
+ 0.71 0.79 1.00 85857143
+ 0.71 0.79 1.00 92928571
+ 0.71 0.79 1.00 100000000
+ 0.71 0.86 0.00 1000000
+ 0.71 0.86 0.00 8071429
+ 0.71 0.86 0.00 15142857
+ 0.71 0.86 0.00 22214286
+ 0.71 0.86 0.00 29285714
+ 0.71 0.86 0.00 36357143
+ 0.71 0.86 0.00 43428571
+ 0.71 0.86 0.00 50500000
+ 0.71 0.86 0.00 57571429
+ 0.71 0.86 0.00 64642857
+ 0.71 0.86 0.00 71714286
+ 0.71 0.86 0.00 78785714
+ 0.71 0.86 0.00 85857143
+ 0.71 0.86 0.00 92928571
+ 0.71 0.86 0.00 100000000
+ 0.71 0.86 0.07 1000000
+ 0.71 0.86 0.07 8071429
+ 0.71 0.86 0.07 15142857
+ 0.71 0.86 0.07 22214286
+ 0.71 0.86 0.07 29285714
+ 0.71 0.86 0.07 36357143
+ 0.71 0.86 0.07 43428571
+ 0.71 0.86 0.07 50500000
+ 0.71 0.86 0.07 57571429
+ 0.71 0.86 0.07 64642857
+ 0.71 0.86 0.07 71714286
+ 0.71 0.86 0.07 78785714
+ 0.71 0.86 0.07 85857143
+ 0.71 0.86 0.07 92928571
+ 0.71 0.86 0.07 100000000
+ 0.71 0.86 0.14 1000000
+ 0.71 0.86 0.14 8071429
+ 0.71 0.86 0.14 15142857
+ 0.71 0.86 0.14 22214286
+ 0.71 0.86 0.14 29285714
+ 0.71 0.86 0.14 36357143
+ 0.71 0.86 0.14 43428571
+ 0.71 0.86 0.14 50500000
+ 0.71 0.86 0.14 57571429
+ 0.71 0.86 0.14 64642857
+ 0.71 0.86 0.14 71714286
+ 0.71 0.86 0.14 78785714
+ 0.71 0.86 0.14 85857143
+ 0.71 0.86 0.14 92928571
+ 0.71 0.86 0.14 100000000
+ 0.71 0.86 0.21 1000000
+ 0.71 0.86 0.21 8071429
+ 0.71 0.86 0.21 15142857
+ 0.71 0.86 0.21 22214286
+ 0.71 0.86 0.21 29285714
+ 0.71 0.86 0.21 36357143
+ 0.71 0.86 0.21 43428571
+ 0.71 0.86 0.21 50500000
+ 0.71 0.86 0.21 57571429
+ 0.71 0.86 0.21 64642857
+ 0.71 0.86 0.21 71714286
+ 0.71 0.86 0.21 78785714
+ 0.71 0.86 0.21 85857143
+ 0.71 0.86 0.21 92928571
+ 0.71 0.86 0.21 100000000
+ 0.71 0.86 0.29 1000000
+ 0.71 0.86 0.29 8071429
+ 0.71 0.86 0.29 15142857
+ 0.71 0.86 0.29 22214286
+ 0.71 0.86 0.29 29285714
+ 0.71 0.86 0.29 36357143
+ 0.71 0.86 0.29 43428571
+ 0.71 0.86 0.29 50500000
+ 0.71 0.86 0.29 57571429
+ 0.71 0.86 0.29 64642857
+ 0.71 0.86 0.29 71714286
+ 0.71 0.86 0.29 78785714
+ 0.71 0.86 0.29 85857143
+ 0.71 0.86 0.29 92928571
+ 0.71 0.86 0.29 100000000
+ 0.71 0.86 0.36 1000000
+ 0.71 0.86 0.36 8071429
+ 0.71 0.86 0.36 15142857
+ 0.71 0.86 0.36 22214286
+ 0.71 0.86 0.36 29285714
+ 0.71 0.86 0.36 36357143
+ 0.71 0.86 0.36 43428571
+ 0.71 0.86 0.36 50500000
+ 0.71 0.86 0.36 57571429
+ 0.71 0.86 0.36 64642857
+ 0.71 0.86 0.36 71714286
+ 0.71 0.86 0.36 78785714
+ 0.71 0.86 0.36 85857143
+ 0.71 0.86 0.36 92928571
+ 0.71 0.86 0.36 100000000
+ 0.71 0.86 0.43 1000000
+ 0.71 0.86 0.43 8071429
+ 0.71 0.86 0.43 15142857
+ 0.71 0.86 0.43 22214286
+ 0.71 0.86 0.43 29285714
+ 0.71 0.86 0.43 36357143
+ 0.71 0.86 0.43 43428571
+ 0.71 0.86 0.43 50500000
+ 0.71 0.86 0.43 57571429
+ 0.71 0.86 0.43 64642857
+ 0.71 0.86 0.43 71714286
+ 0.71 0.86 0.43 78785714
+ 0.71 0.86 0.43 85857143
+ 0.71 0.86 0.43 92928571
+ 0.71 0.86 0.43 100000000
+ 0.71 0.86 0.50 1000000
+ 0.71 0.86 0.50 8071429
+ 0.71 0.86 0.50 15142857
+ 0.71 0.86 0.50 22214286
+ 0.71 0.86 0.50 29285714
+ 0.71 0.86 0.50 36357143
+ 0.71 0.86 0.50 43428571
+ 0.71 0.86 0.50 50500000
+ 0.71 0.86 0.50 57571429
+ 0.71 0.86 0.50 64642857
+ 0.71 0.86 0.50 71714286
+ 0.71 0.86 0.50 78785714
+ 0.71 0.86 0.50 85857143
+ 0.71 0.86 0.50 92928571
+ 0.71 0.86 0.50 100000000
+ 0.71 0.86 0.57 1000000
+ 0.71 0.86 0.57 8071429
+ 0.71 0.86 0.57 15142857
+ 0.71 0.86 0.57 22214286
+ 0.71 0.86 0.57 29285714
+ 0.71 0.86 0.57 36357143
+ 0.71 0.86 0.57 43428571
+ 0.71 0.86 0.57 50500000
+ 0.71 0.86 0.57 57571429
+ 0.71 0.86 0.57 64642857
+ 0.71 0.86 0.57 71714286
+ 0.71 0.86 0.57 78785714
+ 0.71 0.86 0.57 85857143
+ 0.71 0.86 0.57 92928571
+ 0.71 0.86 0.57 100000000
+ 0.71 0.86 0.64 1000000
+ 0.71 0.86 0.64 8071429
+ 0.71 0.86 0.64 15142857
+ 0.71 0.86 0.64 22214286
+ 0.71 0.86 0.64 29285714
+ 0.71 0.86 0.64 36357143
+ 0.71 0.86 0.64 43428571
+ 0.71 0.86 0.64 50500000
+ 0.71 0.86 0.64 57571429
+ 0.71 0.86 0.64 64642857
+ 0.71 0.86 0.64 71714286
+ 0.71 0.86 0.64 78785714
+ 0.71 0.86 0.64 85857143
+ 0.71 0.86 0.64 92928571
+ 0.71 0.86 0.64 100000000
+ 0.71 0.86 0.71 1000000
+ 0.71 0.86 0.71 8071429
+ 0.71 0.86 0.71 15142857
+ 0.71 0.86 0.71 22214286
+ 0.71 0.86 0.71 29285714
+ 0.71 0.86 0.71 36357143
+ 0.71 0.86 0.71 43428571
+ 0.71 0.86 0.71 50500000
+ 0.71 0.86 0.71 57571429
+ 0.71 0.86 0.71 64642857
+ 0.71 0.86 0.71 71714286
+ 0.71 0.86 0.71 78785714
+ 0.71 0.86 0.71 85857143
+ 0.71 0.86 0.71 92928571
+ 0.71 0.86 0.71 100000000
+ 0.71 0.86 0.79 1000000
+ 0.71 0.86 0.79 8071429
+ 0.71 0.86 0.79 15142857
+ 0.71 0.86 0.79 22214286
+ 0.71 0.86 0.79 29285714
+ 0.71 0.86 0.79 36357143
+ 0.71 0.86 0.79 43428571
+ 0.71 0.86 0.79 50500000
+ 0.71 0.86 0.79 57571429
+ 0.71 0.86 0.79 64642857
+ 0.71 0.86 0.79 71714286
+ 0.71 0.86 0.79 78785714
+ 0.71 0.86 0.79 85857143
+ 0.71 0.86 0.79 92928571
+ 0.71 0.86 0.79 100000000
+ 0.71 0.86 0.86 1000000
+ 0.71 0.86 0.86 8071429
+ 0.71 0.86 0.86 15142857
+ 0.71 0.86 0.86 22214286
+ 0.71 0.86 0.86 29285714
+ 0.71 0.86 0.86 36357143
+ 0.71 0.86 0.86 43428571
+ 0.71 0.86 0.86 50500000
+ 0.71 0.86 0.86 57571429
+ 0.71 0.86 0.86 64642857
+ 0.71 0.86 0.86 71714286
+ 0.71 0.86 0.86 78785714
+ 0.71 0.86 0.86 85857143
+ 0.71 0.86 0.86 92928571
+ 0.71 0.86 0.86 100000000
+ 0.71 0.86 0.93 1000000
+ 0.71 0.86 0.93 8071429
+ 0.71 0.86 0.93 15142857
+ 0.71 0.86 0.93 22214286
+ 0.71 0.86 0.93 29285714
+ 0.71 0.86 0.93 36357143
+ 0.71 0.86 0.93 43428571
+ 0.71 0.86 0.93 50500000
+ 0.71 0.86 0.93 57571429
+ 0.71 0.86 0.93 64642857
+ 0.71 0.86 0.93 71714286
+ 0.71 0.86 0.93 78785714
+ 0.71 0.86 0.93 85857143
+ 0.71 0.86 0.93 92928571
+ 0.71 0.86 0.93 100000000
+ 0.71 0.86 1.00 1000000
+ 0.71 0.86 1.00 8071429
+ 0.71 0.86 1.00 15142857
+ 0.71 0.86 1.00 22214286
+ 0.71 0.86 1.00 29285714
+ 0.71 0.86 1.00 36357143
+ 0.71 0.86 1.00 43428571
+ 0.71 0.86 1.00 50500000
+ 0.71 0.86 1.00 57571429
+ 0.71 0.86 1.00 64642857
+ 0.71 0.86 1.00 71714286
+ 0.71 0.86 1.00 78785714
+ 0.71 0.86 1.00 85857143
+ 0.71 0.86 1.00 92928571
+ 0.71 0.86 1.00 100000000
+ 0.71 0.93 0.00 1000000
+ 0.71 0.93 0.00 8071429
+ 0.71 0.93 0.00 15142857
+ 0.71 0.93 0.00 22214286
+ 0.71 0.93 0.00 29285714
+ 0.71 0.93 0.00 36357143
+ 0.71 0.93 0.00 43428571
+ 0.71 0.93 0.00 50500000
+ 0.71 0.93 0.00 57571429
+ 0.71 0.93 0.00 64642857
+ 0.71 0.93 0.00 71714286
+ 0.71 0.93 0.00 78785714
+ 0.71 0.93 0.00 85857143
+ 0.71 0.93 0.00 92928571
+ 0.71 0.93 0.00 100000000
+ 0.71 0.93 0.07 1000000
+ 0.71 0.93 0.07 8071429
+ 0.71 0.93 0.07 15142857
+ 0.71 0.93 0.07 22214286
+ 0.71 0.93 0.07 29285714
+ 0.71 0.93 0.07 36357143
+ 0.71 0.93 0.07 43428571
+ 0.71 0.93 0.07 50500000
+ 0.71 0.93 0.07 57571429
+ 0.71 0.93 0.07 64642857
+ 0.71 0.93 0.07 71714286
+ 0.71 0.93 0.07 78785714
+ 0.71 0.93 0.07 85857143
+ 0.71 0.93 0.07 92928571
+ 0.71 0.93 0.07 100000000
+ 0.71 0.93 0.14 1000000
+ 0.71 0.93 0.14 8071429
+ 0.71 0.93 0.14 15142857
+ 0.71 0.93 0.14 22214286
+ 0.71 0.93 0.14 29285714
+ 0.71 0.93 0.14 36357143
+ 0.71 0.93 0.14 43428571
+ 0.71 0.93 0.14 50500000
+ 0.71 0.93 0.14 57571429
+ 0.71 0.93 0.14 64642857
+ 0.71 0.93 0.14 71714286
+ 0.71 0.93 0.14 78785714
+ 0.71 0.93 0.14 85857143
+ 0.71 0.93 0.14 92928571
+ 0.71 0.93 0.14 100000000
+ 0.71 0.93 0.21 1000000
+ 0.71 0.93 0.21 8071429
+ 0.71 0.93 0.21 15142857
+ 0.71 0.93 0.21 22214286
+ 0.71 0.93 0.21 29285714
+ 0.71 0.93 0.21 36357143
+ 0.71 0.93 0.21 43428571
+ 0.71 0.93 0.21 50500000
+ 0.71 0.93 0.21 57571429
+ 0.71 0.93 0.21 64642857
+ 0.71 0.93 0.21 71714286
+ 0.71 0.93 0.21 78785714
+ 0.71 0.93 0.21 85857143
+ 0.71 0.93 0.21 92928571
+ 0.71 0.93 0.21 100000000
+ 0.71 0.93 0.29 1000000
+ 0.71 0.93 0.29 8071429
+ 0.71 0.93 0.29 15142857
+ 0.71 0.93 0.29 22214286
+ 0.71 0.93 0.29 29285714
+ 0.71 0.93 0.29 36357143
+ 0.71 0.93 0.29 43428571
+ 0.71 0.93 0.29 50500000
+ 0.71 0.93 0.29 57571429
+ 0.71 0.93 0.29 64642857
+ 0.71 0.93 0.29 71714286
+ 0.71 0.93 0.29 78785714
+ 0.71 0.93 0.29 85857143
+ 0.71 0.93 0.29 92928571
+ 0.71 0.93 0.29 100000000
+ 0.71 0.93 0.36 1000000
+ 0.71 0.93 0.36 8071429
+ 0.71 0.93 0.36 15142857
+ 0.71 0.93 0.36 22214286
+ 0.71 0.93 0.36 29285714
+ 0.71 0.93 0.36 36357143
+ 0.71 0.93 0.36 43428571
+ 0.71 0.93 0.36 50500000
+ 0.71 0.93 0.36 57571429
+ 0.71 0.93 0.36 64642857
+ 0.71 0.93 0.36 71714286
+ 0.71 0.93 0.36 78785714
+ 0.71 0.93 0.36 85857143
+ 0.71 0.93 0.36 92928571
+ 0.71 0.93 0.36 100000000
+ 0.71 0.93 0.43 1000000
+ 0.71 0.93 0.43 8071429
+ 0.71 0.93 0.43 15142857
+ 0.71 0.93 0.43 22214286
+ 0.71 0.93 0.43 29285714
+ 0.71 0.93 0.43 36357143
+ 0.71 0.93 0.43 43428571
+ 0.71 0.93 0.43 50500000
+ 0.71 0.93 0.43 57571429
+ 0.71 0.93 0.43 64642857
+ 0.71 0.93 0.43 71714286
+ 0.71 0.93 0.43 78785714
+ 0.71 0.93 0.43 85857143
+ 0.71 0.93 0.43 92928571
+ 0.71 0.93 0.43 100000000
+ 0.71 0.93 0.50 1000000
+ 0.71 0.93 0.50 8071429
+ 0.71 0.93 0.50 15142857
+ 0.71 0.93 0.50 22214286
+ 0.71 0.93 0.50 29285714
+ 0.71 0.93 0.50 36357143
+ 0.71 0.93 0.50 43428571
+ 0.71 0.93 0.50 50500000
+ 0.71 0.93 0.50 57571429
+ 0.71 0.93 0.50 64642857
+ 0.71 0.93 0.50 71714286
+ 0.71 0.93 0.50 78785714
+ 0.71 0.93 0.50 85857143
+ 0.71 0.93 0.50 92928571
+ 0.71 0.93 0.50 100000000
+ 0.71 0.93 0.57 1000000
+ 0.71 0.93 0.57 8071429
+ 0.71 0.93 0.57 15142857
+ 0.71 0.93 0.57 22214286
+ 0.71 0.93 0.57 29285714
+ 0.71 0.93 0.57 36357143
+ 0.71 0.93 0.57 43428571
+ 0.71 0.93 0.57 50500000
+ 0.71 0.93 0.57 57571429
+ 0.71 0.93 0.57 64642857
+ 0.71 0.93 0.57 71714286
+ 0.71 0.93 0.57 78785714
+ 0.71 0.93 0.57 85857143
+ 0.71 0.93 0.57 92928571
+ 0.71 0.93 0.57 100000000
+ 0.71 0.93 0.64 1000000
+ 0.71 0.93 0.64 8071429
+ 0.71 0.93 0.64 15142857
+ 0.71 0.93 0.64 22214286
+ 0.71 0.93 0.64 29285714
+ 0.71 0.93 0.64 36357143
+ 0.71 0.93 0.64 43428571
+ 0.71 0.93 0.64 50500000
+ 0.71 0.93 0.64 57571429
+ 0.71 0.93 0.64 64642857
+ 0.71 0.93 0.64 71714286
+ 0.71 0.93 0.64 78785714
+ 0.71 0.93 0.64 85857143
+ 0.71 0.93 0.64 92928571
+ 0.71 0.93 0.64 100000000
+ 0.71 0.93 0.71 1000000
+ 0.71 0.93 0.71 8071429
+ 0.71 0.93 0.71 15142857
+ 0.71 0.93 0.71 22214286
+ 0.71 0.93 0.71 29285714
+ 0.71 0.93 0.71 36357143
+ 0.71 0.93 0.71 43428571
+ 0.71 0.93 0.71 50500000
+ 0.71 0.93 0.71 57571429
+ 0.71 0.93 0.71 64642857
+ 0.71 0.93 0.71 71714286
+ 0.71 0.93 0.71 78785714
+ 0.71 0.93 0.71 85857143
+ 0.71 0.93 0.71 92928571
+ 0.71 0.93 0.71 100000000
+ 0.71 0.93 0.79 1000000
+ 0.71 0.93 0.79 8071429
+ 0.71 0.93 0.79 15142857
+ 0.71 0.93 0.79 22214286
+ 0.71 0.93 0.79 29285714
+ 0.71 0.93 0.79 36357143
+ 0.71 0.93 0.79 43428571
+ 0.71 0.93 0.79 50500000
+ 0.71 0.93 0.79 57571429
+ 0.71 0.93 0.79 64642857
+ 0.71 0.93 0.79 71714286
+ 0.71 0.93 0.79 78785714
+ 0.71 0.93 0.79 85857143
+ 0.71 0.93 0.79 92928571
+ 0.71 0.93 0.79 100000000
+ 0.71 0.93 0.86 1000000
+ 0.71 0.93 0.86 8071429
+ 0.71 0.93 0.86 15142857
+ 0.71 0.93 0.86 22214286
+ 0.71 0.93 0.86 29285714
+ 0.71 0.93 0.86 36357143
+ 0.71 0.93 0.86 43428571
+ 0.71 0.93 0.86 50500000
+ 0.71 0.93 0.86 57571429
+ 0.71 0.93 0.86 64642857
+ 0.71 0.93 0.86 71714286
+ 0.71 0.93 0.86 78785714
+ 0.71 0.93 0.86 85857143
+ 0.71 0.93 0.86 92928571
+ 0.71 0.93 0.86 100000000
+ 0.71 0.93 0.93 1000000
+ 0.71 0.93 0.93 8071429
+ 0.71 0.93 0.93 15142857
+ 0.71 0.93 0.93 22214286
+ 0.71 0.93 0.93 29285714
+ 0.71 0.93 0.93 36357143
+ 0.71 0.93 0.93 43428571
+ 0.71 0.93 0.93 50500000
+ 0.71 0.93 0.93 57571429
+ 0.71 0.93 0.93 64642857
+ 0.71 0.93 0.93 71714286
+ 0.71 0.93 0.93 78785714
+ 0.71 0.93 0.93 85857143
+ 0.71 0.93 0.93 92928571
+ 0.71 0.93 0.93 100000000
+ 0.71 0.93 1.00 1000000
+ 0.71 0.93 1.00 8071429
+ 0.71 0.93 1.00 15142857
+ 0.71 0.93 1.00 22214286
+ 0.71 0.93 1.00 29285714
+ 0.71 0.93 1.00 36357143
+ 0.71 0.93 1.00 43428571
+ 0.71 0.93 1.00 50500000
+ 0.71 0.93 1.00 57571429
+ 0.71 0.93 1.00 64642857
+ 0.71 0.93 1.00 71714286
+ 0.71 0.93 1.00 78785714
+ 0.71 0.93 1.00 85857143
+ 0.71 0.93 1.00 92928571
+ 0.71 0.93 1.00 100000000
+ 0.71 1.00 0.00 1000000
+ 0.71 1.00 0.00 8071429
+ 0.71 1.00 0.00 15142857
+ 0.71 1.00 0.00 22214286
+ 0.71 1.00 0.00 29285714
+ 0.71 1.00 0.00 36357143
+ 0.71 1.00 0.00 43428571
+ 0.71 1.00 0.00 50500000
+ 0.71 1.00 0.00 57571429
+ 0.71 1.00 0.00 64642857
+ 0.71 1.00 0.00 71714286
+ 0.71 1.00 0.00 78785714
+ 0.71 1.00 0.00 85857143
+ 0.71 1.00 0.00 92928571
+ 0.71 1.00 0.00 100000000
+ 0.71 1.00 0.07 1000000
+ 0.71 1.00 0.07 8071429
+ 0.71 1.00 0.07 15142857
+ 0.71 1.00 0.07 22214286
+ 0.71 1.00 0.07 29285714
+ 0.71 1.00 0.07 36357143
+ 0.71 1.00 0.07 43428571
+ 0.71 1.00 0.07 50500000
+ 0.71 1.00 0.07 57571429
+ 0.71 1.00 0.07 64642857
+ 0.71 1.00 0.07 71714286
+ 0.71 1.00 0.07 78785714
+ 0.71 1.00 0.07 85857143
+ 0.71 1.00 0.07 92928571
+ 0.71 1.00 0.07 100000000
+ 0.71 1.00 0.14 1000000
+ 0.71 1.00 0.14 8071429
+ 0.71 1.00 0.14 15142857
+ 0.71 1.00 0.14 22214286
+ 0.71 1.00 0.14 29285714
+ 0.71 1.00 0.14 36357143
+ 0.71 1.00 0.14 43428571
+ 0.71 1.00 0.14 50500000
+ 0.71 1.00 0.14 57571429
+ 0.71 1.00 0.14 64642857
+ 0.71 1.00 0.14 71714286
+ 0.71 1.00 0.14 78785714
+ 0.71 1.00 0.14 85857143
+ 0.71 1.00 0.14 92928571
+ 0.71 1.00 0.14 100000000
+ 0.71 1.00 0.21 1000000
+ 0.71 1.00 0.21 8071429
+ 0.71 1.00 0.21 15142857
+ 0.71 1.00 0.21 22214286
+ 0.71 1.00 0.21 29285714
+ 0.71 1.00 0.21 36357143
+ 0.71 1.00 0.21 43428571
+ 0.71 1.00 0.21 50500000
+ 0.71 1.00 0.21 57571429
+ 0.71 1.00 0.21 64642857
+ 0.71 1.00 0.21 71714286
+ 0.71 1.00 0.21 78785714
+ 0.71 1.00 0.21 85857143
+ 0.71 1.00 0.21 92928571
+ 0.71 1.00 0.21 100000000
+ 0.71 1.00 0.29 1000000
+ 0.71 1.00 0.29 8071429
+ 0.71 1.00 0.29 15142857
+ 0.71 1.00 0.29 22214286
+ 0.71 1.00 0.29 29285714
+ 0.71 1.00 0.29 36357143
+ 0.71 1.00 0.29 43428571
+ 0.71 1.00 0.29 50500000
+ 0.71 1.00 0.29 57571429
+ 0.71 1.00 0.29 64642857
+ 0.71 1.00 0.29 71714286
+ 0.71 1.00 0.29 78785714
+ 0.71 1.00 0.29 85857143
+ 0.71 1.00 0.29 92928571
+ 0.71 1.00 0.29 100000000
+ 0.71 1.00 0.36 1000000
+ 0.71 1.00 0.36 8071429
+ 0.71 1.00 0.36 15142857
+ 0.71 1.00 0.36 22214286
+ 0.71 1.00 0.36 29285714
+ 0.71 1.00 0.36 36357143
+ 0.71 1.00 0.36 43428571
+ 0.71 1.00 0.36 50500000
+ 0.71 1.00 0.36 57571429
+ 0.71 1.00 0.36 64642857
+ 0.71 1.00 0.36 71714286
+ 0.71 1.00 0.36 78785714
+ 0.71 1.00 0.36 85857143
+ 0.71 1.00 0.36 92928571
+ 0.71 1.00 0.36 100000000
+ 0.71 1.00 0.43 1000000
+ 0.71 1.00 0.43 8071429
+ 0.71 1.00 0.43 15142857
+ 0.71 1.00 0.43 22214286
+ 0.71 1.00 0.43 29285714
+ 0.71 1.00 0.43 36357143
+ 0.71 1.00 0.43 43428571
+ 0.71 1.00 0.43 50500000
+ 0.71 1.00 0.43 57571429
+ 0.71 1.00 0.43 64642857
+ 0.71 1.00 0.43 71714286
+ 0.71 1.00 0.43 78785714
+ 0.71 1.00 0.43 85857143
+ 0.71 1.00 0.43 92928571
+ 0.71 1.00 0.43 100000000
+ 0.71 1.00 0.50 1000000
+ 0.71 1.00 0.50 8071429
+ 0.71 1.00 0.50 15142857
+ 0.71 1.00 0.50 22214286
+ 0.71 1.00 0.50 29285714
+ 0.71 1.00 0.50 36357143
+ 0.71 1.00 0.50 43428571
+ 0.71 1.00 0.50 50500000
+ 0.71 1.00 0.50 57571429
+ 0.71 1.00 0.50 64642857
+ 0.71 1.00 0.50 71714286
+ 0.71 1.00 0.50 78785714
+ 0.71 1.00 0.50 85857143
+ 0.71 1.00 0.50 92928571
+ 0.71 1.00 0.50 100000000
+ 0.71 1.00 0.57 1000000
+ 0.71 1.00 0.57 8071429
+ 0.71 1.00 0.57 15142857
+ 0.71 1.00 0.57 22214286
+ 0.71 1.00 0.57 29285714
+ 0.71 1.00 0.57 36357143
+ 0.71 1.00 0.57 43428571
+ 0.71 1.00 0.57 50500000
+ 0.71 1.00 0.57 57571429
+ 0.71 1.00 0.57 64642857
+ 0.71 1.00 0.57 71714286
+ 0.71 1.00 0.57 78785714
+ 0.71 1.00 0.57 85857143
+ 0.71 1.00 0.57 92928571
+ 0.71 1.00 0.57 100000000
+ 0.71 1.00 0.64 1000000
+ 0.71 1.00 0.64 8071429
+ 0.71 1.00 0.64 15142857
+ 0.71 1.00 0.64 22214286
+ 0.71 1.00 0.64 29285714
+ 0.71 1.00 0.64 36357143
+ 0.71 1.00 0.64 43428571
+ 0.71 1.00 0.64 50500000
+ 0.71 1.00 0.64 57571429
+ 0.71 1.00 0.64 64642857
+ 0.71 1.00 0.64 71714286
+ 0.71 1.00 0.64 78785714
+ 0.71 1.00 0.64 85857143
+ 0.71 1.00 0.64 92928571
+ 0.71 1.00 0.64 100000000
+ 0.71 1.00 0.71 1000000
+ 0.71 1.00 0.71 8071429
+ 0.71 1.00 0.71 15142857
+ 0.71 1.00 0.71 22214286
+ 0.71 1.00 0.71 29285714
+ 0.71 1.00 0.71 36357143
+ 0.71 1.00 0.71 43428571
+ 0.71 1.00 0.71 50500000
+ 0.71 1.00 0.71 57571429
+ 0.71 1.00 0.71 64642857
+ 0.71 1.00 0.71 71714286
+ 0.71 1.00 0.71 78785714
+ 0.71 1.00 0.71 85857143
+ 0.71 1.00 0.71 92928571
+ 0.71 1.00 0.71 100000000
+ 0.71 1.00 0.79 1000000
+ 0.71 1.00 0.79 8071429
+ 0.71 1.00 0.79 15142857
+ 0.71 1.00 0.79 22214286
+ 0.71 1.00 0.79 29285714
+ 0.71 1.00 0.79 36357143
+ 0.71 1.00 0.79 43428571
+ 0.71 1.00 0.79 50500000
+ 0.71 1.00 0.79 57571429
+ 0.71 1.00 0.79 64642857
+ 0.71 1.00 0.79 71714286
+ 0.71 1.00 0.79 78785714
+ 0.71 1.00 0.79 85857143
+ 0.71 1.00 0.79 92928571
+ 0.71 1.00 0.79 100000000
+ 0.71 1.00 0.86 1000000
+ 0.71 1.00 0.86 8071429
+ 0.71 1.00 0.86 15142857
+ 0.71 1.00 0.86 22214286
+ 0.71 1.00 0.86 29285714
+ 0.71 1.00 0.86 36357143
+ 0.71 1.00 0.86 43428571
+ 0.71 1.00 0.86 50500000
+ 0.71 1.00 0.86 57571429
+ 0.71 1.00 0.86 64642857
+ 0.71 1.00 0.86 71714286
+ 0.71 1.00 0.86 78785714
+ 0.71 1.00 0.86 85857143
+ 0.71 1.00 0.86 92928571
+ 0.71 1.00 0.86 100000000
+ 0.71 1.00 0.93 1000000
+ 0.71 1.00 0.93 8071429
+ 0.71 1.00 0.93 15142857
+ 0.71 1.00 0.93 22214286
+ 0.71 1.00 0.93 29285714
+ 0.71 1.00 0.93 36357143
+ 0.71 1.00 0.93 43428571
+ 0.71 1.00 0.93 50500000
+ 0.71 1.00 0.93 57571429
+ 0.71 1.00 0.93 64642857
+ 0.71 1.00 0.93 71714286
+ 0.71 1.00 0.93 78785714
+ 0.71 1.00 0.93 85857143
+ 0.71 1.00 0.93 92928571
+ 0.71 1.00 0.93 100000000
+ 0.71 1.00 1.00 1000000
+ 0.71 1.00 1.00 8071429
+ 0.71 1.00 1.00 15142857
+ 0.71 1.00 1.00 22214286
+ 0.71 1.00 1.00 29285714
+ 0.71 1.00 1.00 36357143
+ 0.71 1.00 1.00 43428571
+ 0.71 1.00 1.00 50500000
+ 0.71 1.00 1.00 57571429
+ 0.71 1.00 1.00 64642857
+ 0.71 1.00 1.00 71714286
+ 0.71 1.00 1.00 78785714
+ 0.71 1.00 1.00 85857143
+ 0.71 1.00 1.00 92928571
+ 0.71 1.00 1.00 100000000
+ 0.79 0.00 0.00 1000000
+ 0.79 0.00 0.00 8071429
+ 0.79 0.00 0.00 15142857
+ 0.79 0.00 0.00 22214286
+ 0.79 0.00 0.00 29285714
+ 0.79 0.00 0.00 36357143
+ 0.79 0.00 0.00 43428571
+ 0.79 0.00 0.00 50500000
+ 0.79 0.00 0.00 57571429
+ 0.79 0.00 0.00 64642857
+ 0.79 0.00 0.00 71714286
+ 0.79 0.00 0.00 78785714
+ 0.79 0.00 0.00 85857143
+ 0.79 0.00 0.00 92928571
+ 0.79 0.00 0.00 100000000
+ 0.79 0.00 0.07 1000000
+ 0.79 0.00 0.07 8071429
+ 0.79 0.00 0.07 15142857
+ 0.79 0.00 0.07 22214286
+ 0.79 0.00 0.07 29285714
+ 0.79 0.00 0.07 36357143
+ 0.79 0.00 0.07 43428571
+ 0.79 0.00 0.07 50500000
+ 0.79 0.00 0.07 57571429
+ 0.79 0.00 0.07 64642857
+ 0.79 0.00 0.07 71714286
+ 0.79 0.00 0.07 78785714
+ 0.79 0.00 0.07 85857143
+ 0.79 0.00 0.07 92928571
+ 0.79 0.00 0.07 100000000
+ 0.79 0.00 0.14 1000000
+ 0.79 0.00 0.14 8071429
+ 0.79 0.00 0.14 15142857
+ 0.79 0.00 0.14 22214286
+ 0.79 0.00 0.14 29285714
+ 0.79 0.00 0.14 36357143
+ 0.79 0.00 0.14 43428571
+ 0.79 0.00 0.14 50500000
+ 0.79 0.00 0.14 57571429
+ 0.79 0.00 0.14 64642857
+ 0.79 0.00 0.14 71714286
+ 0.79 0.00 0.14 78785714
+ 0.79 0.00 0.14 85857143
+ 0.79 0.00 0.14 92928571
+ 0.79 0.00 0.14 100000000
+ 0.79 0.00 0.21 1000000
+ 0.79 0.00 0.21 8071429
+ 0.79 0.00 0.21 15142857
+ 0.79 0.00 0.21 22214286
+ 0.79 0.00 0.21 29285714
+ 0.79 0.00 0.21 36357143
+ 0.79 0.00 0.21 43428571
+ 0.79 0.00 0.21 50500000
+ 0.79 0.00 0.21 57571429
+ 0.79 0.00 0.21 64642857
+ 0.79 0.00 0.21 71714286
+ 0.79 0.00 0.21 78785714
+ 0.79 0.00 0.21 85857143
+ 0.79 0.00 0.21 92928571
+ 0.79 0.00 0.21 100000000
+ 0.79 0.00 0.29 1000000
+ 0.79 0.00 0.29 8071429
+ 0.79 0.00 0.29 15142857
+ 0.79 0.00 0.29 22214286
+ 0.79 0.00 0.29 29285714
+ 0.79 0.00 0.29 36357143
+ 0.79 0.00 0.29 43428571
+ 0.79 0.00 0.29 50500000
+ 0.79 0.00 0.29 57571429
+ 0.79 0.00 0.29 64642857
+ 0.79 0.00 0.29 71714286
+ 0.79 0.00 0.29 78785714
+ 0.79 0.00 0.29 85857143
+ 0.79 0.00 0.29 92928571
+ 0.79 0.00 0.29 100000000
+ 0.79 0.00 0.36 1000000
+ 0.79 0.00 0.36 8071429
+ 0.79 0.00 0.36 15142857
+ 0.79 0.00 0.36 22214286
+ 0.79 0.00 0.36 29285714
+ 0.79 0.00 0.36 36357143
+ 0.79 0.00 0.36 43428571
+ 0.79 0.00 0.36 50500000
+ 0.79 0.00 0.36 57571429
+ 0.79 0.00 0.36 64642857
+ 0.79 0.00 0.36 71714286
+ 0.79 0.00 0.36 78785714
+ 0.79 0.00 0.36 85857143
+ 0.79 0.00 0.36 92928571
+ 0.79 0.00 0.36 100000000
+ 0.79 0.00 0.43 1000000
+ 0.79 0.00 0.43 8071429
+ 0.79 0.00 0.43 15142857
+ 0.79 0.00 0.43 22214286
+ 0.79 0.00 0.43 29285714
+ 0.79 0.00 0.43 36357143
+ 0.79 0.00 0.43 43428571
+ 0.79 0.00 0.43 50500000
+ 0.79 0.00 0.43 57571429
+ 0.79 0.00 0.43 64642857
+ 0.79 0.00 0.43 71714286
+ 0.79 0.00 0.43 78785714
+ 0.79 0.00 0.43 85857143
+ 0.79 0.00 0.43 92928571
+ 0.79 0.00 0.43 100000000
+ 0.79 0.00 0.50 1000000
+ 0.79 0.00 0.50 8071429
+ 0.79 0.00 0.50 15142857
+ 0.79 0.00 0.50 22214286
+ 0.79 0.00 0.50 29285714
+ 0.79 0.00 0.50 36357143
+ 0.79 0.00 0.50 43428571
+ 0.79 0.00 0.50 50500000
+ 0.79 0.00 0.50 57571429
+ 0.79 0.00 0.50 64642857
+ 0.79 0.00 0.50 71714286
+ 0.79 0.00 0.50 78785714
+ 0.79 0.00 0.50 85857143
+ 0.79 0.00 0.50 92928571
+ 0.79 0.00 0.50 100000000
+ 0.79 0.00 0.57 1000000
+ 0.79 0.00 0.57 8071429
+ 0.79 0.00 0.57 15142857
+ 0.79 0.00 0.57 22214286
+ 0.79 0.00 0.57 29285714
+ 0.79 0.00 0.57 36357143
+ 0.79 0.00 0.57 43428571
+ 0.79 0.00 0.57 50500000
+ 0.79 0.00 0.57 57571429
+ 0.79 0.00 0.57 64642857
+ 0.79 0.00 0.57 71714286
+ 0.79 0.00 0.57 78785714
+ 0.79 0.00 0.57 85857143
+ 0.79 0.00 0.57 92928571
+ 0.79 0.00 0.57 100000000
+ 0.79 0.00 0.64 1000000
+ 0.79 0.00 0.64 8071429
+ 0.79 0.00 0.64 15142857
+ 0.79 0.00 0.64 22214286
+ 0.79 0.00 0.64 29285714
+ 0.79 0.00 0.64 36357143
+ 0.79 0.00 0.64 43428571
+ 0.79 0.00 0.64 50500000
+ 0.79 0.00 0.64 57571429
+ 0.79 0.00 0.64 64642857
+ 0.79 0.00 0.64 71714286
+ 0.79 0.00 0.64 78785714
+ 0.79 0.00 0.64 85857143
+ 0.79 0.00 0.64 92928571
+ 0.79 0.00 0.64 100000000
+ 0.79 0.00 0.71 1000000
+ 0.79 0.00 0.71 8071429
+ 0.79 0.00 0.71 15142857
+ 0.79 0.00 0.71 22214286
+ 0.79 0.00 0.71 29285714
+ 0.79 0.00 0.71 36357143
+ 0.79 0.00 0.71 43428571
+ 0.79 0.00 0.71 50500000
+ 0.79 0.00 0.71 57571429
+ 0.79 0.00 0.71 64642857
+ 0.79 0.00 0.71 71714286
+ 0.79 0.00 0.71 78785714
+ 0.79 0.00 0.71 85857143
+ 0.79 0.00 0.71 92928571
+ 0.79 0.00 0.71 100000000
+ 0.79 0.00 0.79 1000000
+ 0.79 0.00 0.79 8071429
+ 0.79 0.00 0.79 15142857
+ 0.79 0.00 0.79 22214286
+ 0.79 0.00 0.79 29285714
+ 0.79 0.00 0.79 36357143
+ 0.79 0.00 0.79 43428571
+ 0.79 0.00 0.79 50500000
+ 0.79 0.00 0.79 57571429
+ 0.79 0.00 0.79 64642857
+ 0.79 0.00 0.79 71714286
+ 0.79 0.00 0.79 78785714
+ 0.79 0.00 0.79 85857143
+ 0.79 0.00 0.79 92928571
+ 0.79 0.00 0.79 100000000
+ 0.79 0.00 0.86 1000000
+ 0.79 0.00 0.86 8071429
+ 0.79 0.00 0.86 15142857
+ 0.79 0.00 0.86 22214286
+ 0.79 0.00 0.86 29285714
+ 0.79 0.00 0.86 36357143
+ 0.79 0.00 0.86 43428571
+ 0.79 0.00 0.86 50500000
+ 0.79 0.00 0.86 57571429
+ 0.79 0.00 0.86 64642857
+ 0.79 0.00 0.86 71714286
+ 0.79 0.00 0.86 78785714
+ 0.79 0.00 0.86 85857143
+ 0.79 0.00 0.86 92928571
+ 0.79 0.00 0.86 100000000
+ 0.79 0.00 0.93 1000000
+ 0.79 0.00 0.93 8071429
+ 0.79 0.00 0.93 15142857
+ 0.79 0.00 0.93 22214286
+ 0.79 0.00 0.93 29285714
+ 0.79 0.00 0.93 36357143
+ 0.79 0.00 0.93 43428571
+ 0.79 0.00 0.93 50500000
+ 0.79 0.00 0.93 57571429
+ 0.79 0.00 0.93 64642857
+ 0.79 0.00 0.93 71714286
+ 0.79 0.00 0.93 78785714
+ 0.79 0.00 0.93 85857143
+ 0.79 0.00 0.93 92928571
+ 0.79 0.00 0.93 100000000
+ 0.79 0.00 1.00 1000000
+ 0.79 0.00 1.00 8071429
+ 0.79 0.00 1.00 15142857
+ 0.79 0.00 1.00 22214286
+ 0.79 0.00 1.00 29285714
+ 0.79 0.00 1.00 36357143
+ 0.79 0.00 1.00 43428571
+ 0.79 0.00 1.00 50500000
+ 0.79 0.00 1.00 57571429
+ 0.79 0.00 1.00 64642857
+ 0.79 0.00 1.00 71714286
+ 0.79 0.00 1.00 78785714
+ 0.79 0.00 1.00 85857143
+ 0.79 0.00 1.00 92928571
+ 0.79 0.00 1.00 100000000
+ 0.79 0.07 0.00 1000000
+ 0.79 0.07 0.00 8071429
+ 0.79 0.07 0.00 15142857
+ 0.79 0.07 0.00 22214286
+ 0.79 0.07 0.00 29285714
+ 0.79 0.07 0.00 36357143
+ 0.79 0.07 0.00 43428571
+ 0.79 0.07 0.00 50500000
+ 0.79 0.07 0.00 57571429
+ 0.79 0.07 0.00 64642857
+ 0.79 0.07 0.00 71714286
+ 0.79 0.07 0.00 78785714
+ 0.79 0.07 0.00 85857143
+ 0.79 0.07 0.00 92928571
+ 0.79 0.07 0.00 100000000
+ 0.79 0.07 0.07 1000000
+ 0.79 0.07 0.07 8071429
+ 0.79 0.07 0.07 15142857
+ 0.79 0.07 0.07 22214286
+ 0.79 0.07 0.07 29285714
+ 0.79 0.07 0.07 36357143
+ 0.79 0.07 0.07 43428571
+ 0.79 0.07 0.07 50500000
+ 0.79 0.07 0.07 57571429
+ 0.79 0.07 0.07 64642857
+ 0.79 0.07 0.07 71714286
+ 0.79 0.07 0.07 78785714
+ 0.79 0.07 0.07 85857143
+ 0.79 0.07 0.07 92928571
+ 0.79 0.07 0.07 100000000
+ 0.79 0.07 0.14 1000000
+ 0.79 0.07 0.14 8071429
+ 0.79 0.07 0.14 15142857
+ 0.79 0.07 0.14 22214286
+ 0.79 0.07 0.14 29285714
+ 0.79 0.07 0.14 36357143
+ 0.79 0.07 0.14 43428571
+ 0.79 0.07 0.14 50500000
+ 0.79 0.07 0.14 57571429
+ 0.79 0.07 0.14 64642857
+ 0.79 0.07 0.14 71714286
+ 0.79 0.07 0.14 78785714
+ 0.79 0.07 0.14 85857143
+ 0.79 0.07 0.14 92928571
+ 0.79 0.07 0.14 100000000
+ 0.79 0.07 0.21 1000000
+ 0.79 0.07 0.21 8071429
+ 0.79 0.07 0.21 15142857
+ 0.79 0.07 0.21 22214286
+ 0.79 0.07 0.21 29285714
+ 0.79 0.07 0.21 36357143
+ 0.79 0.07 0.21 43428571
+ 0.79 0.07 0.21 50500000
+ 0.79 0.07 0.21 57571429
+ 0.79 0.07 0.21 64642857
+ 0.79 0.07 0.21 71714286
+ 0.79 0.07 0.21 78785714
+ 0.79 0.07 0.21 85857143
+ 0.79 0.07 0.21 92928571
+ 0.79 0.07 0.21 100000000
+ 0.79 0.07 0.29 1000000
+ 0.79 0.07 0.29 8071429
+ 0.79 0.07 0.29 15142857
+ 0.79 0.07 0.29 22214286
+ 0.79 0.07 0.29 29285714
+ 0.79 0.07 0.29 36357143
+ 0.79 0.07 0.29 43428571
+ 0.79 0.07 0.29 50500000
+ 0.79 0.07 0.29 57571429
+ 0.79 0.07 0.29 64642857
+ 0.79 0.07 0.29 71714286
+ 0.79 0.07 0.29 78785714
+ 0.79 0.07 0.29 85857143
+ 0.79 0.07 0.29 92928571
+ 0.79 0.07 0.29 100000000
+ 0.79 0.07 0.36 1000000
+ 0.79 0.07 0.36 8071429
+ 0.79 0.07 0.36 15142857
+ 0.79 0.07 0.36 22214286
+ 0.79 0.07 0.36 29285714
+ 0.79 0.07 0.36 36357143
+ 0.79 0.07 0.36 43428571
+ 0.79 0.07 0.36 50500000
+ 0.79 0.07 0.36 57571429
+ 0.79 0.07 0.36 64642857
+ 0.79 0.07 0.36 71714286
+ 0.79 0.07 0.36 78785714
+ 0.79 0.07 0.36 85857143
+ 0.79 0.07 0.36 92928571
+ 0.79 0.07 0.36 100000000
+ 0.79 0.07 0.43 1000000
+ 0.79 0.07 0.43 8071429
+ 0.79 0.07 0.43 15142857
+ 0.79 0.07 0.43 22214286
+ 0.79 0.07 0.43 29285714
+ 0.79 0.07 0.43 36357143
+ 0.79 0.07 0.43 43428571
+ 0.79 0.07 0.43 50500000
+ 0.79 0.07 0.43 57571429
+ 0.79 0.07 0.43 64642857
+ 0.79 0.07 0.43 71714286
+ 0.79 0.07 0.43 78785714
+ 0.79 0.07 0.43 85857143
+ 0.79 0.07 0.43 92928571
+ 0.79 0.07 0.43 100000000
+ 0.79 0.07 0.50 1000000
+ 0.79 0.07 0.50 8071429
+ 0.79 0.07 0.50 15142857
+ 0.79 0.07 0.50 22214286
+ 0.79 0.07 0.50 29285714
+ 0.79 0.07 0.50 36357143
+ 0.79 0.07 0.50 43428571
+ 0.79 0.07 0.50 50500000
+ 0.79 0.07 0.50 57571429
+ 0.79 0.07 0.50 64642857
+ 0.79 0.07 0.50 71714286
+ 0.79 0.07 0.50 78785714
+ 0.79 0.07 0.50 85857143
+ 0.79 0.07 0.50 92928571
+ 0.79 0.07 0.50 100000000
+ 0.79 0.07 0.57 1000000
+ 0.79 0.07 0.57 8071429
+ 0.79 0.07 0.57 15142857
+ 0.79 0.07 0.57 22214286
+ 0.79 0.07 0.57 29285714
+ 0.79 0.07 0.57 36357143
+ 0.79 0.07 0.57 43428571
+ 0.79 0.07 0.57 50500000
+ 0.79 0.07 0.57 57571429
+ 0.79 0.07 0.57 64642857
+ 0.79 0.07 0.57 71714286
+ 0.79 0.07 0.57 78785714
+ 0.79 0.07 0.57 85857143
+ 0.79 0.07 0.57 92928571
+ 0.79 0.07 0.57 100000000
+ 0.79 0.07 0.64 1000000
+ 0.79 0.07 0.64 8071429
+ 0.79 0.07 0.64 15142857
+ 0.79 0.07 0.64 22214286
+ 0.79 0.07 0.64 29285714
+ 0.79 0.07 0.64 36357143
+ 0.79 0.07 0.64 43428571
+ 0.79 0.07 0.64 50500000
+ 0.79 0.07 0.64 57571429
+ 0.79 0.07 0.64 64642857
+ 0.79 0.07 0.64 71714286
+ 0.79 0.07 0.64 78785714
+ 0.79 0.07 0.64 85857143
+ 0.79 0.07 0.64 92928571
+ 0.79 0.07 0.64 100000000
+ 0.79 0.07 0.71 1000000
+ 0.79 0.07 0.71 8071429
+ 0.79 0.07 0.71 15142857
+ 0.79 0.07 0.71 22214286
+ 0.79 0.07 0.71 29285714
+ 0.79 0.07 0.71 36357143
+ 0.79 0.07 0.71 43428571
+ 0.79 0.07 0.71 50500000
+ 0.79 0.07 0.71 57571429
+ 0.79 0.07 0.71 64642857
+ 0.79 0.07 0.71 71714286
+ 0.79 0.07 0.71 78785714
+ 0.79 0.07 0.71 85857143
+ 0.79 0.07 0.71 92928571
+ 0.79 0.07 0.71 100000000
+ 0.79 0.07 0.79 1000000
+ 0.79 0.07 0.79 8071429
+ 0.79 0.07 0.79 15142857
+ 0.79 0.07 0.79 22214286
+ 0.79 0.07 0.79 29285714
+ 0.79 0.07 0.79 36357143
+ 0.79 0.07 0.79 43428571
+ 0.79 0.07 0.79 50500000
+ 0.79 0.07 0.79 57571429
+ 0.79 0.07 0.79 64642857
+ 0.79 0.07 0.79 71714286
+ 0.79 0.07 0.79 78785714
+ 0.79 0.07 0.79 85857143
+ 0.79 0.07 0.79 92928571
+ 0.79 0.07 0.79 100000000
+ 0.79 0.07 0.86 1000000
+ 0.79 0.07 0.86 8071429
+ 0.79 0.07 0.86 15142857
+ 0.79 0.07 0.86 22214286
+ 0.79 0.07 0.86 29285714
+ 0.79 0.07 0.86 36357143
+ 0.79 0.07 0.86 43428571
+ 0.79 0.07 0.86 50500000
+ 0.79 0.07 0.86 57571429
+ 0.79 0.07 0.86 64642857
+ 0.79 0.07 0.86 71714286
+ 0.79 0.07 0.86 78785714
+ 0.79 0.07 0.86 85857143
+ 0.79 0.07 0.86 92928571
+ 0.79 0.07 0.86 100000000
+ 0.79 0.07 0.93 1000000
+ 0.79 0.07 0.93 8071429
+ 0.79 0.07 0.93 15142857
+ 0.79 0.07 0.93 22214286
+ 0.79 0.07 0.93 29285714
+ 0.79 0.07 0.93 36357143
+ 0.79 0.07 0.93 43428571
+ 0.79 0.07 0.93 50500000
+ 0.79 0.07 0.93 57571429
+ 0.79 0.07 0.93 64642857
+ 0.79 0.07 0.93 71714286
+ 0.79 0.07 0.93 78785714
+ 0.79 0.07 0.93 85857143
+ 0.79 0.07 0.93 92928571
+ 0.79 0.07 0.93 100000000
+ 0.79 0.07 1.00 1000000
+ 0.79 0.07 1.00 8071429
+ 0.79 0.07 1.00 15142857
+ 0.79 0.07 1.00 22214286
+ 0.79 0.07 1.00 29285714
+ 0.79 0.07 1.00 36357143
+ 0.79 0.07 1.00 43428571
+ 0.79 0.07 1.00 50500000
+ 0.79 0.07 1.00 57571429
+ 0.79 0.07 1.00 64642857
+ 0.79 0.07 1.00 71714286
+ 0.79 0.07 1.00 78785714
+ 0.79 0.07 1.00 85857143
+ 0.79 0.07 1.00 92928571
+ 0.79 0.07 1.00 100000000
+ 0.79 0.14 0.00 1000000
+ 0.79 0.14 0.00 8071429
+ 0.79 0.14 0.00 15142857
+ 0.79 0.14 0.00 22214286
+ 0.79 0.14 0.00 29285714
+ 0.79 0.14 0.00 36357143
+ 0.79 0.14 0.00 43428571
+ 0.79 0.14 0.00 50500000
+ 0.79 0.14 0.00 57571429
+ 0.79 0.14 0.00 64642857
+ 0.79 0.14 0.00 71714286
+ 0.79 0.14 0.00 78785714
+ 0.79 0.14 0.00 85857143
+ 0.79 0.14 0.00 92928571
+ 0.79 0.14 0.00 100000000
+ 0.79 0.14 0.07 1000000
+ 0.79 0.14 0.07 8071429
+ 0.79 0.14 0.07 15142857
+ 0.79 0.14 0.07 22214286
+ 0.79 0.14 0.07 29285714
+ 0.79 0.14 0.07 36357143
+ 0.79 0.14 0.07 43428571
+ 0.79 0.14 0.07 50500000
+ 0.79 0.14 0.07 57571429
+ 0.79 0.14 0.07 64642857
+ 0.79 0.14 0.07 71714286
+ 0.79 0.14 0.07 78785714
+ 0.79 0.14 0.07 85857143
+ 0.79 0.14 0.07 92928571
+ 0.79 0.14 0.07 100000000
+ 0.79 0.14 0.14 1000000
+ 0.79 0.14 0.14 8071429
+ 0.79 0.14 0.14 15142857
+ 0.79 0.14 0.14 22214286
+ 0.79 0.14 0.14 29285714
+ 0.79 0.14 0.14 36357143
+ 0.79 0.14 0.14 43428571
+ 0.79 0.14 0.14 50500000
+ 0.79 0.14 0.14 57571429
+ 0.79 0.14 0.14 64642857
+ 0.79 0.14 0.14 71714286
+ 0.79 0.14 0.14 78785714
+ 0.79 0.14 0.14 85857143
+ 0.79 0.14 0.14 92928571
+ 0.79 0.14 0.14 100000000
+ 0.79 0.14 0.21 1000000
+ 0.79 0.14 0.21 8071429
+ 0.79 0.14 0.21 15142857
+ 0.79 0.14 0.21 22214286
+ 0.79 0.14 0.21 29285714
+ 0.79 0.14 0.21 36357143
+ 0.79 0.14 0.21 43428571
+ 0.79 0.14 0.21 50500000
+ 0.79 0.14 0.21 57571429
+ 0.79 0.14 0.21 64642857
+ 0.79 0.14 0.21 71714286
+ 0.79 0.14 0.21 78785714
+ 0.79 0.14 0.21 85857143
+ 0.79 0.14 0.21 92928571
+ 0.79 0.14 0.21 100000000
+ 0.79 0.14 0.29 1000000
+ 0.79 0.14 0.29 8071429
+ 0.79 0.14 0.29 15142857
+ 0.79 0.14 0.29 22214286
+ 0.79 0.14 0.29 29285714
+ 0.79 0.14 0.29 36357143
+ 0.79 0.14 0.29 43428571
+ 0.79 0.14 0.29 50500000
+ 0.79 0.14 0.29 57571429
+ 0.79 0.14 0.29 64642857
+ 0.79 0.14 0.29 71714286
+ 0.79 0.14 0.29 78785714
+ 0.79 0.14 0.29 85857143
+ 0.79 0.14 0.29 92928571
+ 0.79 0.14 0.29 100000000
+ 0.79 0.14 0.36 1000000
+ 0.79 0.14 0.36 8071429
+ 0.79 0.14 0.36 15142857
+ 0.79 0.14 0.36 22214286
+ 0.79 0.14 0.36 29285714
+ 0.79 0.14 0.36 36357143
+ 0.79 0.14 0.36 43428571
+ 0.79 0.14 0.36 50500000
+ 0.79 0.14 0.36 57571429
+ 0.79 0.14 0.36 64642857
+ 0.79 0.14 0.36 71714286
+ 0.79 0.14 0.36 78785714
+ 0.79 0.14 0.36 85857143
+ 0.79 0.14 0.36 92928571
+ 0.79 0.14 0.36 100000000
+ 0.79 0.14 0.43 1000000
+ 0.79 0.14 0.43 8071429
+ 0.79 0.14 0.43 15142857
+ 0.79 0.14 0.43 22214286
+ 0.79 0.14 0.43 29285714
+ 0.79 0.14 0.43 36357143
+ 0.79 0.14 0.43 43428571
+ 0.79 0.14 0.43 50500000
+ 0.79 0.14 0.43 57571429
+ 0.79 0.14 0.43 64642857
+ 0.79 0.14 0.43 71714286
+ 0.79 0.14 0.43 78785714
+ 0.79 0.14 0.43 85857143
+ 0.79 0.14 0.43 92928571
+ 0.79 0.14 0.43 100000000
+ 0.79 0.14 0.50 1000000
+ 0.79 0.14 0.50 8071429
+ 0.79 0.14 0.50 15142857
+ 0.79 0.14 0.50 22214286
+ 0.79 0.14 0.50 29285714
+ 0.79 0.14 0.50 36357143
+ 0.79 0.14 0.50 43428571
+ 0.79 0.14 0.50 50500000
+ 0.79 0.14 0.50 57571429
+ 0.79 0.14 0.50 64642857
+ 0.79 0.14 0.50 71714286
+ 0.79 0.14 0.50 78785714
+ 0.79 0.14 0.50 85857143
+ 0.79 0.14 0.50 92928571
+ 0.79 0.14 0.50 100000000
+ 0.79 0.14 0.57 1000000
+ 0.79 0.14 0.57 8071429
+ 0.79 0.14 0.57 15142857
+ 0.79 0.14 0.57 22214286
+ 0.79 0.14 0.57 29285714
+ 0.79 0.14 0.57 36357143
+ 0.79 0.14 0.57 43428571
+ 0.79 0.14 0.57 50500000
+ 0.79 0.14 0.57 57571429
+ 0.79 0.14 0.57 64642857
+ 0.79 0.14 0.57 71714286
+ 0.79 0.14 0.57 78785714
+ 0.79 0.14 0.57 85857143
+ 0.79 0.14 0.57 92928571
+ 0.79 0.14 0.57 100000000
+ 0.79 0.14 0.64 1000000
+ 0.79 0.14 0.64 8071429
+ 0.79 0.14 0.64 15142857
+ 0.79 0.14 0.64 22214286
+ 0.79 0.14 0.64 29285714
+ 0.79 0.14 0.64 36357143
+ 0.79 0.14 0.64 43428571
+ 0.79 0.14 0.64 50500000
+ 0.79 0.14 0.64 57571429
+ 0.79 0.14 0.64 64642857
+ 0.79 0.14 0.64 71714286
+ 0.79 0.14 0.64 78785714
+ 0.79 0.14 0.64 85857143
+ 0.79 0.14 0.64 92928571
+ 0.79 0.14 0.64 100000000
+ 0.79 0.14 0.71 1000000
+ 0.79 0.14 0.71 8071429
+ 0.79 0.14 0.71 15142857
+ 0.79 0.14 0.71 22214286
+ 0.79 0.14 0.71 29285714
+ 0.79 0.14 0.71 36357143
+ 0.79 0.14 0.71 43428571
+ 0.79 0.14 0.71 50500000
+ 0.79 0.14 0.71 57571429
+ 0.79 0.14 0.71 64642857
+ 0.79 0.14 0.71 71714286
+ 0.79 0.14 0.71 78785714
+ 0.79 0.14 0.71 85857143
+ 0.79 0.14 0.71 92928571
+ 0.79 0.14 0.71 100000000
+ 0.79 0.14 0.79 1000000
+ 0.79 0.14 0.79 8071429
+ 0.79 0.14 0.79 15142857
+ 0.79 0.14 0.79 22214286
+ 0.79 0.14 0.79 29285714
+ 0.79 0.14 0.79 36357143
+ 0.79 0.14 0.79 43428571
+ 0.79 0.14 0.79 50500000
+ 0.79 0.14 0.79 57571429
+ 0.79 0.14 0.79 64642857
+ 0.79 0.14 0.79 71714286
+ 0.79 0.14 0.79 78785714
+ 0.79 0.14 0.79 85857143
+ 0.79 0.14 0.79 92928571
+ 0.79 0.14 0.79 100000000
+ 0.79 0.14 0.86 1000000
+ 0.79 0.14 0.86 8071429
+ 0.79 0.14 0.86 15142857
+ 0.79 0.14 0.86 22214286
+ 0.79 0.14 0.86 29285714
+ 0.79 0.14 0.86 36357143
+ 0.79 0.14 0.86 43428571
+ 0.79 0.14 0.86 50500000
+ 0.79 0.14 0.86 57571429
+ 0.79 0.14 0.86 64642857
+ 0.79 0.14 0.86 71714286
+ 0.79 0.14 0.86 78785714
+ 0.79 0.14 0.86 85857143
+ 0.79 0.14 0.86 92928571
+ 0.79 0.14 0.86 100000000
+ 0.79 0.14 0.93 1000000
+ 0.79 0.14 0.93 8071429
+ 0.79 0.14 0.93 15142857
+ 0.79 0.14 0.93 22214286
+ 0.79 0.14 0.93 29285714
+ 0.79 0.14 0.93 36357143
+ 0.79 0.14 0.93 43428571
+ 0.79 0.14 0.93 50500000
+ 0.79 0.14 0.93 57571429
+ 0.79 0.14 0.93 64642857
+ 0.79 0.14 0.93 71714286
+ 0.79 0.14 0.93 78785714
+ 0.79 0.14 0.93 85857143
+ 0.79 0.14 0.93 92928571
+ 0.79 0.14 0.93 100000000
+ 0.79 0.14 1.00 1000000
+ 0.79 0.14 1.00 8071429
+ 0.79 0.14 1.00 15142857
+ 0.79 0.14 1.00 22214286
+ 0.79 0.14 1.00 29285714
+ 0.79 0.14 1.00 36357143
+ 0.79 0.14 1.00 43428571
+ 0.79 0.14 1.00 50500000
+ 0.79 0.14 1.00 57571429
+ 0.79 0.14 1.00 64642857
+ 0.79 0.14 1.00 71714286
+ 0.79 0.14 1.00 78785714
+ 0.79 0.14 1.00 85857143
+ 0.79 0.14 1.00 92928571
+ 0.79 0.14 1.00 100000000
+ 0.79 0.21 0.00 1000000
+ 0.79 0.21 0.00 8071429
+ 0.79 0.21 0.00 15142857
+ 0.79 0.21 0.00 22214286
+ 0.79 0.21 0.00 29285714
+ 0.79 0.21 0.00 36357143
+ 0.79 0.21 0.00 43428571
+ 0.79 0.21 0.00 50500000
+ 0.79 0.21 0.00 57571429
+ 0.79 0.21 0.00 64642857
+ 0.79 0.21 0.00 71714286
+ 0.79 0.21 0.00 78785714
+ 0.79 0.21 0.00 85857143
+ 0.79 0.21 0.00 92928571
+ 0.79 0.21 0.00 100000000
+ 0.79 0.21 0.07 1000000
+ 0.79 0.21 0.07 8071429
+ 0.79 0.21 0.07 15142857
+ 0.79 0.21 0.07 22214286
+ 0.79 0.21 0.07 29285714
+ 0.79 0.21 0.07 36357143
+ 0.79 0.21 0.07 43428571
+ 0.79 0.21 0.07 50500000
+ 0.79 0.21 0.07 57571429
+ 0.79 0.21 0.07 64642857
+ 0.79 0.21 0.07 71714286
+ 0.79 0.21 0.07 78785714
+ 0.79 0.21 0.07 85857143
+ 0.79 0.21 0.07 92928571
+ 0.79 0.21 0.07 100000000
+ 0.79 0.21 0.14 1000000
+ 0.79 0.21 0.14 8071429
+ 0.79 0.21 0.14 15142857
+ 0.79 0.21 0.14 22214286
+ 0.79 0.21 0.14 29285714
+ 0.79 0.21 0.14 36357143
+ 0.79 0.21 0.14 43428571
+ 0.79 0.21 0.14 50500000
+ 0.79 0.21 0.14 57571429
+ 0.79 0.21 0.14 64642857
+ 0.79 0.21 0.14 71714286
+ 0.79 0.21 0.14 78785714
+ 0.79 0.21 0.14 85857143
+ 0.79 0.21 0.14 92928571
+ 0.79 0.21 0.14 100000000
+ 0.79 0.21 0.21 1000000
+ 0.79 0.21 0.21 8071429
+ 0.79 0.21 0.21 15142857
+ 0.79 0.21 0.21 22214286
+ 0.79 0.21 0.21 29285714
+ 0.79 0.21 0.21 36357143
+ 0.79 0.21 0.21 43428571
+ 0.79 0.21 0.21 50500000
+ 0.79 0.21 0.21 57571429
+ 0.79 0.21 0.21 64642857
+ 0.79 0.21 0.21 71714286
+ 0.79 0.21 0.21 78785714
+ 0.79 0.21 0.21 85857143
+ 0.79 0.21 0.21 92928571
+ 0.79 0.21 0.21 100000000
+ 0.79 0.21 0.29 1000000
+ 0.79 0.21 0.29 8071429
+ 0.79 0.21 0.29 15142857
+ 0.79 0.21 0.29 22214286
+ 0.79 0.21 0.29 29285714
+ 0.79 0.21 0.29 36357143
+ 0.79 0.21 0.29 43428571
+ 0.79 0.21 0.29 50500000
+ 0.79 0.21 0.29 57571429
+ 0.79 0.21 0.29 64642857
+ 0.79 0.21 0.29 71714286
+ 0.79 0.21 0.29 78785714
+ 0.79 0.21 0.29 85857143
+ 0.79 0.21 0.29 92928571
+ 0.79 0.21 0.29 100000000
+ 0.79 0.21 0.36 1000000
+ 0.79 0.21 0.36 8071429
+ 0.79 0.21 0.36 15142857
+ 0.79 0.21 0.36 22214286
+ 0.79 0.21 0.36 29285714
+ 0.79 0.21 0.36 36357143
+ 0.79 0.21 0.36 43428571
+ 0.79 0.21 0.36 50500000
+ 0.79 0.21 0.36 57571429
+ 0.79 0.21 0.36 64642857
+ 0.79 0.21 0.36 71714286
+ 0.79 0.21 0.36 78785714
+ 0.79 0.21 0.36 85857143
+ 0.79 0.21 0.36 92928571
+ 0.79 0.21 0.36 100000000
+ 0.79 0.21 0.43 1000000
+ 0.79 0.21 0.43 8071429
+ 0.79 0.21 0.43 15142857
+ 0.79 0.21 0.43 22214286
+ 0.79 0.21 0.43 29285714
+ 0.79 0.21 0.43 36357143
+ 0.79 0.21 0.43 43428571
+ 0.79 0.21 0.43 50500000
+ 0.79 0.21 0.43 57571429
+ 0.79 0.21 0.43 64642857
+ 0.79 0.21 0.43 71714286
+ 0.79 0.21 0.43 78785714
+ 0.79 0.21 0.43 85857143
+ 0.79 0.21 0.43 92928571
+ 0.79 0.21 0.43 100000000
+ 0.79 0.21 0.50 1000000
+ 0.79 0.21 0.50 8071429
+ 0.79 0.21 0.50 15142857
+ 0.79 0.21 0.50 22214286
+ 0.79 0.21 0.50 29285714
+ 0.79 0.21 0.50 36357143
+ 0.79 0.21 0.50 43428571
+ 0.79 0.21 0.50 50500000
+ 0.79 0.21 0.50 57571429
+ 0.79 0.21 0.50 64642857
+ 0.79 0.21 0.50 71714286
+ 0.79 0.21 0.50 78785714
+ 0.79 0.21 0.50 85857143
+ 0.79 0.21 0.50 92928571
+ 0.79 0.21 0.50 100000000
+ 0.79 0.21 0.57 1000000
+ 0.79 0.21 0.57 8071429
+ 0.79 0.21 0.57 15142857
+ 0.79 0.21 0.57 22214286
+ 0.79 0.21 0.57 29285714
+ 0.79 0.21 0.57 36357143
+ 0.79 0.21 0.57 43428571
+ 0.79 0.21 0.57 50500000
+ 0.79 0.21 0.57 57571429
+ 0.79 0.21 0.57 64642857
+ 0.79 0.21 0.57 71714286
+ 0.79 0.21 0.57 78785714
+ 0.79 0.21 0.57 85857143
+ 0.79 0.21 0.57 92928571
+ 0.79 0.21 0.57 100000000
+ 0.79 0.21 0.64 1000000
+ 0.79 0.21 0.64 8071429
+ 0.79 0.21 0.64 15142857
+ 0.79 0.21 0.64 22214286
+ 0.79 0.21 0.64 29285714
+ 0.79 0.21 0.64 36357143
+ 0.79 0.21 0.64 43428571
+ 0.79 0.21 0.64 50500000
+ 0.79 0.21 0.64 57571429
+ 0.79 0.21 0.64 64642857
+ 0.79 0.21 0.64 71714286
+ 0.79 0.21 0.64 78785714
+ 0.79 0.21 0.64 85857143
+ 0.79 0.21 0.64 92928571
+ 0.79 0.21 0.64 100000000
+ 0.79 0.21 0.71 1000000
+ 0.79 0.21 0.71 8071429
+ 0.79 0.21 0.71 15142857
+ 0.79 0.21 0.71 22214286
+ 0.79 0.21 0.71 29285714
+ 0.79 0.21 0.71 36357143
+ 0.79 0.21 0.71 43428571
+ 0.79 0.21 0.71 50500000
+ 0.79 0.21 0.71 57571429
+ 0.79 0.21 0.71 64642857
+ 0.79 0.21 0.71 71714286
+ 0.79 0.21 0.71 78785714
+ 0.79 0.21 0.71 85857143
+ 0.79 0.21 0.71 92928571
+ 0.79 0.21 0.71 100000000
+ 0.79 0.21 0.79 1000000
+ 0.79 0.21 0.79 8071429
+ 0.79 0.21 0.79 15142857
+ 0.79 0.21 0.79 22214286
+ 0.79 0.21 0.79 29285714
+ 0.79 0.21 0.79 36357143
+ 0.79 0.21 0.79 43428571
+ 0.79 0.21 0.79 50500000
+ 0.79 0.21 0.79 57571429
+ 0.79 0.21 0.79 64642857
+ 0.79 0.21 0.79 71714286
+ 0.79 0.21 0.79 78785714
+ 0.79 0.21 0.79 85857143
+ 0.79 0.21 0.79 92928571
+ 0.79 0.21 0.79 100000000
+ 0.79 0.21 0.86 1000000
+ 0.79 0.21 0.86 8071429
+ 0.79 0.21 0.86 15142857
+ 0.79 0.21 0.86 22214286
+ 0.79 0.21 0.86 29285714
+ 0.79 0.21 0.86 36357143
+ 0.79 0.21 0.86 43428571
+ 0.79 0.21 0.86 50500000
+ 0.79 0.21 0.86 57571429
+ 0.79 0.21 0.86 64642857
+ 0.79 0.21 0.86 71714286
+ 0.79 0.21 0.86 78785714
+ 0.79 0.21 0.86 85857143
+ 0.79 0.21 0.86 92928571
+ 0.79 0.21 0.86 100000000
+ 0.79 0.21 0.93 1000000
+ 0.79 0.21 0.93 8071429
+ 0.79 0.21 0.93 15142857
+ 0.79 0.21 0.93 22214286
+ 0.79 0.21 0.93 29285714
+ 0.79 0.21 0.93 36357143
+ 0.79 0.21 0.93 43428571
+ 0.79 0.21 0.93 50500000
+ 0.79 0.21 0.93 57571429
+ 0.79 0.21 0.93 64642857
+ 0.79 0.21 0.93 71714286
+ 0.79 0.21 0.93 78785714
+ 0.79 0.21 0.93 85857143
+ 0.79 0.21 0.93 92928571
+ 0.79 0.21 0.93 100000000
+ 0.79 0.21 1.00 1000000
+ 0.79 0.21 1.00 8071429
+ 0.79 0.21 1.00 15142857
+ 0.79 0.21 1.00 22214286
+ 0.79 0.21 1.00 29285714
+ 0.79 0.21 1.00 36357143
+ 0.79 0.21 1.00 43428571
+ 0.79 0.21 1.00 50500000
+ 0.79 0.21 1.00 57571429
+ 0.79 0.21 1.00 64642857
+ 0.79 0.21 1.00 71714286
+ 0.79 0.21 1.00 78785714
+ 0.79 0.21 1.00 85857143
+ 0.79 0.21 1.00 92928571
+ 0.79 0.21 1.00 100000000
+ 0.79 0.29 0.00 1000000
+ 0.79 0.29 0.00 8071429
+ 0.79 0.29 0.00 15142857
+ 0.79 0.29 0.00 22214286
+ 0.79 0.29 0.00 29285714
+ 0.79 0.29 0.00 36357143
+ 0.79 0.29 0.00 43428571
+ 0.79 0.29 0.00 50500000
+ 0.79 0.29 0.00 57571429
+ 0.79 0.29 0.00 64642857
+ 0.79 0.29 0.00 71714286
+ 0.79 0.29 0.00 78785714
+ 0.79 0.29 0.00 85857143
+ 0.79 0.29 0.00 92928571
+ 0.79 0.29 0.00 100000000
+ 0.79 0.29 0.07 1000000
+ 0.79 0.29 0.07 8071429
+ 0.79 0.29 0.07 15142857
+ 0.79 0.29 0.07 22214286
+ 0.79 0.29 0.07 29285714
+ 0.79 0.29 0.07 36357143
+ 0.79 0.29 0.07 43428571
+ 0.79 0.29 0.07 50500000
+ 0.79 0.29 0.07 57571429
+ 0.79 0.29 0.07 64642857
+ 0.79 0.29 0.07 71714286
+ 0.79 0.29 0.07 78785714
+ 0.79 0.29 0.07 85857143
+ 0.79 0.29 0.07 92928571
+ 0.79 0.29 0.07 100000000
+ 0.79 0.29 0.14 1000000
+ 0.79 0.29 0.14 8071429
+ 0.79 0.29 0.14 15142857
+ 0.79 0.29 0.14 22214286
+ 0.79 0.29 0.14 29285714
+ 0.79 0.29 0.14 36357143
+ 0.79 0.29 0.14 43428571
+ 0.79 0.29 0.14 50500000
+ 0.79 0.29 0.14 57571429
+ 0.79 0.29 0.14 64642857
+ 0.79 0.29 0.14 71714286
+ 0.79 0.29 0.14 78785714
+ 0.79 0.29 0.14 85857143
+ 0.79 0.29 0.14 92928571
+ 0.79 0.29 0.14 100000000
+ 0.79 0.29 0.21 1000000
+ 0.79 0.29 0.21 8071429
+ 0.79 0.29 0.21 15142857
+ 0.79 0.29 0.21 22214286
+ 0.79 0.29 0.21 29285714
+ 0.79 0.29 0.21 36357143
+ 0.79 0.29 0.21 43428571
+ 0.79 0.29 0.21 50500000
+ 0.79 0.29 0.21 57571429
+ 0.79 0.29 0.21 64642857
+ 0.79 0.29 0.21 71714286
+ 0.79 0.29 0.21 78785714
+ 0.79 0.29 0.21 85857143
+ 0.79 0.29 0.21 92928571
+ 0.79 0.29 0.21 100000000
+ 0.79 0.29 0.29 1000000
+ 0.79 0.29 0.29 8071429
+ 0.79 0.29 0.29 15142857
+ 0.79 0.29 0.29 22214286
+ 0.79 0.29 0.29 29285714
+ 0.79 0.29 0.29 36357143
+ 0.79 0.29 0.29 43428571
+ 0.79 0.29 0.29 50500000
+ 0.79 0.29 0.29 57571429
+ 0.79 0.29 0.29 64642857
+ 0.79 0.29 0.29 71714286
+ 0.79 0.29 0.29 78785714
+ 0.79 0.29 0.29 85857143
+ 0.79 0.29 0.29 92928571
+ 0.79 0.29 0.29 100000000
+ 0.79 0.29 0.36 1000000
+ 0.79 0.29 0.36 8071429
+ 0.79 0.29 0.36 15142857
+ 0.79 0.29 0.36 22214286
+ 0.79 0.29 0.36 29285714
+ 0.79 0.29 0.36 36357143
+ 0.79 0.29 0.36 43428571
+ 0.79 0.29 0.36 50500000
+ 0.79 0.29 0.36 57571429
+ 0.79 0.29 0.36 64642857
+ 0.79 0.29 0.36 71714286
+ 0.79 0.29 0.36 78785714
+ 0.79 0.29 0.36 85857143
+ 0.79 0.29 0.36 92928571
+ 0.79 0.29 0.36 100000000
+ 0.79 0.29 0.43 1000000
+ 0.79 0.29 0.43 8071429
+ 0.79 0.29 0.43 15142857
+ 0.79 0.29 0.43 22214286
+ 0.79 0.29 0.43 29285714
+ 0.79 0.29 0.43 36357143
+ 0.79 0.29 0.43 43428571
+ 0.79 0.29 0.43 50500000
+ 0.79 0.29 0.43 57571429
+ 0.79 0.29 0.43 64642857
+ 0.79 0.29 0.43 71714286
+ 0.79 0.29 0.43 78785714
+ 0.79 0.29 0.43 85857143
+ 0.79 0.29 0.43 92928571
+ 0.79 0.29 0.43 100000000
+ 0.79 0.29 0.50 1000000
+ 0.79 0.29 0.50 8071429
+ 0.79 0.29 0.50 15142857
+ 0.79 0.29 0.50 22214286
+ 0.79 0.29 0.50 29285714
+ 0.79 0.29 0.50 36357143
+ 0.79 0.29 0.50 43428571
+ 0.79 0.29 0.50 50500000
+ 0.79 0.29 0.50 57571429
+ 0.79 0.29 0.50 64642857
+ 0.79 0.29 0.50 71714286
+ 0.79 0.29 0.50 78785714
+ 0.79 0.29 0.50 85857143
+ 0.79 0.29 0.50 92928571
+ 0.79 0.29 0.50 100000000
+ 0.79 0.29 0.57 1000000
+ 0.79 0.29 0.57 8071429
+ 0.79 0.29 0.57 15142857
+ 0.79 0.29 0.57 22214286
+ 0.79 0.29 0.57 29285714
+ 0.79 0.29 0.57 36357143
+ 0.79 0.29 0.57 43428571
+ 0.79 0.29 0.57 50500000
+ 0.79 0.29 0.57 57571429
+ 0.79 0.29 0.57 64642857
+ 0.79 0.29 0.57 71714286
+ 0.79 0.29 0.57 78785714
+ 0.79 0.29 0.57 85857143
+ 0.79 0.29 0.57 92928571
+ 0.79 0.29 0.57 100000000
+ 0.79 0.29 0.64 1000000
+ 0.79 0.29 0.64 8071429
+ 0.79 0.29 0.64 15142857
+ 0.79 0.29 0.64 22214286
+ 0.79 0.29 0.64 29285714
+ 0.79 0.29 0.64 36357143
+ 0.79 0.29 0.64 43428571
+ 0.79 0.29 0.64 50500000
+ 0.79 0.29 0.64 57571429
+ 0.79 0.29 0.64 64642857
+ 0.79 0.29 0.64 71714286
+ 0.79 0.29 0.64 78785714
+ 0.79 0.29 0.64 85857143
+ 0.79 0.29 0.64 92928571
+ 0.79 0.29 0.64 100000000
+ 0.79 0.29 0.71 1000000
+ 0.79 0.29 0.71 8071429
+ 0.79 0.29 0.71 15142857
+ 0.79 0.29 0.71 22214286
+ 0.79 0.29 0.71 29285714
+ 0.79 0.29 0.71 36357143
+ 0.79 0.29 0.71 43428571
+ 0.79 0.29 0.71 50500000
+ 0.79 0.29 0.71 57571429
+ 0.79 0.29 0.71 64642857
+ 0.79 0.29 0.71 71714286
+ 0.79 0.29 0.71 78785714
+ 0.79 0.29 0.71 85857143
+ 0.79 0.29 0.71 92928571
+ 0.79 0.29 0.71 100000000
+ 0.79 0.29 0.79 1000000
+ 0.79 0.29 0.79 8071429
+ 0.79 0.29 0.79 15142857
+ 0.79 0.29 0.79 22214286
+ 0.79 0.29 0.79 29285714
+ 0.79 0.29 0.79 36357143
+ 0.79 0.29 0.79 43428571
+ 0.79 0.29 0.79 50500000
+ 0.79 0.29 0.79 57571429
+ 0.79 0.29 0.79 64642857
+ 0.79 0.29 0.79 71714286
+ 0.79 0.29 0.79 78785714
+ 0.79 0.29 0.79 85857143
+ 0.79 0.29 0.79 92928571
+ 0.79 0.29 0.79 100000000
+ 0.79 0.29 0.86 1000000
+ 0.79 0.29 0.86 8071429
+ 0.79 0.29 0.86 15142857
+ 0.79 0.29 0.86 22214286
+ 0.79 0.29 0.86 29285714
+ 0.79 0.29 0.86 36357143
+ 0.79 0.29 0.86 43428571
+ 0.79 0.29 0.86 50500000
+ 0.79 0.29 0.86 57571429
+ 0.79 0.29 0.86 64642857
+ 0.79 0.29 0.86 71714286
+ 0.79 0.29 0.86 78785714
+ 0.79 0.29 0.86 85857143
+ 0.79 0.29 0.86 92928571
+ 0.79 0.29 0.86 100000000
+ 0.79 0.29 0.93 1000000
+ 0.79 0.29 0.93 8071429
+ 0.79 0.29 0.93 15142857
+ 0.79 0.29 0.93 22214286
+ 0.79 0.29 0.93 29285714
+ 0.79 0.29 0.93 36357143
+ 0.79 0.29 0.93 43428571
+ 0.79 0.29 0.93 50500000
+ 0.79 0.29 0.93 57571429
+ 0.79 0.29 0.93 64642857
+ 0.79 0.29 0.93 71714286
+ 0.79 0.29 0.93 78785714
+ 0.79 0.29 0.93 85857143
+ 0.79 0.29 0.93 92928571
+ 0.79 0.29 0.93 100000000
+ 0.79 0.29 1.00 1000000
+ 0.79 0.29 1.00 8071429
+ 0.79 0.29 1.00 15142857
+ 0.79 0.29 1.00 22214286
+ 0.79 0.29 1.00 29285714
+ 0.79 0.29 1.00 36357143
+ 0.79 0.29 1.00 43428571
+ 0.79 0.29 1.00 50500000
+ 0.79 0.29 1.00 57571429
+ 0.79 0.29 1.00 64642857
+ 0.79 0.29 1.00 71714286
+ 0.79 0.29 1.00 78785714
+ 0.79 0.29 1.00 85857143
+ 0.79 0.29 1.00 92928571
+ 0.79 0.29 1.00 100000000
+ 0.79 0.36 0.00 1000000
+ 0.79 0.36 0.00 8071429
+ 0.79 0.36 0.00 15142857
+ 0.79 0.36 0.00 22214286
+ 0.79 0.36 0.00 29285714
+ 0.79 0.36 0.00 36357143
+ 0.79 0.36 0.00 43428571
+ 0.79 0.36 0.00 50500000
+ 0.79 0.36 0.00 57571429
+ 0.79 0.36 0.00 64642857
+ 0.79 0.36 0.00 71714286
+ 0.79 0.36 0.00 78785714
+ 0.79 0.36 0.00 85857143
+ 0.79 0.36 0.00 92928571
+ 0.79 0.36 0.00 100000000
+ 0.79 0.36 0.07 1000000
+ 0.79 0.36 0.07 8071429
+ 0.79 0.36 0.07 15142857
+ 0.79 0.36 0.07 22214286
+ 0.79 0.36 0.07 29285714
+ 0.79 0.36 0.07 36357143
+ 0.79 0.36 0.07 43428571
+ 0.79 0.36 0.07 50500000
+ 0.79 0.36 0.07 57571429
+ 0.79 0.36 0.07 64642857
+ 0.79 0.36 0.07 71714286
+ 0.79 0.36 0.07 78785714
+ 0.79 0.36 0.07 85857143
+ 0.79 0.36 0.07 92928571
+ 0.79 0.36 0.07 100000000
+ 0.79 0.36 0.14 1000000
+ 0.79 0.36 0.14 8071429
+ 0.79 0.36 0.14 15142857
+ 0.79 0.36 0.14 22214286
+ 0.79 0.36 0.14 29285714
+ 0.79 0.36 0.14 36357143
+ 0.79 0.36 0.14 43428571
+ 0.79 0.36 0.14 50500000
+ 0.79 0.36 0.14 57571429
+ 0.79 0.36 0.14 64642857
+ 0.79 0.36 0.14 71714286
+ 0.79 0.36 0.14 78785714
+ 0.79 0.36 0.14 85857143
+ 0.79 0.36 0.14 92928571
+ 0.79 0.36 0.14 100000000
+ 0.79 0.36 0.21 1000000
+ 0.79 0.36 0.21 8071429
+ 0.79 0.36 0.21 15142857
+ 0.79 0.36 0.21 22214286
+ 0.79 0.36 0.21 29285714
+ 0.79 0.36 0.21 36357143
+ 0.79 0.36 0.21 43428571
+ 0.79 0.36 0.21 50500000
+ 0.79 0.36 0.21 57571429
+ 0.79 0.36 0.21 64642857
+ 0.79 0.36 0.21 71714286
+ 0.79 0.36 0.21 78785714
+ 0.79 0.36 0.21 85857143
+ 0.79 0.36 0.21 92928571
+ 0.79 0.36 0.21 100000000
+ 0.79 0.36 0.29 1000000
+ 0.79 0.36 0.29 8071429
+ 0.79 0.36 0.29 15142857
+ 0.79 0.36 0.29 22214286
+ 0.79 0.36 0.29 29285714
+ 0.79 0.36 0.29 36357143
+ 0.79 0.36 0.29 43428571
+ 0.79 0.36 0.29 50500000
+ 0.79 0.36 0.29 57571429
+ 0.79 0.36 0.29 64642857
+ 0.79 0.36 0.29 71714286
+ 0.79 0.36 0.29 78785714
+ 0.79 0.36 0.29 85857143
+ 0.79 0.36 0.29 92928571
+ 0.79 0.36 0.29 100000000
+ 0.79 0.36 0.36 1000000
+ 0.79 0.36 0.36 8071429
+ 0.79 0.36 0.36 15142857
+ 0.79 0.36 0.36 22214286
+ 0.79 0.36 0.36 29285714
+ 0.79 0.36 0.36 36357143
+ 0.79 0.36 0.36 43428571
+ 0.79 0.36 0.36 50500000
+ 0.79 0.36 0.36 57571429
+ 0.79 0.36 0.36 64642857
+ 0.79 0.36 0.36 71714286
+ 0.79 0.36 0.36 78785714
+ 0.79 0.36 0.36 85857143
+ 0.79 0.36 0.36 92928571
+ 0.79 0.36 0.36 100000000
+ 0.79 0.36 0.43 1000000
+ 0.79 0.36 0.43 8071429
+ 0.79 0.36 0.43 15142857
+ 0.79 0.36 0.43 22214286
+ 0.79 0.36 0.43 29285714
+ 0.79 0.36 0.43 36357143
+ 0.79 0.36 0.43 43428571
+ 0.79 0.36 0.43 50500000
+ 0.79 0.36 0.43 57571429
+ 0.79 0.36 0.43 64642857
+ 0.79 0.36 0.43 71714286
+ 0.79 0.36 0.43 78785714
+ 0.79 0.36 0.43 85857143
+ 0.79 0.36 0.43 92928571
+ 0.79 0.36 0.43 100000000
+ 0.79 0.36 0.50 1000000
+ 0.79 0.36 0.50 8071429
+ 0.79 0.36 0.50 15142857
+ 0.79 0.36 0.50 22214286
+ 0.79 0.36 0.50 29285714
+ 0.79 0.36 0.50 36357143
+ 0.79 0.36 0.50 43428571
+ 0.79 0.36 0.50 50500000
+ 0.79 0.36 0.50 57571429
+ 0.79 0.36 0.50 64642857
+ 0.79 0.36 0.50 71714286
+ 0.79 0.36 0.50 78785714
+ 0.79 0.36 0.50 85857143
+ 0.79 0.36 0.50 92928571
+ 0.79 0.36 0.50 100000000
+ 0.79 0.36 0.57 1000000
+ 0.79 0.36 0.57 8071429
+ 0.79 0.36 0.57 15142857
+ 0.79 0.36 0.57 22214286
+ 0.79 0.36 0.57 29285714
+ 0.79 0.36 0.57 36357143
+ 0.79 0.36 0.57 43428571
+ 0.79 0.36 0.57 50500000
+ 0.79 0.36 0.57 57571429
+ 0.79 0.36 0.57 64642857
+ 0.79 0.36 0.57 71714286
+ 0.79 0.36 0.57 78785714
+ 0.79 0.36 0.57 85857143
+ 0.79 0.36 0.57 92928571
+ 0.79 0.36 0.57 100000000
+ 0.79 0.36 0.64 1000000
+ 0.79 0.36 0.64 8071429
+ 0.79 0.36 0.64 15142857
+ 0.79 0.36 0.64 22214286
+ 0.79 0.36 0.64 29285714
+ 0.79 0.36 0.64 36357143
+ 0.79 0.36 0.64 43428571
+ 0.79 0.36 0.64 50500000
+ 0.79 0.36 0.64 57571429
+ 0.79 0.36 0.64 64642857
+ 0.79 0.36 0.64 71714286
+ 0.79 0.36 0.64 78785714
+ 0.79 0.36 0.64 85857143
+ 0.79 0.36 0.64 92928571
+ 0.79 0.36 0.64 100000000
+ 0.79 0.36 0.71 1000000
+ 0.79 0.36 0.71 8071429
+ 0.79 0.36 0.71 15142857
+ 0.79 0.36 0.71 22214286
+ 0.79 0.36 0.71 29285714
+ 0.79 0.36 0.71 36357143
+ 0.79 0.36 0.71 43428571
+ 0.79 0.36 0.71 50500000
+ 0.79 0.36 0.71 57571429
+ 0.79 0.36 0.71 64642857
+ 0.79 0.36 0.71 71714286
+ 0.79 0.36 0.71 78785714
+ 0.79 0.36 0.71 85857143
+ 0.79 0.36 0.71 92928571
+ 0.79 0.36 0.71 100000000
+ 0.79 0.36 0.79 1000000
+ 0.79 0.36 0.79 8071429
+ 0.79 0.36 0.79 15142857
+ 0.79 0.36 0.79 22214286
+ 0.79 0.36 0.79 29285714
+ 0.79 0.36 0.79 36357143
+ 0.79 0.36 0.79 43428571
+ 0.79 0.36 0.79 50500000
+ 0.79 0.36 0.79 57571429
+ 0.79 0.36 0.79 64642857
+ 0.79 0.36 0.79 71714286
+ 0.79 0.36 0.79 78785714
+ 0.79 0.36 0.79 85857143
+ 0.79 0.36 0.79 92928571
+ 0.79 0.36 0.79 100000000
+ 0.79 0.36 0.86 1000000
+ 0.79 0.36 0.86 8071429
+ 0.79 0.36 0.86 15142857
+ 0.79 0.36 0.86 22214286
+ 0.79 0.36 0.86 29285714
+ 0.79 0.36 0.86 36357143
+ 0.79 0.36 0.86 43428571
+ 0.79 0.36 0.86 50500000
+ 0.79 0.36 0.86 57571429
+ 0.79 0.36 0.86 64642857
+ 0.79 0.36 0.86 71714286
+ 0.79 0.36 0.86 78785714
+ 0.79 0.36 0.86 85857143
+ 0.79 0.36 0.86 92928571
+ 0.79 0.36 0.86 100000000
+ 0.79 0.36 0.93 1000000
+ 0.79 0.36 0.93 8071429
+ 0.79 0.36 0.93 15142857
+ 0.79 0.36 0.93 22214286
+ 0.79 0.36 0.93 29285714
+ 0.79 0.36 0.93 36357143
+ 0.79 0.36 0.93 43428571
+ 0.79 0.36 0.93 50500000
+ 0.79 0.36 0.93 57571429
+ 0.79 0.36 0.93 64642857
+ 0.79 0.36 0.93 71714286
+ 0.79 0.36 0.93 78785714
+ 0.79 0.36 0.93 85857143
+ 0.79 0.36 0.93 92928571
+ 0.79 0.36 0.93 100000000
+ 0.79 0.36 1.00 1000000
+ 0.79 0.36 1.00 8071429
+ 0.79 0.36 1.00 15142857
+ 0.79 0.36 1.00 22214286
+ 0.79 0.36 1.00 29285714
+ 0.79 0.36 1.00 36357143
+ 0.79 0.36 1.00 43428571
+ 0.79 0.36 1.00 50500000
+ 0.79 0.36 1.00 57571429
+ 0.79 0.36 1.00 64642857
+ 0.79 0.36 1.00 71714286
+ 0.79 0.36 1.00 78785714
+ 0.79 0.36 1.00 85857143
+ 0.79 0.36 1.00 92928571
+ 0.79 0.36 1.00 100000000
+ 0.79 0.43 0.00 1000000
+ 0.79 0.43 0.00 8071429
+ 0.79 0.43 0.00 15142857
+ 0.79 0.43 0.00 22214286
+ 0.79 0.43 0.00 29285714
+ 0.79 0.43 0.00 36357143
+ 0.79 0.43 0.00 43428571
+ 0.79 0.43 0.00 50500000
+ 0.79 0.43 0.00 57571429
+ 0.79 0.43 0.00 64642857
+ 0.79 0.43 0.00 71714286
+ 0.79 0.43 0.00 78785714
+ 0.79 0.43 0.00 85857143
+ 0.79 0.43 0.00 92928571
+ 0.79 0.43 0.00 100000000
+ 0.79 0.43 0.07 1000000
+ 0.79 0.43 0.07 8071429
+ 0.79 0.43 0.07 15142857
+ 0.79 0.43 0.07 22214286
+ 0.79 0.43 0.07 29285714
+ 0.79 0.43 0.07 36357143
+ 0.79 0.43 0.07 43428571
+ 0.79 0.43 0.07 50500000
+ 0.79 0.43 0.07 57571429
+ 0.79 0.43 0.07 64642857
+ 0.79 0.43 0.07 71714286
+ 0.79 0.43 0.07 78785714
+ 0.79 0.43 0.07 85857143
+ 0.79 0.43 0.07 92928571
+ 0.79 0.43 0.07 100000000
+ 0.79 0.43 0.14 1000000
+ 0.79 0.43 0.14 8071429
+ 0.79 0.43 0.14 15142857
+ 0.79 0.43 0.14 22214286
+ 0.79 0.43 0.14 29285714
+ 0.79 0.43 0.14 36357143
+ 0.79 0.43 0.14 43428571
+ 0.79 0.43 0.14 50500000
+ 0.79 0.43 0.14 57571429
+ 0.79 0.43 0.14 64642857
+ 0.79 0.43 0.14 71714286
+ 0.79 0.43 0.14 78785714
+ 0.79 0.43 0.14 85857143
+ 0.79 0.43 0.14 92928571
+ 0.79 0.43 0.14 100000000
+ 0.79 0.43 0.21 1000000
+ 0.79 0.43 0.21 8071429
+ 0.79 0.43 0.21 15142857
+ 0.79 0.43 0.21 22214286
+ 0.79 0.43 0.21 29285714
+ 0.79 0.43 0.21 36357143
+ 0.79 0.43 0.21 43428571
+ 0.79 0.43 0.21 50500000
+ 0.79 0.43 0.21 57571429
+ 0.79 0.43 0.21 64642857
+ 0.79 0.43 0.21 71714286
+ 0.79 0.43 0.21 78785714
+ 0.79 0.43 0.21 85857143
+ 0.79 0.43 0.21 92928571
+ 0.79 0.43 0.21 100000000
+ 0.79 0.43 0.29 1000000
+ 0.79 0.43 0.29 8071429
+ 0.79 0.43 0.29 15142857
+ 0.79 0.43 0.29 22214286
+ 0.79 0.43 0.29 29285714
+ 0.79 0.43 0.29 36357143
+ 0.79 0.43 0.29 43428571
+ 0.79 0.43 0.29 50500000
+ 0.79 0.43 0.29 57571429
+ 0.79 0.43 0.29 64642857
+ 0.79 0.43 0.29 71714286
+ 0.79 0.43 0.29 78785714
+ 0.79 0.43 0.29 85857143
+ 0.79 0.43 0.29 92928571
+ 0.79 0.43 0.29 100000000
+ 0.79 0.43 0.36 1000000
+ 0.79 0.43 0.36 8071429
+ 0.79 0.43 0.36 15142857
+ 0.79 0.43 0.36 22214286
+ 0.79 0.43 0.36 29285714
+ 0.79 0.43 0.36 36357143
+ 0.79 0.43 0.36 43428571
+ 0.79 0.43 0.36 50500000
+ 0.79 0.43 0.36 57571429
+ 0.79 0.43 0.36 64642857
+ 0.79 0.43 0.36 71714286
+ 0.79 0.43 0.36 78785714
+ 0.79 0.43 0.36 85857143
+ 0.79 0.43 0.36 92928571
+ 0.79 0.43 0.36 100000000
+ 0.79 0.43 0.43 1000000
+ 0.79 0.43 0.43 8071429
+ 0.79 0.43 0.43 15142857
+ 0.79 0.43 0.43 22214286
+ 0.79 0.43 0.43 29285714
+ 0.79 0.43 0.43 36357143
+ 0.79 0.43 0.43 43428571
+ 0.79 0.43 0.43 50500000
+ 0.79 0.43 0.43 57571429
+ 0.79 0.43 0.43 64642857
+ 0.79 0.43 0.43 71714286
+ 0.79 0.43 0.43 78785714
+ 0.79 0.43 0.43 85857143
+ 0.79 0.43 0.43 92928571
+ 0.79 0.43 0.43 100000000
+ 0.79 0.43 0.50 1000000
+ 0.79 0.43 0.50 8071429
+ 0.79 0.43 0.50 15142857
+ 0.79 0.43 0.50 22214286
+ 0.79 0.43 0.50 29285714
+ 0.79 0.43 0.50 36357143
+ 0.79 0.43 0.50 43428571
+ 0.79 0.43 0.50 50500000
+ 0.79 0.43 0.50 57571429
+ 0.79 0.43 0.50 64642857
+ 0.79 0.43 0.50 71714286
+ 0.79 0.43 0.50 78785714
+ 0.79 0.43 0.50 85857143
+ 0.79 0.43 0.50 92928571
+ 0.79 0.43 0.50 100000000
+ 0.79 0.43 0.57 1000000
+ 0.79 0.43 0.57 8071429
+ 0.79 0.43 0.57 15142857
+ 0.79 0.43 0.57 22214286
+ 0.79 0.43 0.57 29285714
+ 0.79 0.43 0.57 36357143
+ 0.79 0.43 0.57 43428571
+ 0.79 0.43 0.57 50500000
+ 0.79 0.43 0.57 57571429
+ 0.79 0.43 0.57 64642857
+ 0.79 0.43 0.57 71714286
+ 0.79 0.43 0.57 78785714
+ 0.79 0.43 0.57 85857143
+ 0.79 0.43 0.57 92928571
+ 0.79 0.43 0.57 100000000
+ 0.79 0.43 0.64 1000000
+ 0.79 0.43 0.64 8071429
+ 0.79 0.43 0.64 15142857
+ 0.79 0.43 0.64 22214286
+ 0.79 0.43 0.64 29285714
+ 0.79 0.43 0.64 36357143
+ 0.79 0.43 0.64 43428571
+ 0.79 0.43 0.64 50500000
+ 0.79 0.43 0.64 57571429
+ 0.79 0.43 0.64 64642857
+ 0.79 0.43 0.64 71714286
+ 0.79 0.43 0.64 78785714
+ 0.79 0.43 0.64 85857143
+ 0.79 0.43 0.64 92928571
+ 0.79 0.43 0.64 100000000
+ 0.79 0.43 0.71 1000000
+ 0.79 0.43 0.71 8071429
+ 0.79 0.43 0.71 15142857
+ 0.79 0.43 0.71 22214286
+ 0.79 0.43 0.71 29285714
+ 0.79 0.43 0.71 36357143
+ 0.79 0.43 0.71 43428571
+ 0.79 0.43 0.71 50500000
+ 0.79 0.43 0.71 57571429
+ 0.79 0.43 0.71 64642857
+ 0.79 0.43 0.71 71714286
+ 0.79 0.43 0.71 78785714
+ 0.79 0.43 0.71 85857143
+ 0.79 0.43 0.71 92928571
+ 0.79 0.43 0.71 100000000
+ 0.79 0.43 0.79 1000000
+ 0.79 0.43 0.79 8071429
+ 0.79 0.43 0.79 15142857
+ 0.79 0.43 0.79 22214286
+ 0.79 0.43 0.79 29285714
+ 0.79 0.43 0.79 36357143
+ 0.79 0.43 0.79 43428571
+ 0.79 0.43 0.79 50500000
+ 0.79 0.43 0.79 57571429
+ 0.79 0.43 0.79 64642857
+ 0.79 0.43 0.79 71714286
+ 0.79 0.43 0.79 78785714
+ 0.79 0.43 0.79 85857143
+ 0.79 0.43 0.79 92928571
+ 0.79 0.43 0.79 100000000
+ 0.79 0.43 0.86 1000000
+ 0.79 0.43 0.86 8071429
+ 0.79 0.43 0.86 15142857
+ 0.79 0.43 0.86 22214286
+ 0.79 0.43 0.86 29285714
+ 0.79 0.43 0.86 36357143
+ 0.79 0.43 0.86 43428571
+ 0.79 0.43 0.86 50500000
+ 0.79 0.43 0.86 57571429
+ 0.79 0.43 0.86 64642857
+ 0.79 0.43 0.86 71714286
+ 0.79 0.43 0.86 78785714
+ 0.79 0.43 0.86 85857143
+ 0.79 0.43 0.86 92928571
+ 0.79 0.43 0.86 100000000
+ 0.79 0.43 0.93 1000000
+ 0.79 0.43 0.93 8071429
+ 0.79 0.43 0.93 15142857
+ 0.79 0.43 0.93 22214286
+ 0.79 0.43 0.93 29285714
+ 0.79 0.43 0.93 36357143
+ 0.79 0.43 0.93 43428571
+ 0.79 0.43 0.93 50500000
+ 0.79 0.43 0.93 57571429
+ 0.79 0.43 0.93 64642857
+ 0.79 0.43 0.93 71714286
+ 0.79 0.43 0.93 78785714
+ 0.79 0.43 0.93 85857143
+ 0.79 0.43 0.93 92928571
+ 0.79 0.43 0.93 100000000
+ 0.79 0.43 1.00 1000000
+ 0.79 0.43 1.00 8071429
+ 0.79 0.43 1.00 15142857
+ 0.79 0.43 1.00 22214286
+ 0.79 0.43 1.00 29285714
+ 0.79 0.43 1.00 36357143
+ 0.79 0.43 1.00 43428571
+ 0.79 0.43 1.00 50500000
+ 0.79 0.43 1.00 57571429
+ 0.79 0.43 1.00 64642857
+ 0.79 0.43 1.00 71714286
+ 0.79 0.43 1.00 78785714
+ 0.79 0.43 1.00 85857143
+ 0.79 0.43 1.00 92928571
+ 0.79 0.43 1.00 100000000
+ 0.79 0.50 0.00 1000000
+ 0.79 0.50 0.00 8071429
+ 0.79 0.50 0.00 15142857
+ 0.79 0.50 0.00 22214286
+ 0.79 0.50 0.00 29285714
+ 0.79 0.50 0.00 36357143
+ 0.79 0.50 0.00 43428571
+ 0.79 0.50 0.00 50500000
+ 0.79 0.50 0.00 57571429
+ 0.79 0.50 0.00 64642857
+ 0.79 0.50 0.00 71714286
+ 0.79 0.50 0.00 78785714
+ 0.79 0.50 0.00 85857143
+ 0.79 0.50 0.00 92928571
+ 0.79 0.50 0.00 100000000
+ 0.79 0.50 0.07 1000000
+ 0.79 0.50 0.07 8071429
+ 0.79 0.50 0.07 15142857
+ 0.79 0.50 0.07 22214286
+ 0.79 0.50 0.07 29285714
+ 0.79 0.50 0.07 36357143
+ 0.79 0.50 0.07 43428571
+ 0.79 0.50 0.07 50500000
+ 0.79 0.50 0.07 57571429
+ 0.79 0.50 0.07 64642857
+ 0.79 0.50 0.07 71714286
+ 0.79 0.50 0.07 78785714
+ 0.79 0.50 0.07 85857143
+ 0.79 0.50 0.07 92928571
+ 0.79 0.50 0.07 100000000
+ 0.79 0.50 0.14 1000000
+ 0.79 0.50 0.14 8071429
+ 0.79 0.50 0.14 15142857
+ 0.79 0.50 0.14 22214286
+ 0.79 0.50 0.14 29285714
+ 0.79 0.50 0.14 36357143
+ 0.79 0.50 0.14 43428571
+ 0.79 0.50 0.14 50500000
+ 0.79 0.50 0.14 57571429
+ 0.79 0.50 0.14 64642857
+ 0.79 0.50 0.14 71714286
+ 0.79 0.50 0.14 78785714
+ 0.79 0.50 0.14 85857143
+ 0.79 0.50 0.14 92928571
+ 0.79 0.50 0.14 100000000
+ 0.79 0.50 0.21 1000000
+ 0.79 0.50 0.21 8071429
+ 0.79 0.50 0.21 15142857
+ 0.79 0.50 0.21 22214286
+ 0.79 0.50 0.21 29285714
+ 0.79 0.50 0.21 36357143
+ 0.79 0.50 0.21 43428571
+ 0.79 0.50 0.21 50500000
+ 0.79 0.50 0.21 57571429
+ 0.79 0.50 0.21 64642857
+ 0.79 0.50 0.21 71714286
+ 0.79 0.50 0.21 78785714
+ 0.79 0.50 0.21 85857143
+ 0.79 0.50 0.21 92928571
+ 0.79 0.50 0.21 100000000
+ 0.79 0.50 0.29 1000000
+ 0.79 0.50 0.29 8071429
+ 0.79 0.50 0.29 15142857
+ 0.79 0.50 0.29 22214286
+ 0.79 0.50 0.29 29285714
+ 0.79 0.50 0.29 36357143
+ 0.79 0.50 0.29 43428571
+ 0.79 0.50 0.29 50500000
+ 0.79 0.50 0.29 57571429
+ 0.79 0.50 0.29 64642857
+ 0.79 0.50 0.29 71714286
+ 0.79 0.50 0.29 78785714
+ 0.79 0.50 0.29 85857143
+ 0.79 0.50 0.29 92928571
+ 0.79 0.50 0.29 100000000
+ 0.79 0.50 0.36 1000000
+ 0.79 0.50 0.36 8071429
+ 0.79 0.50 0.36 15142857
+ 0.79 0.50 0.36 22214286
+ 0.79 0.50 0.36 29285714
+ 0.79 0.50 0.36 36357143
+ 0.79 0.50 0.36 43428571
+ 0.79 0.50 0.36 50500000
+ 0.79 0.50 0.36 57571429
+ 0.79 0.50 0.36 64642857
+ 0.79 0.50 0.36 71714286
+ 0.79 0.50 0.36 78785714
+ 0.79 0.50 0.36 85857143
+ 0.79 0.50 0.36 92928571
+ 0.79 0.50 0.36 100000000
+ 0.79 0.50 0.43 1000000
+ 0.79 0.50 0.43 8071429
+ 0.79 0.50 0.43 15142857
+ 0.79 0.50 0.43 22214286
+ 0.79 0.50 0.43 29285714
+ 0.79 0.50 0.43 36357143
+ 0.79 0.50 0.43 43428571
+ 0.79 0.50 0.43 50500000
+ 0.79 0.50 0.43 57571429
+ 0.79 0.50 0.43 64642857
+ 0.79 0.50 0.43 71714286
+ 0.79 0.50 0.43 78785714
+ 0.79 0.50 0.43 85857143
+ 0.79 0.50 0.43 92928571
+ 0.79 0.50 0.43 100000000
+ 0.79 0.50 0.50 1000000
+ 0.79 0.50 0.50 8071429
+ 0.79 0.50 0.50 15142857
+ 0.79 0.50 0.50 22214286
+ 0.79 0.50 0.50 29285714
+ 0.79 0.50 0.50 36357143
+ 0.79 0.50 0.50 43428571
+ 0.79 0.50 0.50 50500000
+ 0.79 0.50 0.50 57571429
+ 0.79 0.50 0.50 64642857
+ 0.79 0.50 0.50 71714286
+ 0.79 0.50 0.50 78785714
+ 0.79 0.50 0.50 85857143
+ 0.79 0.50 0.50 92928571
+ 0.79 0.50 0.50 100000000
+ 0.79 0.50 0.57 1000000
+ 0.79 0.50 0.57 8071429
+ 0.79 0.50 0.57 15142857
+ 0.79 0.50 0.57 22214286
+ 0.79 0.50 0.57 29285714
+ 0.79 0.50 0.57 36357143
+ 0.79 0.50 0.57 43428571
+ 0.79 0.50 0.57 50500000
+ 0.79 0.50 0.57 57571429
+ 0.79 0.50 0.57 64642857
+ 0.79 0.50 0.57 71714286
+ 0.79 0.50 0.57 78785714
+ 0.79 0.50 0.57 85857143
+ 0.79 0.50 0.57 92928571
+ 0.79 0.50 0.57 100000000
+ 0.79 0.50 0.64 1000000
+ 0.79 0.50 0.64 8071429
+ 0.79 0.50 0.64 15142857
+ 0.79 0.50 0.64 22214286
+ 0.79 0.50 0.64 29285714
+ 0.79 0.50 0.64 36357143
+ 0.79 0.50 0.64 43428571
+ 0.79 0.50 0.64 50500000
+ 0.79 0.50 0.64 57571429
+ 0.79 0.50 0.64 64642857
+ 0.79 0.50 0.64 71714286
+ 0.79 0.50 0.64 78785714
+ 0.79 0.50 0.64 85857143
+ 0.79 0.50 0.64 92928571
+ 0.79 0.50 0.64 100000000
+ 0.79 0.50 0.71 1000000
+ 0.79 0.50 0.71 8071429
+ 0.79 0.50 0.71 15142857
+ 0.79 0.50 0.71 22214286
+ 0.79 0.50 0.71 29285714
+ 0.79 0.50 0.71 36357143
+ 0.79 0.50 0.71 43428571
+ 0.79 0.50 0.71 50500000
+ 0.79 0.50 0.71 57571429
+ 0.79 0.50 0.71 64642857
+ 0.79 0.50 0.71 71714286
+ 0.79 0.50 0.71 78785714
+ 0.79 0.50 0.71 85857143
+ 0.79 0.50 0.71 92928571
+ 0.79 0.50 0.71 100000000
+ 0.79 0.50 0.79 1000000
+ 0.79 0.50 0.79 8071429
+ 0.79 0.50 0.79 15142857
+ 0.79 0.50 0.79 22214286
+ 0.79 0.50 0.79 29285714
+ 0.79 0.50 0.79 36357143
+ 0.79 0.50 0.79 43428571
+ 0.79 0.50 0.79 50500000
+ 0.79 0.50 0.79 57571429
+ 0.79 0.50 0.79 64642857
+ 0.79 0.50 0.79 71714286
+ 0.79 0.50 0.79 78785714
+ 0.79 0.50 0.79 85857143
+ 0.79 0.50 0.79 92928571
+ 0.79 0.50 0.79 100000000
+ 0.79 0.50 0.86 1000000
+ 0.79 0.50 0.86 8071429
+ 0.79 0.50 0.86 15142857
+ 0.79 0.50 0.86 22214286
+ 0.79 0.50 0.86 29285714
+ 0.79 0.50 0.86 36357143
+ 0.79 0.50 0.86 43428571
+ 0.79 0.50 0.86 50500000
+ 0.79 0.50 0.86 57571429
+ 0.79 0.50 0.86 64642857
+ 0.79 0.50 0.86 71714286
+ 0.79 0.50 0.86 78785714
+ 0.79 0.50 0.86 85857143
+ 0.79 0.50 0.86 92928571
+ 0.79 0.50 0.86 100000000
+ 0.79 0.50 0.93 1000000
+ 0.79 0.50 0.93 8071429
+ 0.79 0.50 0.93 15142857
+ 0.79 0.50 0.93 22214286
+ 0.79 0.50 0.93 29285714
+ 0.79 0.50 0.93 36357143
+ 0.79 0.50 0.93 43428571
+ 0.79 0.50 0.93 50500000
+ 0.79 0.50 0.93 57571429
+ 0.79 0.50 0.93 64642857
+ 0.79 0.50 0.93 71714286
+ 0.79 0.50 0.93 78785714
+ 0.79 0.50 0.93 85857143
+ 0.79 0.50 0.93 92928571
+ 0.79 0.50 0.93 100000000
+ 0.79 0.50 1.00 1000000
+ 0.79 0.50 1.00 8071429
+ 0.79 0.50 1.00 15142857
+ 0.79 0.50 1.00 22214286
+ 0.79 0.50 1.00 29285714
+ 0.79 0.50 1.00 36357143
+ 0.79 0.50 1.00 43428571
+ 0.79 0.50 1.00 50500000
+ 0.79 0.50 1.00 57571429
+ 0.79 0.50 1.00 64642857
+ 0.79 0.50 1.00 71714286
+ 0.79 0.50 1.00 78785714
+ 0.79 0.50 1.00 85857143
+ 0.79 0.50 1.00 92928571
+ 0.79 0.50 1.00 100000000
+ 0.79 0.57 0.00 1000000
+ 0.79 0.57 0.00 8071429
+ 0.79 0.57 0.00 15142857
+ 0.79 0.57 0.00 22214286
+ 0.79 0.57 0.00 29285714
+ 0.79 0.57 0.00 36357143
+ 0.79 0.57 0.00 43428571
+ 0.79 0.57 0.00 50500000
+ 0.79 0.57 0.00 57571429
+ 0.79 0.57 0.00 64642857
+ 0.79 0.57 0.00 71714286
+ 0.79 0.57 0.00 78785714
+ 0.79 0.57 0.00 85857143
+ 0.79 0.57 0.00 92928571
+ 0.79 0.57 0.00 100000000
+ 0.79 0.57 0.07 1000000
+ 0.79 0.57 0.07 8071429
+ 0.79 0.57 0.07 15142857
+ 0.79 0.57 0.07 22214286
+ 0.79 0.57 0.07 29285714
+ 0.79 0.57 0.07 36357143
+ 0.79 0.57 0.07 43428571
+ 0.79 0.57 0.07 50500000
+ 0.79 0.57 0.07 57571429
+ 0.79 0.57 0.07 64642857
+ 0.79 0.57 0.07 71714286
+ 0.79 0.57 0.07 78785714
+ 0.79 0.57 0.07 85857143
+ 0.79 0.57 0.07 92928571
+ 0.79 0.57 0.07 100000000
+ 0.79 0.57 0.14 1000000
+ 0.79 0.57 0.14 8071429
+ 0.79 0.57 0.14 15142857
+ 0.79 0.57 0.14 22214286
+ 0.79 0.57 0.14 29285714
+ 0.79 0.57 0.14 36357143
+ 0.79 0.57 0.14 43428571
+ 0.79 0.57 0.14 50500000
+ 0.79 0.57 0.14 57571429
+ 0.79 0.57 0.14 64642857
+ 0.79 0.57 0.14 71714286
+ 0.79 0.57 0.14 78785714
+ 0.79 0.57 0.14 85857143
+ 0.79 0.57 0.14 92928571
+ 0.79 0.57 0.14 100000000
+ 0.79 0.57 0.21 1000000
+ 0.79 0.57 0.21 8071429
+ 0.79 0.57 0.21 15142857
+ 0.79 0.57 0.21 22214286
+ 0.79 0.57 0.21 29285714
+ 0.79 0.57 0.21 36357143
+ 0.79 0.57 0.21 43428571
+ 0.79 0.57 0.21 50500000
+ 0.79 0.57 0.21 57571429
+ 0.79 0.57 0.21 64642857
+ 0.79 0.57 0.21 71714286
+ 0.79 0.57 0.21 78785714
+ 0.79 0.57 0.21 85857143
+ 0.79 0.57 0.21 92928571
+ 0.79 0.57 0.21 100000000
+ 0.79 0.57 0.29 1000000
+ 0.79 0.57 0.29 8071429
+ 0.79 0.57 0.29 15142857
+ 0.79 0.57 0.29 22214286
+ 0.79 0.57 0.29 29285714
+ 0.79 0.57 0.29 36357143
+ 0.79 0.57 0.29 43428571
+ 0.79 0.57 0.29 50500000
+ 0.79 0.57 0.29 57571429
+ 0.79 0.57 0.29 64642857
+ 0.79 0.57 0.29 71714286
+ 0.79 0.57 0.29 78785714
+ 0.79 0.57 0.29 85857143
+ 0.79 0.57 0.29 92928571
+ 0.79 0.57 0.29 100000000
+ 0.79 0.57 0.36 1000000
+ 0.79 0.57 0.36 8071429
+ 0.79 0.57 0.36 15142857
+ 0.79 0.57 0.36 22214286
+ 0.79 0.57 0.36 29285714
+ 0.79 0.57 0.36 36357143
+ 0.79 0.57 0.36 43428571
+ 0.79 0.57 0.36 50500000
+ 0.79 0.57 0.36 57571429
+ 0.79 0.57 0.36 64642857
+ 0.79 0.57 0.36 71714286
+ 0.79 0.57 0.36 78785714
+ 0.79 0.57 0.36 85857143
+ 0.79 0.57 0.36 92928571
+ 0.79 0.57 0.36 100000000
+ 0.79 0.57 0.43 1000000
+ 0.79 0.57 0.43 8071429
+ 0.79 0.57 0.43 15142857
+ 0.79 0.57 0.43 22214286
+ 0.79 0.57 0.43 29285714
+ 0.79 0.57 0.43 36357143
+ 0.79 0.57 0.43 43428571
+ 0.79 0.57 0.43 50500000
+ 0.79 0.57 0.43 57571429
+ 0.79 0.57 0.43 64642857
+ 0.79 0.57 0.43 71714286
+ 0.79 0.57 0.43 78785714
+ 0.79 0.57 0.43 85857143
+ 0.79 0.57 0.43 92928571
+ 0.79 0.57 0.43 100000000
+ 0.79 0.57 0.50 1000000
+ 0.79 0.57 0.50 8071429
+ 0.79 0.57 0.50 15142857
+ 0.79 0.57 0.50 22214286
+ 0.79 0.57 0.50 29285714
+ 0.79 0.57 0.50 36357143
+ 0.79 0.57 0.50 43428571
+ 0.79 0.57 0.50 50500000
+ 0.79 0.57 0.50 57571429
+ 0.79 0.57 0.50 64642857
+ 0.79 0.57 0.50 71714286
+ 0.79 0.57 0.50 78785714
+ 0.79 0.57 0.50 85857143
+ 0.79 0.57 0.50 92928571
+ 0.79 0.57 0.50 100000000
+ 0.79 0.57 0.57 1000000
+ 0.79 0.57 0.57 8071429
+ 0.79 0.57 0.57 15142857
+ 0.79 0.57 0.57 22214286
+ 0.79 0.57 0.57 29285714
+ 0.79 0.57 0.57 36357143
+ 0.79 0.57 0.57 43428571
+ 0.79 0.57 0.57 50500000
+ 0.79 0.57 0.57 57571429
+ 0.79 0.57 0.57 64642857
+ 0.79 0.57 0.57 71714286
+ 0.79 0.57 0.57 78785714
+ 0.79 0.57 0.57 85857143
+ 0.79 0.57 0.57 92928571
+ 0.79 0.57 0.57 100000000
+ 0.79 0.57 0.64 1000000
+ 0.79 0.57 0.64 8071429
+ 0.79 0.57 0.64 15142857
+ 0.79 0.57 0.64 22214286
+ 0.79 0.57 0.64 29285714
+ 0.79 0.57 0.64 36357143
+ 0.79 0.57 0.64 43428571
+ 0.79 0.57 0.64 50500000
+ 0.79 0.57 0.64 57571429
+ 0.79 0.57 0.64 64642857
+ 0.79 0.57 0.64 71714286
+ 0.79 0.57 0.64 78785714
+ 0.79 0.57 0.64 85857143
+ 0.79 0.57 0.64 92928571
+ 0.79 0.57 0.64 100000000
+ 0.79 0.57 0.71 1000000
+ 0.79 0.57 0.71 8071429
+ 0.79 0.57 0.71 15142857
+ 0.79 0.57 0.71 22214286
+ 0.79 0.57 0.71 29285714
+ 0.79 0.57 0.71 36357143
+ 0.79 0.57 0.71 43428571
+ 0.79 0.57 0.71 50500000
+ 0.79 0.57 0.71 57571429
+ 0.79 0.57 0.71 64642857
+ 0.79 0.57 0.71 71714286
+ 0.79 0.57 0.71 78785714
+ 0.79 0.57 0.71 85857143
+ 0.79 0.57 0.71 92928571
+ 0.79 0.57 0.71 100000000
+ 0.79 0.57 0.79 1000000
+ 0.79 0.57 0.79 8071429
+ 0.79 0.57 0.79 15142857
+ 0.79 0.57 0.79 22214286
+ 0.79 0.57 0.79 29285714
+ 0.79 0.57 0.79 36357143
+ 0.79 0.57 0.79 43428571
+ 0.79 0.57 0.79 50500000
+ 0.79 0.57 0.79 57571429
+ 0.79 0.57 0.79 64642857
+ 0.79 0.57 0.79 71714286
+ 0.79 0.57 0.79 78785714
+ 0.79 0.57 0.79 85857143
+ 0.79 0.57 0.79 92928571
+ 0.79 0.57 0.79 100000000
+ 0.79 0.57 0.86 1000000
+ 0.79 0.57 0.86 8071429
+ 0.79 0.57 0.86 15142857
+ 0.79 0.57 0.86 22214286
+ 0.79 0.57 0.86 29285714
+ 0.79 0.57 0.86 36357143
+ 0.79 0.57 0.86 43428571
+ 0.79 0.57 0.86 50500000
+ 0.79 0.57 0.86 57571429
+ 0.79 0.57 0.86 64642857
+ 0.79 0.57 0.86 71714286
+ 0.79 0.57 0.86 78785714
+ 0.79 0.57 0.86 85857143
+ 0.79 0.57 0.86 92928571
+ 0.79 0.57 0.86 100000000
+ 0.79 0.57 0.93 1000000
+ 0.79 0.57 0.93 8071429
+ 0.79 0.57 0.93 15142857
+ 0.79 0.57 0.93 22214286
+ 0.79 0.57 0.93 29285714
+ 0.79 0.57 0.93 36357143
+ 0.79 0.57 0.93 43428571
+ 0.79 0.57 0.93 50500000
+ 0.79 0.57 0.93 57571429
+ 0.79 0.57 0.93 64642857
+ 0.79 0.57 0.93 71714286
+ 0.79 0.57 0.93 78785714
+ 0.79 0.57 0.93 85857143
+ 0.79 0.57 0.93 92928571
+ 0.79 0.57 0.93 100000000
+ 0.79 0.57 1.00 1000000
+ 0.79 0.57 1.00 8071429
+ 0.79 0.57 1.00 15142857
+ 0.79 0.57 1.00 22214286
+ 0.79 0.57 1.00 29285714
+ 0.79 0.57 1.00 36357143
+ 0.79 0.57 1.00 43428571
+ 0.79 0.57 1.00 50500000
+ 0.79 0.57 1.00 57571429
+ 0.79 0.57 1.00 64642857
+ 0.79 0.57 1.00 71714286
+ 0.79 0.57 1.00 78785714
+ 0.79 0.57 1.00 85857143
+ 0.79 0.57 1.00 92928571
+ 0.79 0.57 1.00 100000000
+ 0.79 0.64 0.00 1000000
+ 0.79 0.64 0.00 8071429
+ 0.79 0.64 0.00 15142857
+ 0.79 0.64 0.00 22214286
+ 0.79 0.64 0.00 29285714
+ 0.79 0.64 0.00 36357143
+ 0.79 0.64 0.00 43428571
+ 0.79 0.64 0.00 50500000
+ 0.79 0.64 0.00 57571429
+ 0.79 0.64 0.00 64642857
+ 0.79 0.64 0.00 71714286
+ 0.79 0.64 0.00 78785714
+ 0.79 0.64 0.00 85857143
+ 0.79 0.64 0.00 92928571
+ 0.79 0.64 0.00 100000000
+ 0.79 0.64 0.07 1000000
+ 0.79 0.64 0.07 8071429
+ 0.79 0.64 0.07 15142857
+ 0.79 0.64 0.07 22214286
+ 0.79 0.64 0.07 29285714
+ 0.79 0.64 0.07 36357143
+ 0.79 0.64 0.07 43428571
+ 0.79 0.64 0.07 50500000
+ 0.79 0.64 0.07 57571429
+ 0.79 0.64 0.07 64642857
+ 0.79 0.64 0.07 71714286
+ 0.79 0.64 0.07 78785714
+ 0.79 0.64 0.07 85857143
+ 0.79 0.64 0.07 92928571
+ 0.79 0.64 0.07 100000000
+ 0.79 0.64 0.14 1000000
+ 0.79 0.64 0.14 8071429
+ 0.79 0.64 0.14 15142857
+ 0.79 0.64 0.14 22214286
+ 0.79 0.64 0.14 29285714
+ 0.79 0.64 0.14 36357143
+ 0.79 0.64 0.14 43428571
+ 0.79 0.64 0.14 50500000
+ 0.79 0.64 0.14 57571429
+ 0.79 0.64 0.14 64642857
+ 0.79 0.64 0.14 71714286
+ 0.79 0.64 0.14 78785714
+ 0.79 0.64 0.14 85857143
+ 0.79 0.64 0.14 92928571
+ 0.79 0.64 0.14 100000000
+ 0.79 0.64 0.21 1000000
+ 0.79 0.64 0.21 8071429
+ 0.79 0.64 0.21 15142857
+ 0.79 0.64 0.21 22214286
+ 0.79 0.64 0.21 29285714
+ 0.79 0.64 0.21 36357143
+ 0.79 0.64 0.21 43428571
+ 0.79 0.64 0.21 50500000
+ 0.79 0.64 0.21 57571429
+ 0.79 0.64 0.21 64642857
+ 0.79 0.64 0.21 71714286
+ 0.79 0.64 0.21 78785714
+ 0.79 0.64 0.21 85857143
+ 0.79 0.64 0.21 92928571
+ 0.79 0.64 0.21 100000000
+ 0.79 0.64 0.29 1000000
+ 0.79 0.64 0.29 8071429
+ 0.79 0.64 0.29 15142857
+ 0.79 0.64 0.29 22214286
+ 0.79 0.64 0.29 29285714
+ 0.79 0.64 0.29 36357143
+ 0.79 0.64 0.29 43428571
+ 0.79 0.64 0.29 50500000
+ 0.79 0.64 0.29 57571429
+ 0.79 0.64 0.29 64642857
+ 0.79 0.64 0.29 71714286
+ 0.79 0.64 0.29 78785714
+ 0.79 0.64 0.29 85857143
+ 0.79 0.64 0.29 92928571
+ 0.79 0.64 0.29 100000000
+ 0.79 0.64 0.36 1000000
+ 0.79 0.64 0.36 8071429
+ 0.79 0.64 0.36 15142857
+ 0.79 0.64 0.36 22214286
+ 0.79 0.64 0.36 29285714
+ 0.79 0.64 0.36 36357143
+ 0.79 0.64 0.36 43428571
+ 0.79 0.64 0.36 50500000
+ 0.79 0.64 0.36 57571429
+ 0.79 0.64 0.36 64642857
+ 0.79 0.64 0.36 71714286
+ 0.79 0.64 0.36 78785714
+ 0.79 0.64 0.36 85857143
+ 0.79 0.64 0.36 92928571
+ 0.79 0.64 0.36 100000000
+ 0.79 0.64 0.43 1000000
+ 0.79 0.64 0.43 8071429
+ 0.79 0.64 0.43 15142857
+ 0.79 0.64 0.43 22214286
+ 0.79 0.64 0.43 29285714
+ 0.79 0.64 0.43 36357143
+ 0.79 0.64 0.43 43428571
+ 0.79 0.64 0.43 50500000
+ 0.79 0.64 0.43 57571429
+ 0.79 0.64 0.43 64642857
+ 0.79 0.64 0.43 71714286
+ 0.79 0.64 0.43 78785714
+ 0.79 0.64 0.43 85857143
+ 0.79 0.64 0.43 92928571
+ 0.79 0.64 0.43 100000000
+ 0.79 0.64 0.50 1000000
+ 0.79 0.64 0.50 8071429
+ 0.79 0.64 0.50 15142857
+ 0.79 0.64 0.50 22214286
+ 0.79 0.64 0.50 29285714
+ 0.79 0.64 0.50 36357143
+ 0.79 0.64 0.50 43428571
+ 0.79 0.64 0.50 50500000
+ 0.79 0.64 0.50 57571429
+ 0.79 0.64 0.50 64642857
+ 0.79 0.64 0.50 71714286
+ 0.79 0.64 0.50 78785714
+ 0.79 0.64 0.50 85857143
+ 0.79 0.64 0.50 92928571
+ 0.79 0.64 0.50 100000000
+ 0.79 0.64 0.57 1000000
+ 0.79 0.64 0.57 8071429
+ 0.79 0.64 0.57 15142857
+ 0.79 0.64 0.57 22214286
+ 0.79 0.64 0.57 29285714
+ 0.79 0.64 0.57 36357143
+ 0.79 0.64 0.57 43428571
+ 0.79 0.64 0.57 50500000
+ 0.79 0.64 0.57 57571429
+ 0.79 0.64 0.57 64642857
+ 0.79 0.64 0.57 71714286
+ 0.79 0.64 0.57 78785714
+ 0.79 0.64 0.57 85857143
+ 0.79 0.64 0.57 92928571
+ 0.79 0.64 0.57 100000000
+ 0.79 0.64 0.64 1000000
+ 0.79 0.64 0.64 8071429
+ 0.79 0.64 0.64 15142857
+ 0.79 0.64 0.64 22214286
+ 0.79 0.64 0.64 29285714
+ 0.79 0.64 0.64 36357143
+ 0.79 0.64 0.64 43428571
+ 0.79 0.64 0.64 50500000
+ 0.79 0.64 0.64 57571429
+ 0.79 0.64 0.64 64642857
+ 0.79 0.64 0.64 71714286
+ 0.79 0.64 0.64 78785714
+ 0.79 0.64 0.64 85857143
+ 0.79 0.64 0.64 92928571
+ 0.79 0.64 0.64 100000000
+ 0.79 0.64 0.71 1000000
+ 0.79 0.64 0.71 8071429
+ 0.79 0.64 0.71 15142857
+ 0.79 0.64 0.71 22214286
+ 0.79 0.64 0.71 29285714
+ 0.79 0.64 0.71 36357143
+ 0.79 0.64 0.71 43428571
+ 0.79 0.64 0.71 50500000
+ 0.79 0.64 0.71 57571429
+ 0.79 0.64 0.71 64642857
+ 0.79 0.64 0.71 71714286
+ 0.79 0.64 0.71 78785714
+ 0.79 0.64 0.71 85857143
+ 0.79 0.64 0.71 92928571
+ 0.79 0.64 0.71 100000000
+ 0.79 0.64 0.79 1000000
+ 0.79 0.64 0.79 8071429
+ 0.79 0.64 0.79 15142857
+ 0.79 0.64 0.79 22214286
+ 0.79 0.64 0.79 29285714
+ 0.79 0.64 0.79 36357143
+ 0.79 0.64 0.79 43428571
+ 0.79 0.64 0.79 50500000
+ 0.79 0.64 0.79 57571429
+ 0.79 0.64 0.79 64642857
+ 0.79 0.64 0.79 71714286
+ 0.79 0.64 0.79 78785714
+ 0.79 0.64 0.79 85857143
+ 0.79 0.64 0.79 92928571
+ 0.79 0.64 0.79 100000000
+ 0.79 0.64 0.86 1000000
+ 0.79 0.64 0.86 8071429
+ 0.79 0.64 0.86 15142857
+ 0.79 0.64 0.86 22214286
+ 0.79 0.64 0.86 29285714
+ 0.79 0.64 0.86 36357143
+ 0.79 0.64 0.86 43428571
+ 0.79 0.64 0.86 50500000
+ 0.79 0.64 0.86 57571429
+ 0.79 0.64 0.86 64642857
+ 0.79 0.64 0.86 71714286
+ 0.79 0.64 0.86 78785714
+ 0.79 0.64 0.86 85857143
+ 0.79 0.64 0.86 92928571
+ 0.79 0.64 0.86 100000000
+ 0.79 0.64 0.93 1000000
+ 0.79 0.64 0.93 8071429
+ 0.79 0.64 0.93 15142857
+ 0.79 0.64 0.93 22214286
+ 0.79 0.64 0.93 29285714
+ 0.79 0.64 0.93 36357143
+ 0.79 0.64 0.93 43428571
+ 0.79 0.64 0.93 50500000
+ 0.79 0.64 0.93 57571429
+ 0.79 0.64 0.93 64642857
+ 0.79 0.64 0.93 71714286
+ 0.79 0.64 0.93 78785714
+ 0.79 0.64 0.93 85857143
+ 0.79 0.64 0.93 92928571
+ 0.79 0.64 0.93 100000000
+ 0.79 0.64 1.00 1000000
+ 0.79 0.64 1.00 8071429
+ 0.79 0.64 1.00 15142857
+ 0.79 0.64 1.00 22214286
+ 0.79 0.64 1.00 29285714
+ 0.79 0.64 1.00 36357143
+ 0.79 0.64 1.00 43428571
+ 0.79 0.64 1.00 50500000
+ 0.79 0.64 1.00 57571429
+ 0.79 0.64 1.00 64642857
+ 0.79 0.64 1.00 71714286
+ 0.79 0.64 1.00 78785714
+ 0.79 0.64 1.00 85857143
+ 0.79 0.64 1.00 92928571
+ 0.79 0.64 1.00 100000000
+ 0.79 0.71 0.00 1000000
+ 0.79 0.71 0.00 8071429
+ 0.79 0.71 0.00 15142857
+ 0.79 0.71 0.00 22214286
+ 0.79 0.71 0.00 29285714
+ 0.79 0.71 0.00 36357143
+ 0.79 0.71 0.00 43428571
+ 0.79 0.71 0.00 50500000
+ 0.79 0.71 0.00 57571429
+ 0.79 0.71 0.00 64642857
+ 0.79 0.71 0.00 71714286
+ 0.79 0.71 0.00 78785714
+ 0.79 0.71 0.00 85857143
+ 0.79 0.71 0.00 92928571
+ 0.79 0.71 0.00 100000000
+ 0.79 0.71 0.07 1000000
+ 0.79 0.71 0.07 8071429
+ 0.79 0.71 0.07 15142857
+ 0.79 0.71 0.07 22214286
+ 0.79 0.71 0.07 29285714
+ 0.79 0.71 0.07 36357143
+ 0.79 0.71 0.07 43428571
+ 0.79 0.71 0.07 50500000
+ 0.79 0.71 0.07 57571429
+ 0.79 0.71 0.07 64642857
+ 0.79 0.71 0.07 71714286
+ 0.79 0.71 0.07 78785714
+ 0.79 0.71 0.07 85857143
+ 0.79 0.71 0.07 92928571
+ 0.79 0.71 0.07 100000000
+ 0.79 0.71 0.14 1000000
+ 0.79 0.71 0.14 8071429
+ 0.79 0.71 0.14 15142857
+ 0.79 0.71 0.14 22214286
+ 0.79 0.71 0.14 29285714
+ 0.79 0.71 0.14 36357143
+ 0.79 0.71 0.14 43428571
+ 0.79 0.71 0.14 50500000
+ 0.79 0.71 0.14 57571429
+ 0.79 0.71 0.14 64642857
+ 0.79 0.71 0.14 71714286
+ 0.79 0.71 0.14 78785714
+ 0.79 0.71 0.14 85857143
+ 0.79 0.71 0.14 92928571
+ 0.79 0.71 0.14 100000000
+ 0.79 0.71 0.21 1000000
+ 0.79 0.71 0.21 8071429
+ 0.79 0.71 0.21 15142857
+ 0.79 0.71 0.21 22214286
+ 0.79 0.71 0.21 29285714
+ 0.79 0.71 0.21 36357143
+ 0.79 0.71 0.21 43428571
+ 0.79 0.71 0.21 50500000
+ 0.79 0.71 0.21 57571429
+ 0.79 0.71 0.21 64642857
+ 0.79 0.71 0.21 71714286
+ 0.79 0.71 0.21 78785714
+ 0.79 0.71 0.21 85857143
+ 0.79 0.71 0.21 92928571
+ 0.79 0.71 0.21 100000000
+ 0.79 0.71 0.29 1000000
+ 0.79 0.71 0.29 8071429
+ 0.79 0.71 0.29 15142857
+ 0.79 0.71 0.29 22214286
+ 0.79 0.71 0.29 29285714
+ 0.79 0.71 0.29 36357143
+ 0.79 0.71 0.29 43428571
+ 0.79 0.71 0.29 50500000
+ 0.79 0.71 0.29 57571429
+ 0.79 0.71 0.29 64642857
+ 0.79 0.71 0.29 71714286
+ 0.79 0.71 0.29 78785714
+ 0.79 0.71 0.29 85857143
+ 0.79 0.71 0.29 92928571
+ 0.79 0.71 0.29 100000000
+ 0.79 0.71 0.36 1000000
+ 0.79 0.71 0.36 8071429
+ 0.79 0.71 0.36 15142857
+ 0.79 0.71 0.36 22214286
+ 0.79 0.71 0.36 29285714
+ 0.79 0.71 0.36 36357143
+ 0.79 0.71 0.36 43428571
+ 0.79 0.71 0.36 50500000
+ 0.79 0.71 0.36 57571429
+ 0.79 0.71 0.36 64642857
+ 0.79 0.71 0.36 71714286
+ 0.79 0.71 0.36 78785714
+ 0.79 0.71 0.36 85857143
+ 0.79 0.71 0.36 92928571
+ 0.79 0.71 0.36 100000000
+ 0.79 0.71 0.43 1000000
+ 0.79 0.71 0.43 8071429
+ 0.79 0.71 0.43 15142857
+ 0.79 0.71 0.43 22214286
+ 0.79 0.71 0.43 29285714
+ 0.79 0.71 0.43 36357143
+ 0.79 0.71 0.43 43428571
+ 0.79 0.71 0.43 50500000
+ 0.79 0.71 0.43 57571429
+ 0.79 0.71 0.43 64642857
+ 0.79 0.71 0.43 71714286
+ 0.79 0.71 0.43 78785714
+ 0.79 0.71 0.43 85857143
+ 0.79 0.71 0.43 92928571
+ 0.79 0.71 0.43 100000000
+ 0.79 0.71 0.50 1000000
+ 0.79 0.71 0.50 8071429
+ 0.79 0.71 0.50 15142857
+ 0.79 0.71 0.50 22214286
+ 0.79 0.71 0.50 29285714
+ 0.79 0.71 0.50 36357143
+ 0.79 0.71 0.50 43428571
+ 0.79 0.71 0.50 50500000
+ 0.79 0.71 0.50 57571429
+ 0.79 0.71 0.50 64642857
+ 0.79 0.71 0.50 71714286
+ 0.79 0.71 0.50 78785714
+ 0.79 0.71 0.50 85857143
+ 0.79 0.71 0.50 92928571
+ 0.79 0.71 0.50 100000000
+ 0.79 0.71 0.57 1000000
+ 0.79 0.71 0.57 8071429
+ 0.79 0.71 0.57 15142857
+ 0.79 0.71 0.57 22214286
+ 0.79 0.71 0.57 29285714
+ 0.79 0.71 0.57 36357143
+ 0.79 0.71 0.57 43428571
+ 0.79 0.71 0.57 50500000
+ 0.79 0.71 0.57 57571429
+ 0.79 0.71 0.57 64642857
+ 0.79 0.71 0.57 71714286
+ 0.79 0.71 0.57 78785714
+ 0.79 0.71 0.57 85857143
+ 0.79 0.71 0.57 92928571
+ 0.79 0.71 0.57 100000000
+ 0.79 0.71 0.64 1000000
+ 0.79 0.71 0.64 8071429
+ 0.79 0.71 0.64 15142857
+ 0.79 0.71 0.64 22214286
+ 0.79 0.71 0.64 29285714
+ 0.79 0.71 0.64 36357143
+ 0.79 0.71 0.64 43428571
+ 0.79 0.71 0.64 50500000
+ 0.79 0.71 0.64 57571429
+ 0.79 0.71 0.64 64642857
+ 0.79 0.71 0.64 71714286
+ 0.79 0.71 0.64 78785714
+ 0.79 0.71 0.64 85857143
+ 0.79 0.71 0.64 92928571
+ 0.79 0.71 0.64 100000000
+ 0.79 0.71 0.71 1000000
+ 0.79 0.71 0.71 8071429
+ 0.79 0.71 0.71 15142857
+ 0.79 0.71 0.71 22214286
+ 0.79 0.71 0.71 29285714
+ 0.79 0.71 0.71 36357143
+ 0.79 0.71 0.71 43428571
+ 0.79 0.71 0.71 50500000
+ 0.79 0.71 0.71 57571429
+ 0.79 0.71 0.71 64642857
+ 0.79 0.71 0.71 71714286
+ 0.79 0.71 0.71 78785714
+ 0.79 0.71 0.71 85857143
+ 0.79 0.71 0.71 92928571
+ 0.79 0.71 0.71 100000000
+ 0.79 0.71 0.79 1000000
+ 0.79 0.71 0.79 8071429
+ 0.79 0.71 0.79 15142857
+ 0.79 0.71 0.79 22214286
+ 0.79 0.71 0.79 29285714
+ 0.79 0.71 0.79 36357143
+ 0.79 0.71 0.79 43428571
+ 0.79 0.71 0.79 50500000
+ 0.79 0.71 0.79 57571429
+ 0.79 0.71 0.79 64642857
+ 0.79 0.71 0.79 71714286
+ 0.79 0.71 0.79 78785714
+ 0.79 0.71 0.79 85857143
+ 0.79 0.71 0.79 92928571
+ 0.79 0.71 0.79 100000000
+ 0.79 0.71 0.86 1000000
+ 0.79 0.71 0.86 8071429
+ 0.79 0.71 0.86 15142857
+ 0.79 0.71 0.86 22214286
+ 0.79 0.71 0.86 29285714
+ 0.79 0.71 0.86 36357143
+ 0.79 0.71 0.86 43428571
+ 0.79 0.71 0.86 50500000
+ 0.79 0.71 0.86 57571429
+ 0.79 0.71 0.86 64642857
+ 0.79 0.71 0.86 71714286
+ 0.79 0.71 0.86 78785714
+ 0.79 0.71 0.86 85857143
+ 0.79 0.71 0.86 92928571
+ 0.79 0.71 0.86 100000000
+ 0.79 0.71 0.93 1000000
+ 0.79 0.71 0.93 8071429
+ 0.79 0.71 0.93 15142857
+ 0.79 0.71 0.93 22214286
+ 0.79 0.71 0.93 29285714
+ 0.79 0.71 0.93 36357143
+ 0.79 0.71 0.93 43428571
+ 0.79 0.71 0.93 50500000
+ 0.79 0.71 0.93 57571429
+ 0.79 0.71 0.93 64642857
+ 0.79 0.71 0.93 71714286
+ 0.79 0.71 0.93 78785714
+ 0.79 0.71 0.93 85857143
+ 0.79 0.71 0.93 92928571
+ 0.79 0.71 0.93 100000000
+ 0.79 0.71 1.00 1000000
+ 0.79 0.71 1.00 8071429
+ 0.79 0.71 1.00 15142857
+ 0.79 0.71 1.00 22214286
+ 0.79 0.71 1.00 29285714
+ 0.79 0.71 1.00 36357143
+ 0.79 0.71 1.00 43428571
+ 0.79 0.71 1.00 50500000
+ 0.79 0.71 1.00 57571429
+ 0.79 0.71 1.00 64642857
+ 0.79 0.71 1.00 71714286
+ 0.79 0.71 1.00 78785714
+ 0.79 0.71 1.00 85857143
+ 0.79 0.71 1.00 92928571
+ 0.79 0.71 1.00 100000000
+ 0.79 0.79 0.00 1000000
+ 0.79 0.79 0.00 8071429
+ 0.79 0.79 0.00 15142857
+ 0.79 0.79 0.00 22214286
+ 0.79 0.79 0.00 29285714
+ 0.79 0.79 0.00 36357143
+ 0.79 0.79 0.00 43428571
+ 0.79 0.79 0.00 50500000
+ 0.79 0.79 0.00 57571429
+ 0.79 0.79 0.00 64642857
+ 0.79 0.79 0.00 71714286
+ 0.79 0.79 0.00 78785714
+ 0.79 0.79 0.00 85857143
+ 0.79 0.79 0.00 92928571
+ 0.79 0.79 0.00 100000000
+ 0.79 0.79 0.07 1000000
+ 0.79 0.79 0.07 8071429
+ 0.79 0.79 0.07 15142857
+ 0.79 0.79 0.07 22214286
+ 0.79 0.79 0.07 29285714
+ 0.79 0.79 0.07 36357143
+ 0.79 0.79 0.07 43428571
+ 0.79 0.79 0.07 50500000
+ 0.79 0.79 0.07 57571429
+ 0.79 0.79 0.07 64642857
+ 0.79 0.79 0.07 71714286
+ 0.79 0.79 0.07 78785714
+ 0.79 0.79 0.07 85857143
+ 0.79 0.79 0.07 92928571
+ 0.79 0.79 0.07 100000000
+ 0.79 0.79 0.14 1000000
+ 0.79 0.79 0.14 8071429
+ 0.79 0.79 0.14 15142857
+ 0.79 0.79 0.14 22214286
+ 0.79 0.79 0.14 29285714
+ 0.79 0.79 0.14 36357143
+ 0.79 0.79 0.14 43428571
+ 0.79 0.79 0.14 50500000
+ 0.79 0.79 0.14 57571429
+ 0.79 0.79 0.14 64642857
+ 0.79 0.79 0.14 71714286
+ 0.79 0.79 0.14 78785714
+ 0.79 0.79 0.14 85857143
+ 0.79 0.79 0.14 92928571
+ 0.79 0.79 0.14 100000000
+ 0.79 0.79 0.21 1000000
+ 0.79 0.79 0.21 8071429
+ 0.79 0.79 0.21 15142857
+ 0.79 0.79 0.21 22214286
+ 0.79 0.79 0.21 29285714
+ 0.79 0.79 0.21 36357143
+ 0.79 0.79 0.21 43428571
+ 0.79 0.79 0.21 50500000
+ 0.79 0.79 0.21 57571429
+ 0.79 0.79 0.21 64642857
+ 0.79 0.79 0.21 71714286
+ 0.79 0.79 0.21 78785714
+ 0.79 0.79 0.21 85857143
+ 0.79 0.79 0.21 92928571
+ 0.79 0.79 0.21 100000000
+ 0.79 0.79 0.29 1000000
+ 0.79 0.79 0.29 8071429
+ 0.79 0.79 0.29 15142857
+ 0.79 0.79 0.29 22214286
+ 0.79 0.79 0.29 29285714
+ 0.79 0.79 0.29 36357143
+ 0.79 0.79 0.29 43428571
+ 0.79 0.79 0.29 50500000
+ 0.79 0.79 0.29 57571429
+ 0.79 0.79 0.29 64642857
+ 0.79 0.79 0.29 71714286
+ 0.79 0.79 0.29 78785714
+ 0.79 0.79 0.29 85857143
+ 0.79 0.79 0.29 92928571
+ 0.79 0.79 0.29 100000000
+ 0.79 0.79 0.36 1000000
+ 0.79 0.79 0.36 8071429
+ 0.79 0.79 0.36 15142857
+ 0.79 0.79 0.36 22214286
+ 0.79 0.79 0.36 29285714
+ 0.79 0.79 0.36 36357143
+ 0.79 0.79 0.36 43428571
+ 0.79 0.79 0.36 50500000
+ 0.79 0.79 0.36 57571429
+ 0.79 0.79 0.36 64642857
+ 0.79 0.79 0.36 71714286
+ 0.79 0.79 0.36 78785714
+ 0.79 0.79 0.36 85857143
+ 0.79 0.79 0.36 92928571
+ 0.79 0.79 0.36 100000000
+ 0.79 0.79 0.43 1000000
+ 0.79 0.79 0.43 8071429
+ 0.79 0.79 0.43 15142857
+ 0.79 0.79 0.43 22214286
+ 0.79 0.79 0.43 29285714
+ 0.79 0.79 0.43 36357143
+ 0.79 0.79 0.43 43428571
+ 0.79 0.79 0.43 50500000
+ 0.79 0.79 0.43 57571429
+ 0.79 0.79 0.43 64642857
+ 0.79 0.79 0.43 71714286
+ 0.79 0.79 0.43 78785714
+ 0.79 0.79 0.43 85857143
+ 0.79 0.79 0.43 92928571
+ 0.79 0.79 0.43 100000000
+ 0.79 0.79 0.50 1000000
+ 0.79 0.79 0.50 8071429
+ 0.79 0.79 0.50 15142857
+ 0.79 0.79 0.50 22214286
+ 0.79 0.79 0.50 29285714
+ 0.79 0.79 0.50 36357143
+ 0.79 0.79 0.50 43428571
+ 0.79 0.79 0.50 50500000
+ 0.79 0.79 0.50 57571429
+ 0.79 0.79 0.50 64642857
+ 0.79 0.79 0.50 71714286
+ 0.79 0.79 0.50 78785714
+ 0.79 0.79 0.50 85857143
+ 0.79 0.79 0.50 92928571
+ 0.79 0.79 0.50 100000000
+ 0.79 0.79 0.57 1000000
+ 0.79 0.79 0.57 8071429
+ 0.79 0.79 0.57 15142857
+ 0.79 0.79 0.57 22214286
+ 0.79 0.79 0.57 29285714
+ 0.79 0.79 0.57 36357143
+ 0.79 0.79 0.57 43428571
+ 0.79 0.79 0.57 50500000
+ 0.79 0.79 0.57 57571429
+ 0.79 0.79 0.57 64642857
+ 0.79 0.79 0.57 71714286
+ 0.79 0.79 0.57 78785714
+ 0.79 0.79 0.57 85857143
+ 0.79 0.79 0.57 92928571
+ 0.79 0.79 0.57 100000000
+ 0.79 0.79 0.64 1000000
+ 0.79 0.79 0.64 8071429
+ 0.79 0.79 0.64 15142857
+ 0.79 0.79 0.64 22214286
+ 0.79 0.79 0.64 29285714
+ 0.79 0.79 0.64 36357143
+ 0.79 0.79 0.64 43428571
+ 0.79 0.79 0.64 50500000
+ 0.79 0.79 0.64 57571429
+ 0.79 0.79 0.64 64642857
+ 0.79 0.79 0.64 71714286
+ 0.79 0.79 0.64 78785714
+ 0.79 0.79 0.64 85857143
+ 0.79 0.79 0.64 92928571
+ 0.79 0.79 0.64 100000000
+ 0.79 0.79 0.71 1000000
+ 0.79 0.79 0.71 8071429
+ 0.79 0.79 0.71 15142857
+ 0.79 0.79 0.71 22214286
+ 0.79 0.79 0.71 29285714
+ 0.79 0.79 0.71 36357143
+ 0.79 0.79 0.71 43428571
+ 0.79 0.79 0.71 50500000
+ 0.79 0.79 0.71 57571429
+ 0.79 0.79 0.71 64642857
+ 0.79 0.79 0.71 71714286
+ 0.79 0.79 0.71 78785714
+ 0.79 0.79 0.71 85857143
+ 0.79 0.79 0.71 92928571
+ 0.79 0.79 0.71 100000000
+ 0.79 0.79 0.79 1000000
+ 0.79 0.79 0.79 8071429
+ 0.79 0.79 0.79 15142857
+ 0.79 0.79 0.79 22214286
+ 0.79 0.79 0.79 29285714
+ 0.79 0.79 0.79 36357143
+ 0.79 0.79 0.79 43428571
+ 0.79 0.79 0.79 50500000
+ 0.79 0.79 0.79 57571429
+ 0.79 0.79 0.79 64642857
+ 0.79 0.79 0.79 71714286
+ 0.79 0.79 0.79 78785714
+ 0.79 0.79 0.79 85857143
+ 0.79 0.79 0.79 92928571
+ 0.79 0.79 0.79 100000000
+ 0.79 0.79 0.86 1000000
+ 0.79 0.79 0.86 8071429
+ 0.79 0.79 0.86 15142857
+ 0.79 0.79 0.86 22214286
+ 0.79 0.79 0.86 29285714
+ 0.79 0.79 0.86 36357143
+ 0.79 0.79 0.86 43428571
+ 0.79 0.79 0.86 50500000
+ 0.79 0.79 0.86 57571429
+ 0.79 0.79 0.86 64642857
+ 0.79 0.79 0.86 71714286
+ 0.79 0.79 0.86 78785714
+ 0.79 0.79 0.86 85857143
+ 0.79 0.79 0.86 92928571
+ 0.79 0.79 0.86 100000000
+ 0.79 0.79 0.93 1000000
+ 0.79 0.79 0.93 8071429
+ 0.79 0.79 0.93 15142857
+ 0.79 0.79 0.93 22214286
+ 0.79 0.79 0.93 29285714
+ 0.79 0.79 0.93 36357143
+ 0.79 0.79 0.93 43428571
+ 0.79 0.79 0.93 50500000
+ 0.79 0.79 0.93 57571429
+ 0.79 0.79 0.93 64642857
+ 0.79 0.79 0.93 71714286
+ 0.79 0.79 0.93 78785714
+ 0.79 0.79 0.93 85857143
+ 0.79 0.79 0.93 92928571
+ 0.79 0.79 0.93 100000000
+ 0.79 0.79 1.00 1000000
+ 0.79 0.79 1.00 8071429
+ 0.79 0.79 1.00 15142857
+ 0.79 0.79 1.00 22214286
+ 0.79 0.79 1.00 29285714
+ 0.79 0.79 1.00 36357143
+ 0.79 0.79 1.00 43428571
+ 0.79 0.79 1.00 50500000
+ 0.79 0.79 1.00 57571429
+ 0.79 0.79 1.00 64642857
+ 0.79 0.79 1.00 71714286
+ 0.79 0.79 1.00 78785714
+ 0.79 0.79 1.00 85857143
+ 0.79 0.79 1.00 92928571
+ 0.79 0.79 1.00 100000000
+ 0.79 0.86 0.00 1000000
+ 0.79 0.86 0.00 8071429
+ 0.79 0.86 0.00 15142857
+ 0.79 0.86 0.00 22214286
+ 0.79 0.86 0.00 29285714
+ 0.79 0.86 0.00 36357143
+ 0.79 0.86 0.00 43428571
+ 0.79 0.86 0.00 50500000
+ 0.79 0.86 0.00 57571429
+ 0.79 0.86 0.00 64642857
+ 0.79 0.86 0.00 71714286
+ 0.79 0.86 0.00 78785714
+ 0.79 0.86 0.00 85857143
+ 0.79 0.86 0.00 92928571
+ 0.79 0.86 0.00 100000000
+ 0.79 0.86 0.07 1000000
+ 0.79 0.86 0.07 8071429
+ 0.79 0.86 0.07 15142857
+ 0.79 0.86 0.07 22214286
+ 0.79 0.86 0.07 29285714
+ 0.79 0.86 0.07 36357143
+ 0.79 0.86 0.07 43428571
+ 0.79 0.86 0.07 50500000
+ 0.79 0.86 0.07 57571429
+ 0.79 0.86 0.07 64642857
+ 0.79 0.86 0.07 71714286
+ 0.79 0.86 0.07 78785714
+ 0.79 0.86 0.07 85857143
+ 0.79 0.86 0.07 92928571
+ 0.79 0.86 0.07 100000000
+ 0.79 0.86 0.14 1000000
+ 0.79 0.86 0.14 8071429
+ 0.79 0.86 0.14 15142857
+ 0.79 0.86 0.14 22214286
+ 0.79 0.86 0.14 29285714
+ 0.79 0.86 0.14 36357143
+ 0.79 0.86 0.14 43428571
+ 0.79 0.86 0.14 50500000
+ 0.79 0.86 0.14 57571429
+ 0.79 0.86 0.14 64642857
+ 0.79 0.86 0.14 71714286
+ 0.79 0.86 0.14 78785714
+ 0.79 0.86 0.14 85857143
+ 0.79 0.86 0.14 92928571
+ 0.79 0.86 0.14 100000000
+ 0.79 0.86 0.21 1000000
+ 0.79 0.86 0.21 8071429
+ 0.79 0.86 0.21 15142857
+ 0.79 0.86 0.21 22214286
+ 0.79 0.86 0.21 29285714
+ 0.79 0.86 0.21 36357143
+ 0.79 0.86 0.21 43428571
+ 0.79 0.86 0.21 50500000
+ 0.79 0.86 0.21 57571429
+ 0.79 0.86 0.21 64642857
+ 0.79 0.86 0.21 71714286
+ 0.79 0.86 0.21 78785714
+ 0.79 0.86 0.21 85857143
+ 0.79 0.86 0.21 92928571
+ 0.79 0.86 0.21 100000000
+ 0.79 0.86 0.29 1000000
+ 0.79 0.86 0.29 8071429
+ 0.79 0.86 0.29 15142857
+ 0.79 0.86 0.29 22214286
+ 0.79 0.86 0.29 29285714
+ 0.79 0.86 0.29 36357143
+ 0.79 0.86 0.29 43428571
+ 0.79 0.86 0.29 50500000
+ 0.79 0.86 0.29 57571429
+ 0.79 0.86 0.29 64642857
+ 0.79 0.86 0.29 71714286
+ 0.79 0.86 0.29 78785714
+ 0.79 0.86 0.29 85857143
+ 0.79 0.86 0.29 92928571
+ 0.79 0.86 0.29 100000000
+ 0.79 0.86 0.36 1000000
+ 0.79 0.86 0.36 8071429
+ 0.79 0.86 0.36 15142857
+ 0.79 0.86 0.36 22214286
+ 0.79 0.86 0.36 29285714
+ 0.79 0.86 0.36 36357143
+ 0.79 0.86 0.36 43428571
+ 0.79 0.86 0.36 50500000
+ 0.79 0.86 0.36 57571429
+ 0.79 0.86 0.36 64642857
+ 0.79 0.86 0.36 71714286
+ 0.79 0.86 0.36 78785714
+ 0.79 0.86 0.36 85857143
+ 0.79 0.86 0.36 92928571
+ 0.79 0.86 0.36 100000000
+ 0.79 0.86 0.43 1000000
+ 0.79 0.86 0.43 8071429
+ 0.79 0.86 0.43 15142857
+ 0.79 0.86 0.43 22214286
+ 0.79 0.86 0.43 29285714
+ 0.79 0.86 0.43 36357143
+ 0.79 0.86 0.43 43428571
+ 0.79 0.86 0.43 50500000
+ 0.79 0.86 0.43 57571429
+ 0.79 0.86 0.43 64642857
+ 0.79 0.86 0.43 71714286
+ 0.79 0.86 0.43 78785714
+ 0.79 0.86 0.43 85857143
+ 0.79 0.86 0.43 92928571
+ 0.79 0.86 0.43 100000000
+ 0.79 0.86 0.50 1000000
+ 0.79 0.86 0.50 8071429
+ 0.79 0.86 0.50 15142857
+ 0.79 0.86 0.50 22214286
+ 0.79 0.86 0.50 29285714
+ 0.79 0.86 0.50 36357143
+ 0.79 0.86 0.50 43428571
+ 0.79 0.86 0.50 50500000
+ 0.79 0.86 0.50 57571429
+ 0.79 0.86 0.50 64642857
+ 0.79 0.86 0.50 71714286
+ 0.79 0.86 0.50 78785714
+ 0.79 0.86 0.50 85857143
+ 0.79 0.86 0.50 92928571
+ 0.79 0.86 0.50 100000000
+ 0.79 0.86 0.57 1000000
+ 0.79 0.86 0.57 8071429
+ 0.79 0.86 0.57 15142857
+ 0.79 0.86 0.57 22214286
+ 0.79 0.86 0.57 29285714
+ 0.79 0.86 0.57 36357143
+ 0.79 0.86 0.57 43428571
+ 0.79 0.86 0.57 50500000
+ 0.79 0.86 0.57 57571429
+ 0.79 0.86 0.57 64642857
+ 0.79 0.86 0.57 71714286
+ 0.79 0.86 0.57 78785714
+ 0.79 0.86 0.57 85857143
+ 0.79 0.86 0.57 92928571
+ 0.79 0.86 0.57 100000000
+ 0.79 0.86 0.64 1000000
+ 0.79 0.86 0.64 8071429
+ 0.79 0.86 0.64 15142857
+ 0.79 0.86 0.64 22214286
+ 0.79 0.86 0.64 29285714
+ 0.79 0.86 0.64 36357143
+ 0.79 0.86 0.64 43428571
+ 0.79 0.86 0.64 50500000
+ 0.79 0.86 0.64 57571429
+ 0.79 0.86 0.64 64642857
+ 0.79 0.86 0.64 71714286
+ 0.79 0.86 0.64 78785714
+ 0.79 0.86 0.64 85857143
+ 0.79 0.86 0.64 92928571
+ 0.79 0.86 0.64 100000000
+ 0.79 0.86 0.71 1000000
+ 0.79 0.86 0.71 8071429
+ 0.79 0.86 0.71 15142857
+ 0.79 0.86 0.71 22214286
+ 0.79 0.86 0.71 29285714
+ 0.79 0.86 0.71 36357143
+ 0.79 0.86 0.71 43428571
+ 0.79 0.86 0.71 50500000
+ 0.79 0.86 0.71 57571429
+ 0.79 0.86 0.71 64642857
+ 0.79 0.86 0.71 71714286
+ 0.79 0.86 0.71 78785714
+ 0.79 0.86 0.71 85857143
+ 0.79 0.86 0.71 92928571
+ 0.79 0.86 0.71 100000000
+ 0.79 0.86 0.79 1000000
+ 0.79 0.86 0.79 8071429
+ 0.79 0.86 0.79 15142857
+ 0.79 0.86 0.79 22214286
+ 0.79 0.86 0.79 29285714
+ 0.79 0.86 0.79 36357143
+ 0.79 0.86 0.79 43428571
+ 0.79 0.86 0.79 50500000
+ 0.79 0.86 0.79 57571429
+ 0.79 0.86 0.79 64642857
+ 0.79 0.86 0.79 71714286
+ 0.79 0.86 0.79 78785714
+ 0.79 0.86 0.79 85857143
+ 0.79 0.86 0.79 92928571
+ 0.79 0.86 0.79 100000000
+ 0.79 0.86 0.86 1000000
+ 0.79 0.86 0.86 8071429
+ 0.79 0.86 0.86 15142857
+ 0.79 0.86 0.86 22214286
+ 0.79 0.86 0.86 29285714
+ 0.79 0.86 0.86 36357143
+ 0.79 0.86 0.86 43428571
+ 0.79 0.86 0.86 50500000
+ 0.79 0.86 0.86 57571429
+ 0.79 0.86 0.86 64642857
+ 0.79 0.86 0.86 71714286
+ 0.79 0.86 0.86 78785714
+ 0.79 0.86 0.86 85857143
+ 0.79 0.86 0.86 92928571
+ 0.79 0.86 0.86 100000000
+ 0.79 0.86 0.93 1000000
+ 0.79 0.86 0.93 8071429
+ 0.79 0.86 0.93 15142857
+ 0.79 0.86 0.93 22214286
+ 0.79 0.86 0.93 29285714
+ 0.79 0.86 0.93 36357143
+ 0.79 0.86 0.93 43428571
+ 0.79 0.86 0.93 50500000
+ 0.79 0.86 0.93 57571429
+ 0.79 0.86 0.93 64642857
+ 0.79 0.86 0.93 71714286
+ 0.79 0.86 0.93 78785714
+ 0.79 0.86 0.93 85857143
+ 0.79 0.86 0.93 92928571
+ 0.79 0.86 0.93 100000000
+ 0.79 0.86 1.00 1000000
+ 0.79 0.86 1.00 8071429
+ 0.79 0.86 1.00 15142857
+ 0.79 0.86 1.00 22214286
+ 0.79 0.86 1.00 29285714
+ 0.79 0.86 1.00 36357143
+ 0.79 0.86 1.00 43428571
+ 0.79 0.86 1.00 50500000
+ 0.79 0.86 1.00 57571429
+ 0.79 0.86 1.00 64642857
+ 0.79 0.86 1.00 71714286
+ 0.79 0.86 1.00 78785714
+ 0.79 0.86 1.00 85857143
+ 0.79 0.86 1.00 92928571
+ 0.79 0.86 1.00 100000000
+ 0.79 0.93 0.00 1000000
+ 0.79 0.93 0.00 8071429
+ 0.79 0.93 0.00 15142857
+ 0.79 0.93 0.00 22214286
+ 0.79 0.93 0.00 29285714
+ 0.79 0.93 0.00 36357143
+ 0.79 0.93 0.00 43428571
+ 0.79 0.93 0.00 50500000
+ 0.79 0.93 0.00 57571429
+ 0.79 0.93 0.00 64642857
+ 0.79 0.93 0.00 71714286
+ 0.79 0.93 0.00 78785714
+ 0.79 0.93 0.00 85857143
+ 0.79 0.93 0.00 92928571
+ 0.79 0.93 0.00 100000000
+ 0.79 0.93 0.07 1000000
+ 0.79 0.93 0.07 8071429
+ 0.79 0.93 0.07 15142857
+ 0.79 0.93 0.07 22214286
+ 0.79 0.93 0.07 29285714
+ 0.79 0.93 0.07 36357143
+ 0.79 0.93 0.07 43428571
+ 0.79 0.93 0.07 50500000
+ 0.79 0.93 0.07 57571429
+ 0.79 0.93 0.07 64642857
+ 0.79 0.93 0.07 71714286
+ 0.79 0.93 0.07 78785714
+ 0.79 0.93 0.07 85857143
+ 0.79 0.93 0.07 92928571
+ 0.79 0.93 0.07 100000000
+ 0.79 0.93 0.14 1000000
+ 0.79 0.93 0.14 8071429
+ 0.79 0.93 0.14 15142857
+ 0.79 0.93 0.14 22214286
+ 0.79 0.93 0.14 29285714
+ 0.79 0.93 0.14 36357143
+ 0.79 0.93 0.14 43428571
+ 0.79 0.93 0.14 50500000
+ 0.79 0.93 0.14 57571429
+ 0.79 0.93 0.14 64642857
+ 0.79 0.93 0.14 71714286
+ 0.79 0.93 0.14 78785714
+ 0.79 0.93 0.14 85857143
+ 0.79 0.93 0.14 92928571
+ 0.79 0.93 0.14 100000000
+ 0.79 0.93 0.21 1000000
+ 0.79 0.93 0.21 8071429
+ 0.79 0.93 0.21 15142857
+ 0.79 0.93 0.21 22214286
+ 0.79 0.93 0.21 29285714
+ 0.79 0.93 0.21 36357143
+ 0.79 0.93 0.21 43428571
+ 0.79 0.93 0.21 50500000
+ 0.79 0.93 0.21 57571429
+ 0.79 0.93 0.21 64642857
+ 0.79 0.93 0.21 71714286
+ 0.79 0.93 0.21 78785714
+ 0.79 0.93 0.21 85857143
+ 0.79 0.93 0.21 92928571
+ 0.79 0.93 0.21 100000000
+ 0.79 0.93 0.29 1000000
+ 0.79 0.93 0.29 8071429
+ 0.79 0.93 0.29 15142857
+ 0.79 0.93 0.29 22214286
+ 0.79 0.93 0.29 29285714
+ 0.79 0.93 0.29 36357143
+ 0.79 0.93 0.29 43428571
+ 0.79 0.93 0.29 50500000
+ 0.79 0.93 0.29 57571429
+ 0.79 0.93 0.29 64642857
+ 0.79 0.93 0.29 71714286
+ 0.79 0.93 0.29 78785714
+ 0.79 0.93 0.29 85857143
+ 0.79 0.93 0.29 92928571
+ 0.79 0.93 0.29 100000000
+ 0.79 0.93 0.36 1000000
+ 0.79 0.93 0.36 8071429
+ 0.79 0.93 0.36 15142857
+ 0.79 0.93 0.36 22214286
+ 0.79 0.93 0.36 29285714
+ 0.79 0.93 0.36 36357143
+ 0.79 0.93 0.36 43428571
+ 0.79 0.93 0.36 50500000
+ 0.79 0.93 0.36 57571429
+ 0.79 0.93 0.36 64642857
+ 0.79 0.93 0.36 71714286
+ 0.79 0.93 0.36 78785714
+ 0.79 0.93 0.36 85857143
+ 0.79 0.93 0.36 92928571
+ 0.79 0.93 0.36 100000000
+ 0.79 0.93 0.43 1000000
+ 0.79 0.93 0.43 8071429
+ 0.79 0.93 0.43 15142857
+ 0.79 0.93 0.43 22214286
+ 0.79 0.93 0.43 29285714
+ 0.79 0.93 0.43 36357143
+ 0.79 0.93 0.43 43428571
+ 0.79 0.93 0.43 50500000
+ 0.79 0.93 0.43 57571429
+ 0.79 0.93 0.43 64642857
+ 0.79 0.93 0.43 71714286
+ 0.79 0.93 0.43 78785714
+ 0.79 0.93 0.43 85857143
+ 0.79 0.93 0.43 92928571
+ 0.79 0.93 0.43 100000000
+ 0.79 0.93 0.50 1000000
+ 0.79 0.93 0.50 8071429
+ 0.79 0.93 0.50 15142857
+ 0.79 0.93 0.50 22214286
+ 0.79 0.93 0.50 29285714
+ 0.79 0.93 0.50 36357143
+ 0.79 0.93 0.50 43428571
+ 0.79 0.93 0.50 50500000
+ 0.79 0.93 0.50 57571429
+ 0.79 0.93 0.50 64642857
+ 0.79 0.93 0.50 71714286
+ 0.79 0.93 0.50 78785714
+ 0.79 0.93 0.50 85857143
+ 0.79 0.93 0.50 92928571
+ 0.79 0.93 0.50 100000000
+ 0.79 0.93 0.57 1000000
+ 0.79 0.93 0.57 8071429
+ 0.79 0.93 0.57 15142857
+ 0.79 0.93 0.57 22214286
+ 0.79 0.93 0.57 29285714
+ 0.79 0.93 0.57 36357143
+ 0.79 0.93 0.57 43428571
+ 0.79 0.93 0.57 50500000
+ 0.79 0.93 0.57 57571429
+ 0.79 0.93 0.57 64642857
+ 0.79 0.93 0.57 71714286
+ 0.79 0.93 0.57 78785714
+ 0.79 0.93 0.57 85857143
+ 0.79 0.93 0.57 92928571
+ 0.79 0.93 0.57 100000000
+ 0.79 0.93 0.64 1000000
+ 0.79 0.93 0.64 8071429
+ 0.79 0.93 0.64 15142857
+ 0.79 0.93 0.64 22214286
+ 0.79 0.93 0.64 29285714
+ 0.79 0.93 0.64 36357143
+ 0.79 0.93 0.64 43428571
+ 0.79 0.93 0.64 50500000
+ 0.79 0.93 0.64 57571429
+ 0.79 0.93 0.64 64642857
+ 0.79 0.93 0.64 71714286
+ 0.79 0.93 0.64 78785714
+ 0.79 0.93 0.64 85857143
+ 0.79 0.93 0.64 92928571
+ 0.79 0.93 0.64 100000000
+ 0.79 0.93 0.71 1000000
+ 0.79 0.93 0.71 8071429
+ 0.79 0.93 0.71 15142857
+ 0.79 0.93 0.71 22214286
+ 0.79 0.93 0.71 29285714
+ 0.79 0.93 0.71 36357143
+ 0.79 0.93 0.71 43428571
+ 0.79 0.93 0.71 50500000
+ 0.79 0.93 0.71 57571429
+ 0.79 0.93 0.71 64642857
+ 0.79 0.93 0.71 71714286
+ 0.79 0.93 0.71 78785714
+ 0.79 0.93 0.71 85857143
+ 0.79 0.93 0.71 92928571
+ 0.79 0.93 0.71 100000000
+ 0.79 0.93 0.79 1000000
+ 0.79 0.93 0.79 8071429
+ 0.79 0.93 0.79 15142857
+ 0.79 0.93 0.79 22214286
+ 0.79 0.93 0.79 29285714
+ 0.79 0.93 0.79 36357143
+ 0.79 0.93 0.79 43428571
+ 0.79 0.93 0.79 50500000
+ 0.79 0.93 0.79 57571429
+ 0.79 0.93 0.79 64642857
+ 0.79 0.93 0.79 71714286
+ 0.79 0.93 0.79 78785714
+ 0.79 0.93 0.79 85857143
+ 0.79 0.93 0.79 92928571
+ 0.79 0.93 0.79 100000000
+ 0.79 0.93 0.86 1000000
+ 0.79 0.93 0.86 8071429
+ 0.79 0.93 0.86 15142857
+ 0.79 0.93 0.86 22214286
+ 0.79 0.93 0.86 29285714
+ 0.79 0.93 0.86 36357143
+ 0.79 0.93 0.86 43428571
+ 0.79 0.93 0.86 50500000
+ 0.79 0.93 0.86 57571429
+ 0.79 0.93 0.86 64642857
+ 0.79 0.93 0.86 71714286
+ 0.79 0.93 0.86 78785714
+ 0.79 0.93 0.86 85857143
+ 0.79 0.93 0.86 92928571
+ 0.79 0.93 0.86 100000000
+ 0.79 0.93 0.93 1000000
+ 0.79 0.93 0.93 8071429
+ 0.79 0.93 0.93 15142857
+ 0.79 0.93 0.93 22214286
+ 0.79 0.93 0.93 29285714
+ 0.79 0.93 0.93 36357143
+ 0.79 0.93 0.93 43428571
+ 0.79 0.93 0.93 50500000
+ 0.79 0.93 0.93 57571429
+ 0.79 0.93 0.93 64642857
+ 0.79 0.93 0.93 71714286
+ 0.79 0.93 0.93 78785714
+ 0.79 0.93 0.93 85857143
+ 0.79 0.93 0.93 92928571
+ 0.79 0.93 0.93 100000000
+ 0.79 0.93 1.00 1000000
+ 0.79 0.93 1.00 8071429
+ 0.79 0.93 1.00 15142857
+ 0.79 0.93 1.00 22214286
+ 0.79 0.93 1.00 29285714
+ 0.79 0.93 1.00 36357143
+ 0.79 0.93 1.00 43428571
+ 0.79 0.93 1.00 50500000
+ 0.79 0.93 1.00 57571429
+ 0.79 0.93 1.00 64642857
+ 0.79 0.93 1.00 71714286
+ 0.79 0.93 1.00 78785714
+ 0.79 0.93 1.00 85857143
+ 0.79 0.93 1.00 92928571
+ 0.79 0.93 1.00 100000000
+ 0.79 1.00 0.00 1000000
+ 0.79 1.00 0.00 8071429
+ 0.79 1.00 0.00 15142857
+ 0.79 1.00 0.00 22214286
+ 0.79 1.00 0.00 29285714
+ 0.79 1.00 0.00 36357143
+ 0.79 1.00 0.00 43428571
+ 0.79 1.00 0.00 50500000
+ 0.79 1.00 0.00 57571429
+ 0.79 1.00 0.00 64642857
+ 0.79 1.00 0.00 71714286
+ 0.79 1.00 0.00 78785714
+ 0.79 1.00 0.00 85857143
+ 0.79 1.00 0.00 92928571
+ 0.79 1.00 0.00 100000000
+ 0.79 1.00 0.07 1000000
+ 0.79 1.00 0.07 8071429
+ 0.79 1.00 0.07 15142857
+ 0.79 1.00 0.07 22214286
+ 0.79 1.00 0.07 29285714
+ 0.79 1.00 0.07 36357143
+ 0.79 1.00 0.07 43428571
+ 0.79 1.00 0.07 50500000
+ 0.79 1.00 0.07 57571429
+ 0.79 1.00 0.07 64642857
+ 0.79 1.00 0.07 71714286
+ 0.79 1.00 0.07 78785714
+ 0.79 1.00 0.07 85857143
+ 0.79 1.00 0.07 92928571
+ 0.79 1.00 0.07 100000000
+ 0.79 1.00 0.14 1000000
+ 0.79 1.00 0.14 8071429
+ 0.79 1.00 0.14 15142857
+ 0.79 1.00 0.14 22214286
+ 0.79 1.00 0.14 29285714
+ 0.79 1.00 0.14 36357143
+ 0.79 1.00 0.14 43428571
+ 0.79 1.00 0.14 50500000
+ 0.79 1.00 0.14 57571429
+ 0.79 1.00 0.14 64642857
+ 0.79 1.00 0.14 71714286
+ 0.79 1.00 0.14 78785714
+ 0.79 1.00 0.14 85857143
+ 0.79 1.00 0.14 92928571
+ 0.79 1.00 0.14 100000000
+ 0.79 1.00 0.21 1000000
+ 0.79 1.00 0.21 8071429
+ 0.79 1.00 0.21 15142857
+ 0.79 1.00 0.21 22214286
+ 0.79 1.00 0.21 29285714
+ 0.79 1.00 0.21 36357143
+ 0.79 1.00 0.21 43428571
+ 0.79 1.00 0.21 50500000
+ 0.79 1.00 0.21 57571429
+ 0.79 1.00 0.21 64642857
+ 0.79 1.00 0.21 71714286
+ 0.79 1.00 0.21 78785714
+ 0.79 1.00 0.21 85857143
+ 0.79 1.00 0.21 92928571
+ 0.79 1.00 0.21 100000000
+ 0.79 1.00 0.29 1000000
+ 0.79 1.00 0.29 8071429
+ 0.79 1.00 0.29 15142857
+ 0.79 1.00 0.29 22214286
+ 0.79 1.00 0.29 29285714
+ 0.79 1.00 0.29 36357143
+ 0.79 1.00 0.29 43428571
+ 0.79 1.00 0.29 50500000
+ 0.79 1.00 0.29 57571429
+ 0.79 1.00 0.29 64642857
+ 0.79 1.00 0.29 71714286
+ 0.79 1.00 0.29 78785714
+ 0.79 1.00 0.29 85857143
+ 0.79 1.00 0.29 92928571
+ 0.79 1.00 0.29 100000000
+ 0.79 1.00 0.36 1000000
+ 0.79 1.00 0.36 8071429
+ 0.79 1.00 0.36 15142857
+ 0.79 1.00 0.36 22214286
+ 0.79 1.00 0.36 29285714
+ 0.79 1.00 0.36 36357143
+ 0.79 1.00 0.36 43428571
+ 0.79 1.00 0.36 50500000
+ 0.79 1.00 0.36 57571429
+ 0.79 1.00 0.36 64642857
+ 0.79 1.00 0.36 71714286
+ 0.79 1.00 0.36 78785714
+ 0.79 1.00 0.36 85857143
+ 0.79 1.00 0.36 92928571
+ 0.79 1.00 0.36 100000000
+ 0.79 1.00 0.43 1000000
+ 0.79 1.00 0.43 8071429
+ 0.79 1.00 0.43 15142857
+ 0.79 1.00 0.43 22214286
+ 0.79 1.00 0.43 29285714
+ 0.79 1.00 0.43 36357143
+ 0.79 1.00 0.43 43428571
+ 0.79 1.00 0.43 50500000
+ 0.79 1.00 0.43 57571429
+ 0.79 1.00 0.43 64642857
+ 0.79 1.00 0.43 71714286
+ 0.79 1.00 0.43 78785714
+ 0.79 1.00 0.43 85857143
+ 0.79 1.00 0.43 92928571
+ 0.79 1.00 0.43 100000000
+ 0.79 1.00 0.50 1000000
+ 0.79 1.00 0.50 8071429
+ 0.79 1.00 0.50 15142857
+ 0.79 1.00 0.50 22214286
+ 0.79 1.00 0.50 29285714
+ 0.79 1.00 0.50 36357143
+ 0.79 1.00 0.50 43428571
+ 0.79 1.00 0.50 50500000
+ 0.79 1.00 0.50 57571429
+ 0.79 1.00 0.50 64642857
+ 0.79 1.00 0.50 71714286
+ 0.79 1.00 0.50 78785714
+ 0.79 1.00 0.50 85857143
+ 0.79 1.00 0.50 92928571
+ 0.79 1.00 0.50 100000000
+ 0.79 1.00 0.57 1000000
+ 0.79 1.00 0.57 8071429
+ 0.79 1.00 0.57 15142857
+ 0.79 1.00 0.57 22214286
+ 0.79 1.00 0.57 29285714
+ 0.79 1.00 0.57 36357143
+ 0.79 1.00 0.57 43428571
+ 0.79 1.00 0.57 50500000
+ 0.79 1.00 0.57 57571429
+ 0.79 1.00 0.57 64642857
+ 0.79 1.00 0.57 71714286
+ 0.79 1.00 0.57 78785714
+ 0.79 1.00 0.57 85857143
+ 0.79 1.00 0.57 92928571
+ 0.79 1.00 0.57 100000000
+ 0.79 1.00 0.64 1000000
+ 0.79 1.00 0.64 8071429
+ 0.79 1.00 0.64 15142857
+ 0.79 1.00 0.64 22214286
+ 0.79 1.00 0.64 29285714
+ 0.79 1.00 0.64 36357143
+ 0.79 1.00 0.64 43428571
+ 0.79 1.00 0.64 50500000
+ 0.79 1.00 0.64 57571429
+ 0.79 1.00 0.64 64642857
+ 0.79 1.00 0.64 71714286
+ 0.79 1.00 0.64 78785714
+ 0.79 1.00 0.64 85857143
+ 0.79 1.00 0.64 92928571
+ 0.79 1.00 0.64 100000000
+ 0.79 1.00 0.71 1000000
+ 0.79 1.00 0.71 8071429
+ 0.79 1.00 0.71 15142857
+ 0.79 1.00 0.71 22214286
+ 0.79 1.00 0.71 29285714
+ 0.79 1.00 0.71 36357143
+ 0.79 1.00 0.71 43428571
+ 0.79 1.00 0.71 50500000
+ 0.79 1.00 0.71 57571429
+ 0.79 1.00 0.71 64642857
+ 0.79 1.00 0.71 71714286
+ 0.79 1.00 0.71 78785714
+ 0.79 1.00 0.71 85857143
+ 0.79 1.00 0.71 92928571
+ 0.79 1.00 0.71 100000000
+ 0.79 1.00 0.79 1000000
+ 0.79 1.00 0.79 8071429
+ 0.79 1.00 0.79 15142857
+ 0.79 1.00 0.79 22214286
+ 0.79 1.00 0.79 29285714
+ 0.79 1.00 0.79 36357143
+ 0.79 1.00 0.79 43428571
+ 0.79 1.00 0.79 50500000
+ 0.79 1.00 0.79 57571429
+ 0.79 1.00 0.79 64642857
+ 0.79 1.00 0.79 71714286
+ 0.79 1.00 0.79 78785714
+ 0.79 1.00 0.79 85857143
+ 0.79 1.00 0.79 92928571
+ 0.79 1.00 0.79 100000000
+ 0.79 1.00 0.86 1000000
+ 0.79 1.00 0.86 8071429
+ 0.79 1.00 0.86 15142857
+ 0.79 1.00 0.86 22214286
+ 0.79 1.00 0.86 29285714
+ 0.79 1.00 0.86 36357143
+ 0.79 1.00 0.86 43428571
+ 0.79 1.00 0.86 50500000
+ 0.79 1.00 0.86 57571429
+ 0.79 1.00 0.86 64642857
+ 0.79 1.00 0.86 71714286
+ 0.79 1.00 0.86 78785714
+ 0.79 1.00 0.86 85857143
+ 0.79 1.00 0.86 92928571
+ 0.79 1.00 0.86 100000000
+ 0.79 1.00 0.93 1000000
+ 0.79 1.00 0.93 8071429
+ 0.79 1.00 0.93 15142857
+ 0.79 1.00 0.93 22214286
+ 0.79 1.00 0.93 29285714
+ 0.79 1.00 0.93 36357143
+ 0.79 1.00 0.93 43428571
+ 0.79 1.00 0.93 50500000
+ 0.79 1.00 0.93 57571429
+ 0.79 1.00 0.93 64642857
+ 0.79 1.00 0.93 71714286
+ 0.79 1.00 0.93 78785714
+ 0.79 1.00 0.93 85857143
+ 0.79 1.00 0.93 92928571
+ 0.79 1.00 0.93 100000000
+ 0.79 1.00 1.00 1000000
+ 0.79 1.00 1.00 8071429
+ 0.79 1.00 1.00 15142857
+ 0.79 1.00 1.00 22214286
+ 0.79 1.00 1.00 29285714
+ 0.79 1.00 1.00 36357143
+ 0.79 1.00 1.00 43428571
+ 0.79 1.00 1.00 50500000
+ 0.79 1.00 1.00 57571429
+ 0.79 1.00 1.00 64642857
+ 0.79 1.00 1.00 71714286
+ 0.79 1.00 1.00 78785714
+ 0.79 1.00 1.00 85857143
+ 0.79 1.00 1.00 92928571
+ 0.79 1.00 1.00 100000000
+ 0.86 0.00 0.00 1000000
+ 0.86 0.00 0.00 8071429
+ 0.86 0.00 0.00 15142857
+ 0.86 0.00 0.00 22214286
+ 0.86 0.00 0.00 29285714
+ 0.86 0.00 0.00 36357143
+ 0.86 0.00 0.00 43428571
+ 0.86 0.00 0.00 50500000
+ 0.86 0.00 0.00 57571429
+ 0.86 0.00 0.00 64642857
+ 0.86 0.00 0.00 71714286
+ 0.86 0.00 0.00 78785714
+ 0.86 0.00 0.00 85857143
+ 0.86 0.00 0.00 92928571
+ 0.86 0.00 0.00 100000000
+ 0.86 0.00 0.07 1000000
+ 0.86 0.00 0.07 8071429
+ 0.86 0.00 0.07 15142857
+ 0.86 0.00 0.07 22214286
+ 0.86 0.00 0.07 29285714
+ 0.86 0.00 0.07 36357143
+ 0.86 0.00 0.07 43428571
+ 0.86 0.00 0.07 50500000
+ 0.86 0.00 0.07 57571429
+ 0.86 0.00 0.07 64642857
+ 0.86 0.00 0.07 71714286
+ 0.86 0.00 0.07 78785714
+ 0.86 0.00 0.07 85857143
+ 0.86 0.00 0.07 92928571
+ 0.86 0.00 0.07 100000000
+ 0.86 0.00 0.14 1000000
+ 0.86 0.00 0.14 8071429
+ 0.86 0.00 0.14 15142857
+ 0.86 0.00 0.14 22214286
+ 0.86 0.00 0.14 29285714
+ 0.86 0.00 0.14 36357143
+ 0.86 0.00 0.14 43428571
+ 0.86 0.00 0.14 50500000
+ 0.86 0.00 0.14 57571429
+ 0.86 0.00 0.14 64642857
+ 0.86 0.00 0.14 71714286
+ 0.86 0.00 0.14 78785714
+ 0.86 0.00 0.14 85857143
+ 0.86 0.00 0.14 92928571
+ 0.86 0.00 0.14 100000000
+ 0.86 0.00 0.21 1000000
+ 0.86 0.00 0.21 8071429
+ 0.86 0.00 0.21 15142857
+ 0.86 0.00 0.21 22214286
+ 0.86 0.00 0.21 29285714
+ 0.86 0.00 0.21 36357143
+ 0.86 0.00 0.21 43428571
+ 0.86 0.00 0.21 50500000
+ 0.86 0.00 0.21 57571429
+ 0.86 0.00 0.21 64642857
+ 0.86 0.00 0.21 71714286
+ 0.86 0.00 0.21 78785714
+ 0.86 0.00 0.21 85857143
+ 0.86 0.00 0.21 92928571
+ 0.86 0.00 0.21 100000000
+ 0.86 0.00 0.29 1000000
+ 0.86 0.00 0.29 8071429
+ 0.86 0.00 0.29 15142857
+ 0.86 0.00 0.29 22214286
+ 0.86 0.00 0.29 29285714
+ 0.86 0.00 0.29 36357143
+ 0.86 0.00 0.29 43428571
+ 0.86 0.00 0.29 50500000
+ 0.86 0.00 0.29 57571429
+ 0.86 0.00 0.29 64642857
+ 0.86 0.00 0.29 71714286
+ 0.86 0.00 0.29 78785714
+ 0.86 0.00 0.29 85857143
+ 0.86 0.00 0.29 92928571
+ 0.86 0.00 0.29 100000000
+ 0.86 0.00 0.36 1000000
+ 0.86 0.00 0.36 8071429
+ 0.86 0.00 0.36 15142857
+ 0.86 0.00 0.36 22214286
+ 0.86 0.00 0.36 29285714
+ 0.86 0.00 0.36 36357143
+ 0.86 0.00 0.36 43428571
+ 0.86 0.00 0.36 50500000
+ 0.86 0.00 0.36 57571429
+ 0.86 0.00 0.36 64642857
+ 0.86 0.00 0.36 71714286
+ 0.86 0.00 0.36 78785714
+ 0.86 0.00 0.36 85857143
+ 0.86 0.00 0.36 92928571
+ 0.86 0.00 0.36 100000000
+ 0.86 0.00 0.43 1000000
+ 0.86 0.00 0.43 8071429
+ 0.86 0.00 0.43 15142857
+ 0.86 0.00 0.43 22214286
+ 0.86 0.00 0.43 29285714
+ 0.86 0.00 0.43 36357143
+ 0.86 0.00 0.43 43428571
+ 0.86 0.00 0.43 50500000
+ 0.86 0.00 0.43 57571429
+ 0.86 0.00 0.43 64642857
+ 0.86 0.00 0.43 71714286
+ 0.86 0.00 0.43 78785714
+ 0.86 0.00 0.43 85857143
+ 0.86 0.00 0.43 92928571
+ 0.86 0.00 0.43 100000000
+ 0.86 0.00 0.50 1000000
+ 0.86 0.00 0.50 8071429
+ 0.86 0.00 0.50 15142857
+ 0.86 0.00 0.50 22214286
+ 0.86 0.00 0.50 29285714
+ 0.86 0.00 0.50 36357143
+ 0.86 0.00 0.50 43428571
+ 0.86 0.00 0.50 50500000
+ 0.86 0.00 0.50 57571429
+ 0.86 0.00 0.50 64642857
+ 0.86 0.00 0.50 71714286
+ 0.86 0.00 0.50 78785714
+ 0.86 0.00 0.50 85857143
+ 0.86 0.00 0.50 92928571
+ 0.86 0.00 0.50 100000000
+ 0.86 0.00 0.57 1000000
+ 0.86 0.00 0.57 8071429
+ 0.86 0.00 0.57 15142857
+ 0.86 0.00 0.57 22214286
+ 0.86 0.00 0.57 29285714
+ 0.86 0.00 0.57 36357143
+ 0.86 0.00 0.57 43428571
+ 0.86 0.00 0.57 50500000
+ 0.86 0.00 0.57 57571429
+ 0.86 0.00 0.57 64642857
+ 0.86 0.00 0.57 71714286
+ 0.86 0.00 0.57 78785714
+ 0.86 0.00 0.57 85857143
+ 0.86 0.00 0.57 92928571
+ 0.86 0.00 0.57 100000000
+ 0.86 0.00 0.64 1000000
+ 0.86 0.00 0.64 8071429
+ 0.86 0.00 0.64 15142857
+ 0.86 0.00 0.64 22214286
+ 0.86 0.00 0.64 29285714
+ 0.86 0.00 0.64 36357143
+ 0.86 0.00 0.64 43428571
+ 0.86 0.00 0.64 50500000
+ 0.86 0.00 0.64 57571429
+ 0.86 0.00 0.64 64642857
+ 0.86 0.00 0.64 71714286
+ 0.86 0.00 0.64 78785714
+ 0.86 0.00 0.64 85857143
+ 0.86 0.00 0.64 92928571
+ 0.86 0.00 0.64 100000000
+ 0.86 0.00 0.71 1000000
+ 0.86 0.00 0.71 8071429
+ 0.86 0.00 0.71 15142857
+ 0.86 0.00 0.71 22214286
+ 0.86 0.00 0.71 29285714
+ 0.86 0.00 0.71 36357143
+ 0.86 0.00 0.71 43428571
+ 0.86 0.00 0.71 50500000
+ 0.86 0.00 0.71 57571429
+ 0.86 0.00 0.71 64642857
+ 0.86 0.00 0.71 71714286
+ 0.86 0.00 0.71 78785714
+ 0.86 0.00 0.71 85857143
+ 0.86 0.00 0.71 92928571
+ 0.86 0.00 0.71 100000000
+ 0.86 0.00 0.79 1000000
+ 0.86 0.00 0.79 8071429
+ 0.86 0.00 0.79 15142857
+ 0.86 0.00 0.79 22214286
+ 0.86 0.00 0.79 29285714
+ 0.86 0.00 0.79 36357143
+ 0.86 0.00 0.79 43428571
+ 0.86 0.00 0.79 50500000
+ 0.86 0.00 0.79 57571429
+ 0.86 0.00 0.79 64642857
+ 0.86 0.00 0.79 71714286
+ 0.86 0.00 0.79 78785714
+ 0.86 0.00 0.79 85857143
+ 0.86 0.00 0.79 92928571
+ 0.86 0.00 0.79 100000000
+ 0.86 0.00 0.86 1000000
+ 0.86 0.00 0.86 8071429
+ 0.86 0.00 0.86 15142857
+ 0.86 0.00 0.86 22214286
+ 0.86 0.00 0.86 29285714
+ 0.86 0.00 0.86 36357143
+ 0.86 0.00 0.86 43428571
+ 0.86 0.00 0.86 50500000
+ 0.86 0.00 0.86 57571429
+ 0.86 0.00 0.86 64642857
+ 0.86 0.00 0.86 71714286
+ 0.86 0.00 0.86 78785714
+ 0.86 0.00 0.86 85857143
+ 0.86 0.00 0.86 92928571
+ 0.86 0.00 0.86 100000000
+ 0.86 0.00 0.93 1000000
+ 0.86 0.00 0.93 8071429
+ 0.86 0.00 0.93 15142857
+ 0.86 0.00 0.93 22214286
+ 0.86 0.00 0.93 29285714
+ 0.86 0.00 0.93 36357143
+ 0.86 0.00 0.93 43428571
+ 0.86 0.00 0.93 50500000
+ 0.86 0.00 0.93 57571429
+ 0.86 0.00 0.93 64642857
+ 0.86 0.00 0.93 71714286
+ 0.86 0.00 0.93 78785714
+ 0.86 0.00 0.93 85857143
+ 0.86 0.00 0.93 92928571
+ 0.86 0.00 0.93 100000000
+ 0.86 0.00 1.00 1000000
+ 0.86 0.00 1.00 8071429
+ 0.86 0.00 1.00 15142857
+ 0.86 0.00 1.00 22214286
+ 0.86 0.00 1.00 29285714
+ 0.86 0.00 1.00 36357143
+ 0.86 0.00 1.00 43428571
+ 0.86 0.00 1.00 50500000
+ 0.86 0.00 1.00 57571429
+ 0.86 0.00 1.00 64642857
+ 0.86 0.00 1.00 71714286
+ 0.86 0.00 1.00 78785714
+ 0.86 0.00 1.00 85857143
+ 0.86 0.00 1.00 92928571
+ 0.86 0.00 1.00 100000000
+ 0.86 0.07 0.00 1000000
+ 0.86 0.07 0.00 8071429
+ 0.86 0.07 0.00 15142857
+ 0.86 0.07 0.00 22214286
+ 0.86 0.07 0.00 29285714
+ 0.86 0.07 0.00 36357143
+ 0.86 0.07 0.00 43428571
+ 0.86 0.07 0.00 50500000
+ 0.86 0.07 0.00 57571429
+ 0.86 0.07 0.00 64642857
+ 0.86 0.07 0.00 71714286
+ 0.86 0.07 0.00 78785714
+ 0.86 0.07 0.00 85857143
+ 0.86 0.07 0.00 92928571
+ 0.86 0.07 0.00 100000000
+ 0.86 0.07 0.07 1000000
+ 0.86 0.07 0.07 8071429
+ 0.86 0.07 0.07 15142857
+ 0.86 0.07 0.07 22214286
+ 0.86 0.07 0.07 29285714
+ 0.86 0.07 0.07 36357143
+ 0.86 0.07 0.07 43428571
+ 0.86 0.07 0.07 50500000
+ 0.86 0.07 0.07 57571429
+ 0.86 0.07 0.07 64642857
+ 0.86 0.07 0.07 71714286
+ 0.86 0.07 0.07 78785714
+ 0.86 0.07 0.07 85857143
+ 0.86 0.07 0.07 92928571
+ 0.86 0.07 0.07 100000000
+ 0.86 0.07 0.14 1000000
+ 0.86 0.07 0.14 8071429
+ 0.86 0.07 0.14 15142857
+ 0.86 0.07 0.14 22214286
+ 0.86 0.07 0.14 29285714
+ 0.86 0.07 0.14 36357143
+ 0.86 0.07 0.14 43428571
+ 0.86 0.07 0.14 50500000
+ 0.86 0.07 0.14 57571429
+ 0.86 0.07 0.14 64642857
+ 0.86 0.07 0.14 71714286
+ 0.86 0.07 0.14 78785714
+ 0.86 0.07 0.14 85857143
+ 0.86 0.07 0.14 92928571
+ 0.86 0.07 0.14 100000000
+ 0.86 0.07 0.21 1000000
+ 0.86 0.07 0.21 8071429
+ 0.86 0.07 0.21 15142857
+ 0.86 0.07 0.21 22214286
+ 0.86 0.07 0.21 29285714
+ 0.86 0.07 0.21 36357143
+ 0.86 0.07 0.21 43428571
+ 0.86 0.07 0.21 50500000
+ 0.86 0.07 0.21 57571429
+ 0.86 0.07 0.21 64642857
+ 0.86 0.07 0.21 71714286
+ 0.86 0.07 0.21 78785714
+ 0.86 0.07 0.21 85857143
+ 0.86 0.07 0.21 92928571
+ 0.86 0.07 0.21 100000000
+ 0.86 0.07 0.29 1000000
+ 0.86 0.07 0.29 8071429
+ 0.86 0.07 0.29 15142857
+ 0.86 0.07 0.29 22214286
+ 0.86 0.07 0.29 29285714
+ 0.86 0.07 0.29 36357143
+ 0.86 0.07 0.29 43428571
+ 0.86 0.07 0.29 50500000
+ 0.86 0.07 0.29 57571429
+ 0.86 0.07 0.29 64642857
+ 0.86 0.07 0.29 71714286
+ 0.86 0.07 0.29 78785714
+ 0.86 0.07 0.29 85857143
+ 0.86 0.07 0.29 92928571
+ 0.86 0.07 0.29 100000000
+ 0.86 0.07 0.36 1000000
+ 0.86 0.07 0.36 8071429
+ 0.86 0.07 0.36 15142857
+ 0.86 0.07 0.36 22214286
+ 0.86 0.07 0.36 29285714
+ 0.86 0.07 0.36 36357143
+ 0.86 0.07 0.36 43428571
+ 0.86 0.07 0.36 50500000
+ 0.86 0.07 0.36 57571429
+ 0.86 0.07 0.36 64642857
+ 0.86 0.07 0.36 71714286
+ 0.86 0.07 0.36 78785714
+ 0.86 0.07 0.36 85857143
+ 0.86 0.07 0.36 92928571
+ 0.86 0.07 0.36 100000000
+ 0.86 0.07 0.43 1000000
+ 0.86 0.07 0.43 8071429
+ 0.86 0.07 0.43 15142857
+ 0.86 0.07 0.43 22214286
+ 0.86 0.07 0.43 29285714
+ 0.86 0.07 0.43 36357143
+ 0.86 0.07 0.43 43428571
+ 0.86 0.07 0.43 50500000
+ 0.86 0.07 0.43 57571429
+ 0.86 0.07 0.43 64642857
+ 0.86 0.07 0.43 71714286
+ 0.86 0.07 0.43 78785714
+ 0.86 0.07 0.43 85857143
+ 0.86 0.07 0.43 92928571
+ 0.86 0.07 0.43 100000000
+ 0.86 0.07 0.50 1000000
+ 0.86 0.07 0.50 8071429
+ 0.86 0.07 0.50 15142857
+ 0.86 0.07 0.50 22214286
+ 0.86 0.07 0.50 29285714
+ 0.86 0.07 0.50 36357143
+ 0.86 0.07 0.50 43428571
+ 0.86 0.07 0.50 50500000
+ 0.86 0.07 0.50 57571429
+ 0.86 0.07 0.50 64642857
+ 0.86 0.07 0.50 71714286
+ 0.86 0.07 0.50 78785714
+ 0.86 0.07 0.50 85857143
+ 0.86 0.07 0.50 92928571
+ 0.86 0.07 0.50 100000000
+ 0.86 0.07 0.57 1000000
+ 0.86 0.07 0.57 8071429
+ 0.86 0.07 0.57 15142857
+ 0.86 0.07 0.57 22214286
+ 0.86 0.07 0.57 29285714
+ 0.86 0.07 0.57 36357143
+ 0.86 0.07 0.57 43428571
+ 0.86 0.07 0.57 50500000
+ 0.86 0.07 0.57 57571429
+ 0.86 0.07 0.57 64642857
+ 0.86 0.07 0.57 71714286
+ 0.86 0.07 0.57 78785714
+ 0.86 0.07 0.57 85857143
+ 0.86 0.07 0.57 92928571
+ 0.86 0.07 0.57 100000000
+ 0.86 0.07 0.64 1000000
+ 0.86 0.07 0.64 8071429
+ 0.86 0.07 0.64 15142857
+ 0.86 0.07 0.64 22214286
+ 0.86 0.07 0.64 29285714
+ 0.86 0.07 0.64 36357143
+ 0.86 0.07 0.64 43428571
+ 0.86 0.07 0.64 50500000
+ 0.86 0.07 0.64 57571429
+ 0.86 0.07 0.64 64642857
+ 0.86 0.07 0.64 71714286
+ 0.86 0.07 0.64 78785714
+ 0.86 0.07 0.64 85857143
+ 0.86 0.07 0.64 92928571
+ 0.86 0.07 0.64 100000000
+ 0.86 0.07 0.71 1000000
+ 0.86 0.07 0.71 8071429
+ 0.86 0.07 0.71 15142857
+ 0.86 0.07 0.71 22214286
+ 0.86 0.07 0.71 29285714
+ 0.86 0.07 0.71 36357143
+ 0.86 0.07 0.71 43428571
+ 0.86 0.07 0.71 50500000
+ 0.86 0.07 0.71 57571429
+ 0.86 0.07 0.71 64642857
+ 0.86 0.07 0.71 71714286
+ 0.86 0.07 0.71 78785714
+ 0.86 0.07 0.71 85857143
+ 0.86 0.07 0.71 92928571
+ 0.86 0.07 0.71 100000000
+ 0.86 0.07 0.79 1000000
+ 0.86 0.07 0.79 8071429
+ 0.86 0.07 0.79 15142857
+ 0.86 0.07 0.79 22214286
+ 0.86 0.07 0.79 29285714
+ 0.86 0.07 0.79 36357143
+ 0.86 0.07 0.79 43428571
+ 0.86 0.07 0.79 50500000
+ 0.86 0.07 0.79 57571429
+ 0.86 0.07 0.79 64642857
+ 0.86 0.07 0.79 71714286
+ 0.86 0.07 0.79 78785714
+ 0.86 0.07 0.79 85857143
+ 0.86 0.07 0.79 92928571
+ 0.86 0.07 0.79 100000000
+ 0.86 0.07 0.86 1000000
+ 0.86 0.07 0.86 8071429
+ 0.86 0.07 0.86 15142857
+ 0.86 0.07 0.86 22214286
+ 0.86 0.07 0.86 29285714
+ 0.86 0.07 0.86 36357143
+ 0.86 0.07 0.86 43428571
+ 0.86 0.07 0.86 50500000
+ 0.86 0.07 0.86 57571429
+ 0.86 0.07 0.86 64642857
+ 0.86 0.07 0.86 71714286
+ 0.86 0.07 0.86 78785714
+ 0.86 0.07 0.86 85857143
+ 0.86 0.07 0.86 92928571
+ 0.86 0.07 0.86 100000000
+ 0.86 0.07 0.93 1000000
+ 0.86 0.07 0.93 8071429
+ 0.86 0.07 0.93 15142857
+ 0.86 0.07 0.93 22214286
+ 0.86 0.07 0.93 29285714
+ 0.86 0.07 0.93 36357143
+ 0.86 0.07 0.93 43428571
+ 0.86 0.07 0.93 50500000
+ 0.86 0.07 0.93 57571429
+ 0.86 0.07 0.93 64642857
+ 0.86 0.07 0.93 71714286
+ 0.86 0.07 0.93 78785714
+ 0.86 0.07 0.93 85857143
+ 0.86 0.07 0.93 92928571
+ 0.86 0.07 0.93 100000000
+ 0.86 0.07 1.00 1000000
+ 0.86 0.07 1.00 8071429
+ 0.86 0.07 1.00 15142857
+ 0.86 0.07 1.00 22214286
+ 0.86 0.07 1.00 29285714
+ 0.86 0.07 1.00 36357143
+ 0.86 0.07 1.00 43428571
+ 0.86 0.07 1.00 50500000
+ 0.86 0.07 1.00 57571429
+ 0.86 0.07 1.00 64642857
+ 0.86 0.07 1.00 71714286
+ 0.86 0.07 1.00 78785714
+ 0.86 0.07 1.00 85857143
+ 0.86 0.07 1.00 92928571
+ 0.86 0.07 1.00 100000000
+ 0.86 0.14 0.00 1000000
+ 0.86 0.14 0.00 8071429
+ 0.86 0.14 0.00 15142857
+ 0.86 0.14 0.00 22214286
+ 0.86 0.14 0.00 29285714
+ 0.86 0.14 0.00 36357143
+ 0.86 0.14 0.00 43428571
+ 0.86 0.14 0.00 50500000
+ 0.86 0.14 0.00 57571429
+ 0.86 0.14 0.00 64642857
+ 0.86 0.14 0.00 71714286
+ 0.86 0.14 0.00 78785714
+ 0.86 0.14 0.00 85857143
+ 0.86 0.14 0.00 92928571
+ 0.86 0.14 0.00 100000000
+ 0.86 0.14 0.07 1000000
+ 0.86 0.14 0.07 8071429
+ 0.86 0.14 0.07 15142857
+ 0.86 0.14 0.07 22214286
+ 0.86 0.14 0.07 29285714
+ 0.86 0.14 0.07 36357143
+ 0.86 0.14 0.07 43428571
+ 0.86 0.14 0.07 50500000
+ 0.86 0.14 0.07 57571429
+ 0.86 0.14 0.07 64642857
+ 0.86 0.14 0.07 71714286
+ 0.86 0.14 0.07 78785714
+ 0.86 0.14 0.07 85857143
+ 0.86 0.14 0.07 92928571
+ 0.86 0.14 0.07 100000000
+ 0.86 0.14 0.14 1000000
+ 0.86 0.14 0.14 8071429
+ 0.86 0.14 0.14 15142857
+ 0.86 0.14 0.14 22214286
+ 0.86 0.14 0.14 29285714
+ 0.86 0.14 0.14 36357143
+ 0.86 0.14 0.14 43428571
+ 0.86 0.14 0.14 50500000
+ 0.86 0.14 0.14 57571429
+ 0.86 0.14 0.14 64642857
+ 0.86 0.14 0.14 71714286
+ 0.86 0.14 0.14 78785714
+ 0.86 0.14 0.14 85857143
+ 0.86 0.14 0.14 92928571
+ 0.86 0.14 0.14 100000000
+ 0.86 0.14 0.21 1000000
+ 0.86 0.14 0.21 8071429
+ 0.86 0.14 0.21 15142857
+ 0.86 0.14 0.21 22214286
+ 0.86 0.14 0.21 29285714
+ 0.86 0.14 0.21 36357143
+ 0.86 0.14 0.21 43428571
+ 0.86 0.14 0.21 50500000
+ 0.86 0.14 0.21 57571429
+ 0.86 0.14 0.21 64642857
+ 0.86 0.14 0.21 71714286
+ 0.86 0.14 0.21 78785714
+ 0.86 0.14 0.21 85857143
+ 0.86 0.14 0.21 92928571
+ 0.86 0.14 0.21 100000000
+ 0.86 0.14 0.29 1000000
+ 0.86 0.14 0.29 8071429
+ 0.86 0.14 0.29 15142857
+ 0.86 0.14 0.29 22214286
+ 0.86 0.14 0.29 29285714
+ 0.86 0.14 0.29 36357143
+ 0.86 0.14 0.29 43428571
+ 0.86 0.14 0.29 50500000
+ 0.86 0.14 0.29 57571429
+ 0.86 0.14 0.29 64642857
+ 0.86 0.14 0.29 71714286
+ 0.86 0.14 0.29 78785714
+ 0.86 0.14 0.29 85857143
+ 0.86 0.14 0.29 92928571
+ 0.86 0.14 0.29 100000000
+ 0.86 0.14 0.36 1000000
+ 0.86 0.14 0.36 8071429
+ 0.86 0.14 0.36 15142857
+ 0.86 0.14 0.36 22214286
+ 0.86 0.14 0.36 29285714
+ 0.86 0.14 0.36 36357143
+ 0.86 0.14 0.36 43428571
+ 0.86 0.14 0.36 50500000
+ 0.86 0.14 0.36 57571429
+ 0.86 0.14 0.36 64642857
+ 0.86 0.14 0.36 71714286
+ 0.86 0.14 0.36 78785714
+ 0.86 0.14 0.36 85857143
+ 0.86 0.14 0.36 92928571
+ 0.86 0.14 0.36 100000000
+ 0.86 0.14 0.43 1000000
+ 0.86 0.14 0.43 8071429
+ 0.86 0.14 0.43 15142857
+ 0.86 0.14 0.43 22214286
+ 0.86 0.14 0.43 29285714
+ 0.86 0.14 0.43 36357143
+ 0.86 0.14 0.43 43428571
+ 0.86 0.14 0.43 50500000
+ 0.86 0.14 0.43 57571429
+ 0.86 0.14 0.43 64642857
+ 0.86 0.14 0.43 71714286
+ 0.86 0.14 0.43 78785714
+ 0.86 0.14 0.43 85857143
+ 0.86 0.14 0.43 92928571
+ 0.86 0.14 0.43 100000000
+ 0.86 0.14 0.50 1000000
+ 0.86 0.14 0.50 8071429
+ 0.86 0.14 0.50 15142857
+ 0.86 0.14 0.50 22214286
+ 0.86 0.14 0.50 29285714
+ 0.86 0.14 0.50 36357143
+ 0.86 0.14 0.50 43428571
+ 0.86 0.14 0.50 50500000
+ 0.86 0.14 0.50 57571429
+ 0.86 0.14 0.50 64642857
+ 0.86 0.14 0.50 71714286
+ 0.86 0.14 0.50 78785714
+ 0.86 0.14 0.50 85857143
+ 0.86 0.14 0.50 92928571
+ 0.86 0.14 0.50 100000000
+ 0.86 0.14 0.57 1000000
+ 0.86 0.14 0.57 8071429
+ 0.86 0.14 0.57 15142857
+ 0.86 0.14 0.57 22214286
+ 0.86 0.14 0.57 29285714
+ 0.86 0.14 0.57 36357143
+ 0.86 0.14 0.57 43428571
+ 0.86 0.14 0.57 50500000
+ 0.86 0.14 0.57 57571429
+ 0.86 0.14 0.57 64642857
+ 0.86 0.14 0.57 71714286
+ 0.86 0.14 0.57 78785714
+ 0.86 0.14 0.57 85857143
+ 0.86 0.14 0.57 92928571
+ 0.86 0.14 0.57 100000000
+ 0.86 0.14 0.64 1000000
+ 0.86 0.14 0.64 8071429
+ 0.86 0.14 0.64 15142857
+ 0.86 0.14 0.64 22214286
+ 0.86 0.14 0.64 29285714
+ 0.86 0.14 0.64 36357143
+ 0.86 0.14 0.64 43428571
+ 0.86 0.14 0.64 50500000
+ 0.86 0.14 0.64 57571429
+ 0.86 0.14 0.64 64642857
+ 0.86 0.14 0.64 71714286
+ 0.86 0.14 0.64 78785714
+ 0.86 0.14 0.64 85857143
+ 0.86 0.14 0.64 92928571
+ 0.86 0.14 0.64 100000000
+ 0.86 0.14 0.71 1000000
+ 0.86 0.14 0.71 8071429
+ 0.86 0.14 0.71 15142857
+ 0.86 0.14 0.71 22214286
+ 0.86 0.14 0.71 29285714
+ 0.86 0.14 0.71 36357143
+ 0.86 0.14 0.71 43428571
+ 0.86 0.14 0.71 50500000
+ 0.86 0.14 0.71 57571429
+ 0.86 0.14 0.71 64642857
+ 0.86 0.14 0.71 71714286
+ 0.86 0.14 0.71 78785714
+ 0.86 0.14 0.71 85857143
+ 0.86 0.14 0.71 92928571
+ 0.86 0.14 0.71 100000000
+ 0.86 0.14 0.79 1000000
+ 0.86 0.14 0.79 8071429
+ 0.86 0.14 0.79 15142857
+ 0.86 0.14 0.79 22214286
+ 0.86 0.14 0.79 29285714
+ 0.86 0.14 0.79 36357143
+ 0.86 0.14 0.79 43428571
+ 0.86 0.14 0.79 50500000
+ 0.86 0.14 0.79 57571429
+ 0.86 0.14 0.79 64642857
+ 0.86 0.14 0.79 71714286
+ 0.86 0.14 0.79 78785714
+ 0.86 0.14 0.79 85857143
+ 0.86 0.14 0.79 92928571
+ 0.86 0.14 0.79 100000000
+ 0.86 0.14 0.86 1000000
+ 0.86 0.14 0.86 8071429
+ 0.86 0.14 0.86 15142857
+ 0.86 0.14 0.86 22214286
+ 0.86 0.14 0.86 29285714
+ 0.86 0.14 0.86 36357143
+ 0.86 0.14 0.86 43428571
+ 0.86 0.14 0.86 50500000
+ 0.86 0.14 0.86 57571429
+ 0.86 0.14 0.86 64642857
+ 0.86 0.14 0.86 71714286
+ 0.86 0.14 0.86 78785714
+ 0.86 0.14 0.86 85857143
+ 0.86 0.14 0.86 92928571
+ 0.86 0.14 0.86 100000000
+ 0.86 0.14 0.93 1000000
+ 0.86 0.14 0.93 8071429
+ 0.86 0.14 0.93 15142857
+ 0.86 0.14 0.93 22214286
+ 0.86 0.14 0.93 29285714
+ 0.86 0.14 0.93 36357143
+ 0.86 0.14 0.93 43428571
+ 0.86 0.14 0.93 50500000
+ 0.86 0.14 0.93 57571429
+ 0.86 0.14 0.93 64642857
+ 0.86 0.14 0.93 71714286
+ 0.86 0.14 0.93 78785714
+ 0.86 0.14 0.93 85857143
+ 0.86 0.14 0.93 92928571
+ 0.86 0.14 0.93 100000000
+ 0.86 0.14 1.00 1000000
+ 0.86 0.14 1.00 8071429
+ 0.86 0.14 1.00 15142857
+ 0.86 0.14 1.00 22214286
+ 0.86 0.14 1.00 29285714
+ 0.86 0.14 1.00 36357143
+ 0.86 0.14 1.00 43428571
+ 0.86 0.14 1.00 50500000
+ 0.86 0.14 1.00 57571429
+ 0.86 0.14 1.00 64642857
+ 0.86 0.14 1.00 71714286
+ 0.86 0.14 1.00 78785714
+ 0.86 0.14 1.00 85857143
+ 0.86 0.14 1.00 92928571
+ 0.86 0.14 1.00 100000000
+ 0.86 0.21 0.00 1000000
+ 0.86 0.21 0.00 8071429
+ 0.86 0.21 0.00 15142857
+ 0.86 0.21 0.00 22214286
+ 0.86 0.21 0.00 29285714
+ 0.86 0.21 0.00 36357143
+ 0.86 0.21 0.00 43428571
+ 0.86 0.21 0.00 50500000
+ 0.86 0.21 0.00 57571429
+ 0.86 0.21 0.00 64642857
+ 0.86 0.21 0.00 71714286
+ 0.86 0.21 0.00 78785714
+ 0.86 0.21 0.00 85857143
+ 0.86 0.21 0.00 92928571
+ 0.86 0.21 0.00 100000000
+ 0.86 0.21 0.07 1000000
+ 0.86 0.21 0.07 8071429
+ 0.86 0.21 0.07 15142857
+ 0.86 0.21 0.07 22214286
+ 0.86 0.21 0.07 29285714
+ 0.86 0.21 0.07 36357143
+ 0.86 0.21 0.07 43428571
+ 0.86 0.21 0.07 50500000
+ 0.86 0.21 0.07 57571429
+ 0.86 0.21 0.07 64642857
+ 0.86 0.21 0.07 71714286
+ 0.86 0.21 0.07 78785714
+ 0.86 0.21 0.07 85857143
+ 0.86 0.21 0.07 92928571
+ 0.86 0.21 0.07 100000000
+ 0.86 0.21 0.14 1000000
+ 0.86 0.21 0.14 8071429
+ 0.86 0.21 0.14 15142857
+ 0.86 0.21 0.14 22214286
+ 0.86 0.21 0.14 29285714
+ 0.86 0.21 0.14 36357143
+ 0.86 0.21 0.14 43428571
+ 0.86 0.21 0.14 50500000
+ 0.86 0.21 0.14 57571429
+ 0.86 0.21 0.14 64642857
+ 0.86 0.21 0.14 71714286
+ 0.86 0.21 0.14 78785714
+ 0.86 0.21 0.14 85857143
+ 0.86 0.21 0.14 92928571
+ 0.86 0.21 0.14 100000000
+ 0.86 0.21 0.21 1000000
+ 0.86 0.21 0.21 8071429
+ 0.86 0.21 0.21 15142857
+ 0.86 0.21 0.21 22214286
+ 0.86 0.21 0.21 29285714
+ 0.86 0.21 0.21 36357143
+ 0.86 0.21 0.21 43428571
+ 0.86 0.21 0.21 50500000
+ 0.86 0.21 0.21 57571429
+ 0.86 0.21 0.21 64642857
+ 0.86 0.21 0.21 71714286
+ 0.86 0.21 0.21 78785714
+ 0.86 0.21 0.21 85857143
+ 0.86 0.21 0.21 92928571
+ 0.86 0.21 0.21 100000000
+ 0.86 0.21 0.29 1000000
+ 0.86 0.21 0.29 8071429
+ 0.86 0.21 0.29 15142857
+ 0.86 0.21 0.29 22214286
+ 0.86 0.21 0.29 29285714
+ 0.86 0.21 0.29 36357143
+ 0.86 0.21 0.29 43428571
+ 0.86 0.21 0.29 50500000
+ 0.86 0.21 0.29 57571429
+ 0.86 0.21 0.29 64642857
+ 0.86 0.21 0.29 71714286
+ 0.86 0.21 0.29 78785714
+ 0.86 0.21 0.29 85857143
+ 0.86 0.21 0.29 92928571
+ 0.86 0.21 0.29 100000000
+ 0.86 0.21 0.36 1000000
+ 0.86 0.21 0.36 8071429
+ 0.86 0.21 0.36 15142857
+ 0.86 0.21 0.36 22214286
+ 0.86 0.21 0.36 29285714
+ 0.86 0.21 0.36 36357143
+ 0.86 0.21 0.36 43428571
+ 0.86 0.21 0.36 50500000
+ 0.86 0.21 0.36 57571429
+ 0.86 0.21 0.36 64642857
+ 0.86 0.21 0.36 71714286
+ 0.86 0.21 0.36 78785714
+ 0.86 0.21 0.36 85857143
+ 0.86 0.21 0.36 92928571
+ 0.86 0.21 0.36 100000000
+ 0.86 0.21 0.43 1000000
+ 0.86 0.21 0.43 8071429
+ 0.86 0.21 0.43 15142857
+ 0.86 0.21 0.43 22214286
+ 0.86 0.21 0.43 29285714
+ 0.86 0.21 0.43 36357143
+ 0.86 0.21 0.43 43428571
+ 0.86 0.21 0.43 50500000
+ 0.86 0.21 0.43 57571429
+ 0.86 0.21 0.43 64642857
+ 0.86 0.21 0.43 71714286
+ 0.86 0.21 0.43 78785714
+ 0.86 0.21 0.43 85857143
+ 0.86 0.21 0.43 92928571
+ 0.86 0.21 0.43 100000000
+ 0.86 0.21 0.50 1000000
+ 0.86 0.21 0.50 8071429
+ 0.86 0.21 0.50 15142857
+ 0.86 0.21 0.50 22214286
+ 0.86 0.21 0.50 29285714
+ 0.86 0.21 0.50 36357143
+ 0.86 0.21 0.50 43428571
+ 0.86 0.21 0.50 50500000
+ 0.86 0.21 0.50 57571429
+ 0.86 0.21 0.50 64642857
+ 0.86 0.21 0.50 71714286
+ 0.86 0.21 0.50 78785714
+ 0.86 0.21 0.50 85857143
+ 0.86 0.21 0.50 92928571
+ 0.86 0.21 0.50 100000000
+ 0.86 0.21 0.57 1000000
+ 0.86 0.21 0.57 8071429
+ 0.86 0.21 0.57 15142857
+ 0.86 0.21 0.57 22214286
+ 0.86 0.21 0.57 29285714
+ 0.86 0.21 0.57 36357143
+ 0.86 0.21 0.57 43428571
+ 0.86 0.21 0.57 50500000
+ 0.86 0.21 0.57 57571429
+ 0.86 0.21 0.57 64642857
+ 0.86 0.21 0.57 71714286
+ 0.86 0.21 0.57 78785714
+ 0.86 0.21 0.57 85857143
+ 0.86 0.21 0.57 92928571
+ 0.86 0.21 0.57 100000000
+ 0.86 0.21 0.64 1000000
+ 0.86 0.21 0.64 8071429
+ 0.86 0.21 0.64 15142857
+ 0.86 0.21 0.64 22214286
+ 0.86 0.21 0.64 29285714
+ 0.86 0.21 0.64 36357143
+ 0.86 0.21 0.64 43428571
+ 0.86 0.21 0.64 50500000
+ 0.86 0.21 0.64 57571429
+ 0.86 0.21 0.64 64642857
+ 0.86 0.21 0.64 71714286
+ 0.86 0.21 0.64 78785714
+ 0.86 0.21 0.64 85857143
+ 0.86 0.21 0.64 92928571
+ 0.86 0.21 0.64 100000000
+ 0.86 0.21 0.71 1000000
+ 0.86 0.21 0.71 8071429
+ 0.86 0.21 0.71 15142857
+ 0.86 0.21 0.71 22214286
+ 0.86 0.21 0.71 29285714
+ 0.86 0.21 0.71 36357143
+ 0.86 0.21 0.71 43428571
+ 0.86 0.21 0.71 50500000
+ 0.86 0.21 0.71 57571429
+ 0.86 0.21 0.71 64642857
+ 0.86 0.21 0.71 71714286
+ 0.86 0.21 0.71 78785714
+ 0.86 0.21 0.71 85857143
+ 0.86 0.21 0.71 92928571
+ 0.86 0.21 0.71 100000000
+ 0.86 0.21 0.79 1000000
+ 0.86 0.21 0.79 8071429
+ 0.86 0.21 0.79 15142857
+ 0.86 0.21 0.79 22214286
+ 0.86 0.21 0.79 29285714
+ 0.86 0.21 0.79 36357143
+ 0.86 0.21 0.79 43428571
+ 0.86 0.21 0.79 50500000
+ 0.86 0.21 0.79 57571429
+ 0.86 0.21 0.79 64642857
+ 0.86 0.21 0.79 71714286
+ 0.86 0.21 0.79 78785714
+ 0.86 0.21 0.79 85857143
+ 0.86 0.21 0.79 92928571
+ 0.86 0.21 0.79 100000000
+ 0.86 0.21 0.86 1000000
+ 0.86 0.21 0.86 8071429
+ 0.86 0.21 0.86 15142857
+ 0.86 0.21 0.86 22214286
+ 0.86 0.21 0.86 29285714
+ 0.86 0.21 0.86 36357143
+ 0.86 0.21 0.86 43428571
+ 0.86 0.21 0.86 50500000
+ 0.86 0.21 0.86 57571429
+ 0.86 0.21 0.86 64642857
+ 0.86 0.21 0.86 71714286
+ 0.86 0.21 0.86 78785714
+ 0.86 0.21 0.86 85857143
+ 0.86 0.21 0.86 92928571
+ 0.86 0.21 0.86 100000000
+ 0.86 0.21 0.93 1000000
+ 0.86 0.21 0.93 8071429
+ 0.86 0.21 0.93 15142857
+ 0.86 0.21 0.93 22214286
+ 0.86 0.21 0.93 29285714
+ 0.86 0.21 0.93 36357143
+ 0.86 0.21 0.93 43428571
+ 0.86 0.21 0.93 50500000
+ 0.86 0.21 0.93 57571429
+ 0.86 0.21 0.93 64642857
+ 0.86 0.21 0.93 71714286
+ 0.86 0.21 0.93 78785714
+ 0.86 0.21 0.93 85857143
+ 0.86 0.21 0.93 92928571
+ 0.86 0.21 0.93 100000000
+ 0.86 0.21 1.00 1000000
+ 0.86 0.21 1.00 8071429
+ 0.86 0.21 1.00 15142857
+ 0.86 0.21 1.00 22214286
+ 0.86 0.21 1.00 29285714
+ 0.86 0.21 1.00 36357143
+ 0.86 0.21 1.00 43428571
+ 0.86 0.21 1.00 50500000
+ 0.86 0.21 1.00 57571429
+ 0.86 0.21 1.00 64642857
+ 0.86 0.21 1.00 71714286
+ 0.86 0.21 1.00 78785714
+ 0.86 0.21 1.00 85857143
+ 0.86 0.21 1.00 92928571
+ 0.86 0.21 1.00 100000000
+ 0.86 0.29 0.00 1000000
+ 0.86 0.29 0.00 8071429
+ 0.86 0.29 0.00 15142857
+ 0.86 0.29 0.00 22214286
+ 0.86 0.29 0.00 29285714
+ 0.86 0.29 0.00 36357143
+ 0.86 0.29 0.00 43428571
+ 0.86 0.29 0.00 50500000
+ 0.86 0.29 0.00 57571429
+ 0.86 0.29 0.00 64642857
+ 0.86 0.29 0.00 71714286
+ 0.86 0.29 0.00 78785714
+ 0.86 0.29 0.00 85857143
+ 0.86 0.29 0.00 92928571
+ 0.86 0.29 0.00 100000000
+ 0.86 0.29 0.07 1000000
+ 0.86 0.29 0.07 8071429
+ 0.86 0.29 0.07 15142857
+ 0.86 0.29 0.07 22214286
+ 0.86 0.29 0.07 29285714
+ 0.86 0.29 0.07 36357143
+ 0.86 0.29 0.07 43428571
+ 0.86 0.29 0.07 50500000
+ 0.86 0.29 0.07 57571429
+ 0.86 0.29 0.07 64642857
+ 0.86 0.29 0.07 71714286
+ 0.86 0.29 0.07 78785714
+ 0.86 0.29 0.07 85857143
+ 0.86 0.29 0.07 92928571
+ 0.86 0.29 0.07 100000000
+ 0.86 0.29 0.14 1000000
+ 0.86 0.29 0.14 8071429
+ 0.86 0.29 0.14 15142857
+ 0.86 0.29 0.14 22214286
+ 0.86 0.29 0.14 29285714
+ 0.86 0.29 0.14 36357143
+ 0.86 0.29 0.14 43428571
+ 0.86 0.29 0.14 50500000
+ 0.86 0.29 0.14 57571429
+ 0.86 0.29 0.14 64642857
+ 0.86 0.29 0.14 71714286
+ 0.86 0.29 0.14 78785714
+ 0.86 0.29 0.14 85857143
+ 0.86 0.29 0.14 92928571
+ 0.86 0.29 0.14 100000000
+ 0.86 0.29 0.21 1000000
+ 0.86 0.29 0.21 8071429
+ 0.86 0.29 0.21 15142857
+ 0.86 0.29 0.21 22214286
+ 0.86 0.29 0.21 29285714
+ 0.86 0.29 0.21 36357143
+ 0.86 0.29 0.21 43428571
+ 0.86 0.29 0.21 50500000
+ 0.86 0.29 0.21 57571429
+ 0.86 0.29 0.21 64642857
+ 0.86 0.29 0.21 71714286
+ 0.86 0.29 0.21 78785714
+ 0.86 0.29 0.21 85857143
+ 0.86 0.29 0.21 92928571
+ 0.86 0.29 0.21 100000000
+ 0.86 0.29 0.29 1000000
+ 0.86 0.29 0.29 8071429
+ 0.86 0.29 0.29 15142857
+ 0.86 0.29 0.29 22214286
+ 0.86 0.29 0.29 29285714
+ 0.86 0.29 0.29 36357143
+ 0.86 0.29 0.29 43428571
+ 0.86 0.29 0.29 50500000
+ 0.86 0.29 0.29 57571429
+ 0.86 0.29 0.29 64642857
+ 0.86 0.29 0.29 71714286
+ 0.86 0.29 0.29 78785714
+ 0.86 0.29 0.29 85857143
+ 0.86 0.29 0.29 92928571
+ 0.86 0.29 0.29 100000000
+ 0.86 0.29 0.36 1000000
+ 0.86 0.29 0.36 8071429
+ 0.86 0.29 0.36 15142857
+ 0.86 0.29 0.36 22214286
+ 0.86 0.29 0.36 29285714
+ 0.86 0.29 0.36 36357143
+ 0.86 0.29 0.36 43428571
+ 0.86 0.29 0.36 50500000
+ 0.86 0.29 0.36 57571429
+ 0.86 0.29 0.36 64642857
+ 0.86 0.29 0.36 71714286
+ 0.86 0.29 0.36 78785714
+ 0.86 0.29 0.36 85857143
+ 0.86 0.29 0.36 92928571
+ 0.86 0.29 0.36 100000000
+ 0.86 0.29 0.43 1000000
+ 0.86 0.29 0.43 8071429
+ 0.86 0.29 0.43 15142857
+ 0.86 0.29 0.43 22214286
+ 0.86 0.29 0.43 29285714
+ 0.86 0.29 0.43 36357143
+ 0.86 0.29 0.43 43428571
+ 0.86 0.29 0.43 50500000
+ 0.86 0.29 0.43 57571429
+ 0.86 0.29 0.43 64642857
+ 0.86 0.29 0.43 71714286
+ 0.86 0.29 0.43 78785714
+ 0.86 0.29 0.43 85857143
+ 0.86 0.29 0.43 92928571
+ 0.86 0.29 0.43 100000000
+ 0.86 0.29 0.50 1000000
+ 0.86 0.29 0.50 8071429
+ 0.86 0.29 0.50 15142857
+ 0.86 0.29 0.50 22214286
+ 0.86 0.29 0.50 29285714
+ 0.86 0.29 0.50 36357143
+ 0.86 0.29 0.50 43428571
+ 0.86 0.29 0.50 50500000
+ 0.86 0.29 0.50 57571429
+ 0.86 0.29 0.50 64642857
+ 0.86 0.29 0.50 71714286
+ 0.86 0.29 0.50 78785714
+ 0.86 0.29 0.50 85857143
+ 0.86 0.29 0.50 92928571
+ 0.86 0.29 0.50 100000000
+ 0.86 0.29 0.57 1000000
+ 0.86 0.29 0.57 8071429
+ 0.86 0.29 0.57 15142857
+ 0.86 0.29 0.57 22214286
+ 0.86 0.29 0.57 29285714
+ 0.86 0.29 0.57 36357143
+ 0.86 0.29 0.57 43428571
+ 0.86 0.29 0.57 50500000
+ 0.86 0.29 0.57 57571429
+ 0.86 0.29 0.57 64642857
+ 0.86 0.29 0.57 71714286
+ 0.86 0.29 0.57 78785714
+ 0.86 0.29 0.57 85857143
+ 0.86 0.29 0.57 92928571
+ 0.86 0.29 0.57 100000000
+ 0.86 0.29 0.64 1000000
+ 0.86 0.29 0.64 8071429
+ 0.86 0.29 0.64 15142857
+ 0.86 0.29 0.64 22214286
+ 0.86 0.29 0.64 29285714
+ 0.86 0.29 0.64 36357143
+ 0.86 0.29 0.64 43428571
+ 0.86 0.29 0.64 50500000
+ 0.86 0.29 0.64 57571429
+ 0.86 0.29 0.64 64642857
+ 0.86 0.29 0.64 71714286
+ 0.86 0.29 0.64 78785714
+ 0.86 0.29 0.64 85857143
+ 0.86 0.29 0.64 92928571
+ 0.86 0.29 0.64 100000000
+ 0.86 0.29 0.71 1000000
+ 0.86 0.29 0.71 8071429
+ 0.86 0.29 0.71 15142857
+ 0.86 0.29 0.71 22214286
+ 0.86 0.29 0.71 29285714
+ 0.86 0.29 0.71 36357143
+ 0.86 0.29 0.71 43428571
+ 0.86 0.29 0.71 50500000
+ 0.86 0.29 0.71 57571429
+ 0.86 0.29 0.71 64642857
+ 0.86 0.29 0.71 71714286
+ 0.86 0.29 0.71 78785714
+ 0.86 0.29 0.71 85857143
+ 0.86 0.29 0.71 92928571
+ 0.86 0.29 0.71 100000000
+ 0.86 0.29 0.79 1000000
+ 0.86 0.29 0.79 8071429
+ 0.86 0.29 0.79 15142857
+ 0.86 0.29 0.79 22214286
+ 0.86 0.29 0.79 29285714
+ 0.86 0.29 0.79 36357143
+ 0.86 0.29 0.79 43428571
+ 0.86 0.29 0.79 50500000
+ 0.86 0.29 0.79 57571429
+ 0.86 0.29 0.79 64642857
+ 0.86 0.29 0.79 71714286
+ 0.86 0.29 0.79 78785714
+ 0.86 0.29 0.79 85857143
+ 0.86 0.29 0.79 92928571
+ 0.86 0.29 0.79 100000000
+ 0.86 0.29 0.86 1000000
+ 0.86 0.29 0.86 8071429
+ 0.86 0.29 0.86 15142857
+ 0.86 0.29 0.86 22214286
+ 0.86 0.29 0.86 29285714
+ 0.86 0.29 0.86 36357143
+ 0.86 0.29 0.86 43428571
+ 0.86 0.29 0.86 50500000
+ 0.86 0.29 0.86 57571429
+ 0.86 0.29 0.86 64642857
+ 0.86 0.29 0.86 71714286
+ 0.86 0.29 0.86 78785714
+ 0.86 0.29 0.86 85857143
+ 0.86 0.29 0.86 92928571
+ 0.86 0.29 0.86 100000000
+ 0.86 0.29 0.93 1000000
+ 0.86 0.29 0.93 8071429
+ 0.86 0.29 0.93 15142857
+ 0.86 0.29 0.93 22214286
+ 0.86 0.29 0.93 29285714
+ 0.86 0.29 0.93 36357143
+ 0.86 0.29 0.93 43428571
+ 0.86 0.29 0.93 50500000
+ 0.86 0.29 0.93 57571429
+ 0.86 0.29 0.93 64642857
+ 0.86 0.29 0.93 71714286
+ 0.86 0.29 0.93 78785714
+ 0.86 0.29 0.93 85857143
+ 0.86 0.29 0.93 92928571
+ 0.86 0.29 0.93 100000000
+ 0.86 0.29 1.00 1000000
+ 0.86 0.29 1.00 8071429
+ 0.86 0.29 1.00 15142857
+ 0.86 0.29 1.00 22214286
+ 0.86 0.29 1.00 29285714
+ 0.86 0.29 1.00 36357143
+ 0.86 0.29 1.00 43428571
+ 0.86 0.29 1.00 50500000
+ 0.86 0.29 1.00 57571429
+ 0.86 0.29 1.00 64642857
+ 0.86 0.29 1.00 71714286
+ 0.86 0.29 1.00 78785714
+ 0.86 0.29 1.00 85857143
+ 0.86 0.29 1.00 92928571
+ 0.86 0.29 1.00 100000000
+ 0.86 0.36 0.00 1000000
+ 0.86 0.36 0.00 8071429
+ 0.86 0.36 0.00 15142857
+ 0.86 0.36 0.00 22214286
+ 0.86 0.36 0.00 29285714
+ 0.86 0.36 0.00 36357143
+ 0.86 0.36 0.00 43428571
+ 0.86 0.36 0.00 50500000
+ 0.86 0.36 0.00 57571429
+ 0.86 0.36 0.00 64642857
+ 0.86 0.36 0.00 71714286
+ 0.86 0.36 0.00 78785714
+ 0.86 0.36 0.00 85857143
+ 0.86 0.36 0.00 92928571
+ 0.86 0.36 0.00 100000000
+ 0.86 0.36 0.07 1000000
+ 0.86 0.36 0.07 8071429
+ 0.86 0.36 0.07 15142857
+ 0.86 0.36 0.07 22214286
+ 0.86 0.36 0.07 29285714
+ 0.86 0.36 0.07 36357143
+ 0.86 0.36 0.07 43428571
+ 0.86 0.36 0.07 50500000
+ 0.86 0.36 0.07 57571429
+ 0.86 0.36 0.07 64642857
+ 0.86 0.36 0.07 71714286
+ 0.86 0.36 0.07 78785714
+ 0.86 0.36 0.07 85857143
+ 0.86 0.36 0.07 92928571
+ 0.86 0.36 0.07 100000000
+ 0.86 0.36 0.14 1000000
+ 0.86 0.36 0.14 8071429
+ 0.86 0.36 0.14 15142857
+ 0.86 0.36 0.14 22214286
+ 0.86 0.36 0.14 29285714
+ 0.86 0.36 0.14 36357143
+ 0.86 0.36 0.14 43428571
+ 0.86 0.36 0.14 50500000
+ 0.86 0.36 0.14 57571429
+ 0.86 0.36 0.14 64642857
+ 0.86 0.36 0.14 71714286
+ 0.86 0.36 0.14 78785714
+ 0.86 0.36 0.14 85857143
+ 0.86 0.36 0.14 92928571
+ 0.86 0.36 0.14 100000000
+ 0.86 0.36 0.21 1000000
+ 0.86 0.36 0.21 8071429
+ 0.86 0.36 0.21 15142857
+ 0.86 0.36 0.21 22214286
+ 0.86 0.36 0.21 29285714
+ 0.86 0.36 0.21 36357143
+ 0.86 0.36 0.21 43428571
+ 0.86 0.36 0.21 50500000
+ 0.86 0.36 0.21 57571429
+ 0.86 0.36 0.21 64642857
+ 0.86 0.36 0.21 71714286
+ 0.86 0.36 0.21 78785714
+ 0.86 0.36 0.21 85857143
+ 0.86 0.36 0.21 92928571
+ 0.86 0.36 0.21 100000000
+ 0.86 0.36 0.29 1000000
+ 0.86 0.36 0.29 8071429
+ 0.86 0.36 0.29 15142857
+ 0.86 0.36 0.29 22214286
+ 0.86 0.36 0.29 29285714
+ 0.86 0.36 0.29 36357143
+ 0.86 0.36 0.29 43428571
+ 0.86 0.36 0.29 50500000
+ 0.86 0.36 0.29 57571429
+ 0.86 0.36 0.29 64642857
+ 0.86 0.36 0.29 71714286
+ 0.86 0.36 0.29 78785714
+ 0.86 0.36 0.29 85857143
+ 0.86 0.36 0.29 92928571
+ 0.86 0.36 0.29 100000000
+ 0.86 0.36 0.36 1000000
+ 0.86 0.36 0.36 8071429
+ 0.86 0.36 0.36 15142857
+ 0.86 0.36 0.36 22214286
+ 0.86 0.36 0.36 29285714
+ 0.86 0.36 0.36 36357143
+ 0.86 0.36 0.36 43428571
+ 0.86 0.36 0.36 50500000
+ 0.86 0.36 0.36 57571429
+ 0.86 0.36 0.36 64642857
+ 0.86 0.36 0.36 71714286
+ 0.86 0.36 0.36 78785714
+ 0.86 0.36 0.36 85857143
+ 0.86 0.36 0.36 92928571
+ 0.86 0.36 0.36 100000000
+ 0.86 0.36 0.43 1000000
+ 0.86 0.36 0.43 8071429
+ 0.86 0.36 0.43 15142857
+ 0.86 0.36 0.43 22214286
+ 0.86 0.36 0.43 29285714
+ 0.86 0.36 0.43 36357143
+ 0.86 0.36 0.43 43428571
+ 0.86 0.36 0.43 50500000
+ 0.86 0.36 0.43 57571429
+ 0.86 0.36 0.43 64642857
+ 0.86 0.36 0.43 71714286
+ 0.86 0.36 0.43 78785714
+ 0.86 0.36 0.43 85857143
+ 0.86 0.36 0.43 92928571
+ 0.86 0.36 0.43 100000000
+ 0.86 0.36 0.50 1000000
+ 0.86 0.36 0.50 8071429
+ 0.86 0.36 0.50 15142857
+ 0.86 0.36 0.50 22214286
+ 0.86 0.36 0.50 29285714
+ 0.86 0.36 0.50 36357143
+ 0.86 0.36 0.50 43428571
+ 0.86 0.36 0.50 50500000
+ 0.86 0.36 0.50 57571429
+ 0.86 0.36 0.50 64642857
+ 0.86 0.36 0.50 71714286
+ 0.86 0.36 0.50 78785714
+ 0.86 0.36 0.50 85857143
+ 0.86 0.36 0.50 92928571
+ 0.86 0.36 0.50 100000000
+ 0.86 0.36 0.57 1000000
+ 0.86 0.36 0.57 8071429
+ 0.86 0.36 0.57 15142857
+ 0.86 0.36 0.57 22214286
+ 0.86 0.36 0.57 29285714
+ 0.86 0.36 0.57 36357143
+ 0.86 0.36 0.57 43428571
+ 0.86 0.36 0.57 50500000
+ 0.86 0.36 0.57 57571429
+ 0.86 0.36 0.57 64642857
+ 0.86 0.36 0.57 71714286
+ 0.86 0.36 0.57 78785714
+ 0.86 0.36 0.57 85857143
+ 0.86 0.36 0.57 92928571
+ 0.86 0.36 0.57 100000000
+ 0.86 0.36 0.64 1000000
+ 0.86 0.36 0.64 8071429
+ 0.86 0.36 0.64 15142857
+ 0.86 0.36 0.64 22214286
+ 0.86 0.36 0.64 29285714
+ 0.86 0.36 0.64 36357143
+ 0.86 0.36 0.64 43428571
+ 0.86 0.36 0.64 50500000
+ 0.86 0.36 0.64 57571429
+ 0.86 0.36 0.64 64642857
+ 0.86 0.36 0.64 71714286
+ 0.86 0.36 0.64 78785714
+ 0.86 0.36 0.64 85857143
+ 0.86 0.36 0.64 92928571
+ 0.86 0.36 0.64 100000000
+ 0.86 0.36 0.71 1000000
+ 0.86 0.36 0.71 8071429
+ 0.86 0.36 0.71 15142857
+ 0.86 0.36 0.71 22214286
+ 0.86 0.36 0.71 29285714
+ 0.86 0.36 0.71 36357143
+ 0.86 0.36 0.71 43428571
+ 0.86 0.36 0.71 50500000
+ 0.86 0.36 0.71 57571429
+ 0.86 0.36 0.71 64642857
+ 0.86 0.36 0.71 71714286
+ 0.86 0.36 0.71 78785714
+ 0.86 0.36 0.71 85857143
+ 0.86 0.36 0.71 92928571
+ 0.86 0.36 0.71 100000000
+ 0.86 0.36 0.79 1000000
+ 0.86 0.36 0.79 8071429
+ 0.86 0.36 0.79 15142857
+ 0.86 0.36 0.79 22214286
+ 0.86 0.36 0.79 29285714
+ 0.86 0.36 0.79 36357143
+ 0.86 0.36 0.79 43428571
+ 0.86 0.36 0.79 50500000
+ 0.86 0.36 0.79 57571429
+ 0.86 0.36 0.79 64642857
+ 0.86 0.36 0.79 71714286
+ 0.86 0.36 0.79 78785714
+ 0.86 0.36 0.79 85857143
+ 0.86 0.36 0.79 92928571
+ 0.86 0.36 0.79 100000000
+ 0.86 0.36 0.86 1000000
+ 0.86 0.36 0.86 8071429
+ 0.86 0.36 0.86 15142857
+ 0.86 0.36 0.86 22214286
+ 0.86 0.36 0.86 29285714
+ 0.86 0.36 0.86 36357143
+ 0.86 0.36 0.86 43428571
+ 0.86 0.36 0.86 50500000
+ 0.86 0.36 0.86 57571429
+ 0.86 0.36 0.86 64642857
+ 0.86 0.36 0.86 71714286
+ 0.86 0.36 0.86 78785714
+ 0.86 0.36 0.86 85857143
+ 0.86 0.36 0.86 92928571
+ 0.86 0.36 0.86 100000000
+ 0.86 0.36 0.93 1000000
+ 0.86 0.36 0.93 8071429
+ 0.86 0.36 0.93 15142857
+ 0.86 0.36 0.93 22214286
+ 0.86 0.36 0.93 29285714
+ 0.86 0.36 0.93 36357143
+ 0.86 0.36 0.93 43428571
+ 0.86 0.36 0.93 50500000
+ 0.86 0.36 0.93 57571429
+ 0.86 0.36 0.93 64642857
+ 0.86 0.36 0.93 71714286
+ 0.86 0.36 0.93 78785714
+ 0.86 0.36 0.93 85857143
+ 0.86 0.36 0.93 92928571
+ 0.86 0.36 0.93 100000000
+ 0.86 0.36 1.00 1000000
+ 0.86 0.36 1.00 8071429
+ 0.86 0.36 1.00 15142857
+ 0.86 0.36 1.00 22214286
+ 0.86 0.36 1.00 29285714
+ 0.86 0.36 1.00 36357143
+ 0.86 0.36 1.00 43428571
+ 0.86 0.36 1.00 50500000
+ 0.86 0.36 1.00 57571429
+ 0.86 0.36 1.00 64642857
+ 0.86 0.36 1.00 71714286
+ 0.86 0.36 1.00 78785714
+ 0.86 0.36 1.00 85857143
+ 0.86 0.36 1.00 92928571
+ 0.86 0.36 1.00 100000000
+ 0.86 0.43 0.00 1000000
+ 0.86 0.43 0.00 8071429
+ 0.86 0.43 0.00 15142857
+ 0.86 0.43 0.00 22214286
+ 0.86 0.43 0.00 29285714
+ 0.86 0.43 0.00 36357143
+ 0.86 0.43 0.00 43428571
+ 0.86 0.43 0.00 50500000
+ 0.86 0.43 0.00 57571429
+ 0.86 0.43 0.00 64642857
+ 0.86 0.43 0.00 71714286
+ 0.86 0.43 0.00 78785714
+ 0.86 0.43 0.00 85857143
+ 0.86 0.43 0.00 92928571
+ 0.86 0.43 0.00 100000000
+ 0.86 0.43 0.07 1000000
+ 0.86 0.43 0.07 8071429
+ 0.86 0.43 0.07 15142857
+ 0.86 0.43 0.07 22214286
+ 0.86 0.43 0.07 29285714
+ 0.86 0.43 0.07 36357143
+ 0.86 0.43 0.07 43428571
+ 0.86 0.43 0.07 50500000
+ 0.86 0.43 0.07 57571429
+ 0.86 0.43 0.07 64642857
+ 0.86 0.43 0.07 71714286
+ 0.86 0.43 0.07 78785714
+ 0.86 0.43 0.07 85857143
+ 0.86 0.43 0.07 92928571
+ 0.86 0.43 0.07 100000000
+ 0.86 0.43 0.14 1000000
+ 0.86 0.43 0.14 8071429
+ 0.86 0.43 0.14 15142857
+ 0.86 0.43 0.14 22214286
+ 0.86 0.43 0.14 29285714
+ 0.86 0.43 0.14 36357143
+ 0.86 0.43 0.14 43428571
+ 0.86 0.43 0.14 50500000
+ 0.86 0.43 0.14 57571429
+ 0.86 0.43 0.14 64642857
+ 0.86 0.43 0.14 71714286
+ 0.86 0.43 0.14 78785714
+ 0.86 0.43 0.14 85857143
+ 0.86 0.43 0.14 92928571
+ 0.86 0.43 0.14 100000000
+ 0.86 0.43 0.21 1000000
+ 0.86 0.43 0.21 8071429
+ 0.86 0.43 0.21 15142857
+ 0.86 0.43 0.21 22214286
+ 0.86 0.43 0.21 29285714
+ 0.86 0.43 0.21 36357143
+ 0.86 0.43 0.21 43428571
+ 0.86 0.43 0.21 50500000
+ 0.86 0.43 0.21 57571429
+ 0.86 0.43 0.21 64642857
+ 0.86 0.43 0.21 71714286
+ 0.86 0.43 0.21 78785714
+ 0.86 0.43 0.21 85857143
+ 0.86 0.43 0.21 92928571
+ 0.86 0.43 0.21 100000000
+ 0.86 0.43 0.29 1000000
+ 0.86 0.43 0.29 8071429
+ 0.86 0.43 0.29 15142857
+ 0.86 0.43 0.29 22214286
+ 0.86 0.43 0.29 29285714
+ 0.86 0.43 0.29 36357143
+ 0.86 0.43 0.29 43428571
+ 0.86 0.43 0.29 50500000
+ 0.86 0.43 0.29 57571429
+ 0.86 0.43 0.29 64642857
+ 0.86 0.43 0.29 71714286
+ 0.86 0.43 0.29 78785714
+ 0.86 0.43 0.29 85857143
+ 0.86 0.43 0.29 92928571
+ 0.86 0.43 0.29 100000000
+ 0.86 0.43 0.36 1000000
+ 0.86 0.43 0.36 8071429
+ 0.86 0.43 0.36 15142857
+ 0.86 0.43 0.36 22214286
+ 0.86 0.43 0.36 29285714
+ 0.86 0.43 0.36 36357143
+ 0.86 0.43 0.36 43428571
+ 0.86 0.43 0.36 50500000
+ 0.86 0.43 0.36 57571429
+ 0.86 0.43 0.36 64642857
+ 0.86 0.43 0.36 71714286
+ 0.86 0.43 0.36 78785714
+ 0.86 0.43 0.36 85857143
+ 0.86 0.43 0.36 92928571
+ 0.86 0.43 0.36 100000000
+ 0.86 0.43 0.43 1000000
+ 0.86 0.43 0.43 8071429
+ 0.86 0.43 0.43 15142857
+ 0.86 0.43 0.43 22214286
+ 0.86 0.43 0.43 29285714
+ 0.86 0.43 0.43 36357143
+ 0.86 0.43 0.43 43428571
+ 0.86 0.43 0.43 50500000
+ 0.86 0.43 0.43 57571429
+ 0.86 0.43 0.43 64642857
+ 0.86 0.43 0.43 71714286
+ 0.86 0.43 0.43 78785714
+ 0.86 0.43 0.43 85857143
+ 0.86 0.43 0.43 92928571
+ 0.86 0.43 0.43 100000000
+ 0.86 0.43 0.50 1000000
+ 0.86 0.43 0.50 8071429
+ 0.86 0.43 0.50 15142857
+ 0.86 0.43 0.50 22214286
+ 0.86 0.43 0.50 29285714
+ 0.86 0.43 0.50 36357143
+ 0.86 0.43 0.50 43428571
+ 0.86 0.43 0.50 50500000
+ 0.86 0.43 0.50 57571429
+ 0.86 0.43 0.50 64642857
+ 0.86 0.43 0.50 71714286
+ 0.86 0.43 0.50 78785714
+ 0.86 0.43 0.50 85857143
+ 0.86 0.43 0.50 92928571
+ 0.86 0.43 0.50 100000000
+ 0.86 0.43 0.57 1000000
+ 0.86 0.43 0.57 8071429
+ 0.86 0.43 0.57 15142857
+ 0.86 0.43 0.57 22214286
+ 0.86 0.43 0.57 29285714
+ 0.86 0.43 0.57 36357143
+ 0.86 0.43 0.57 43428571
+ 0.86 0.43 0.57 50500000
+ 0.86 0.43 0.57 57571429
+ 0.86 0.43 0.57 64642857
+ 0.86 0.43 0.57 71714286
+ 0.86 0.43 0.57 78785714
+ 0.86 0.43 0.57 85857143
+ 0.86 0.43 0.57 92928571
+ 0.86 0.43 0.57 100000000
+ 0.86 0.43 0.64 1000000
+ 0.86 0.43 0.64 8071429
+ 0.86 0.43 0.64 15142857
+ 0.86 0.43 0.64 22214286
+ 0.86 0.43 0.64 29285714
+ 0.86 0.43 0.64 36357143
+ 0.86 0.43 0.64 43428571
+ 0.86 0.43 0.64 50500000
+ 0.86 0.43 0.64 57571429
+ 0.86 0.43 0.64 64642857
+ 0.86 0.43 0.64 71714286
+ 0.86 0.43 0.64 78785714
+ 0.86 0.43 0.64 85857143
+ 0.86 0.43 0.64 92928571
+ 0.86 0.43 0.64 100000000
+ 0.86 0.43 0.71 1000000
+ 0.86 0.43 0.71 8071429
+ 0.86 0.43 0.71 15142857
+ 0.86 0.43 0.71 22214286
+ 0.86 0.43 0.71 29285714
+ 0.86 0.43 0.71 36357143
+ 0.86 0.43 0.71 43428571
+ 0.86 0.43 0.71 50500000
+ 0.86 0.43 0.71 57571429
+ 0.86 0.43 0.71 64642857
+ 0.86 0.43 0.71 71714286
+ 0.86 0.43 0.71 78785714
+ 0.86 0.43 0.71 85857143
+ 0.86 0.43 0.71 92928571
+ 0.86 0.43 0.71 100000000
+ 0.86 0.43 0.79 1000000
+ 0.86 0.43 0.79 8071429
+ 0.86 0.43 0.79 15142857
+ 0.86 0.43 0.79 22214286
+ 0.86 0.43 0.79 29285714
+ 0.86 0.43 0.79 36357143
+ 0.86 0.43 0.79 43428571
+ 0.86 0.43 0.79 50500000
+ 0.86 0.43 0.79 57571429
+ 0.86 0.43 0.79 64642857
+ 0.86 0.43 0.79 71714286
+ 0.86 0.43 0.79 78785714
+ 0.86 0.43 0.79 85857143
+ 0.86 0.43 0.79 92928571
+ 0.86 0.43 0.79 100000000
+ 0.86 0.43 0.86 1000000
+ 0.86 0.43 0.86 8071429
+ 0.86 0.43 0.86 15142857
+ 0.86 0.43 0.86 22214286
+ 0.86 0.43 0.86 29285714
+ 0.86 0.43 0.86 36357143
+ 0.86 0.43 0.86 43428571
+ 0.86 0.43 0.86 50500000
+ 0.86 0.43 0.86 57571429
+ 0.86 0.43 0.86 64642857
+ 0.86 0.43 0.86 71714286
+ 0.86 0.43 0.86 78785714
+ 0.86 0.43 0.86 85857143
+ 0.86 0.43 0.86 92928571
+ 0.86 0.43 0.86 100000000
+ 0.86 0.43 0.93 1000000
+ 0.86 0.43 0.93 8071429
+ 0.86 0.43 0.93 15142857
+ 0.86 0.43 0.93 22214286
+ 0.86 0.43 0.93 29285714
+ 0.86 0.43 0.93 36357143
+ 0.86 0.43 0.93 43428571
+ 0.86 0.43 0.93 50500000
+ 0.86 0.43 0.93 57571429
+ 0.86 0.43 0.93 64642857
+ 0.86 0.43 0.93 71714286
+ 0.86 0.43 0.93 78785714
+ 0.86 0.43 0.93 85857143
+ 0.86 0.43 0.93 92928571
+ 0.86 0.43 0.93 100000000
+ 0.86 0.43 1.00 1000000
+ 0.86 0.43 1.00 8071429
+ 0.86 0.43 1.00 15142857
+ 0.86 0.43 1.00 22214286
+ 0.86 0.43 1.00 29285714
+ 0.86 0.43 1.00 36357143
+ 0.86 0.43 1.00 43428571
+ 0.86 0.43 1.00 50500000
+ 0.86 0.43 1.00 57571429
+ 0.86 0.43 1.00 64642857
+ 0.86 0.43 1.00 71714286
+ 0.86 0.43 1.00 78785714
+ 0.86 0.43 1.00 85857143
+ 0.86 0.43 1.00 92928571
+ 0.86 0.43 1.00 100000000
+ 0.86 0.50 0.00 1000000
+ 0.86 0.50 0.00 8071429
+ 0.86 0.50 0.00 15142857
+ 0.86 0.50 0.00 22214286
+ 0.86 0.50 0.00 29285714
+ 0.86 0.50 0.00 36357143
+ 0.86 0.50 0.00 43428571
+ 0.86 0.50 0.00 50500000
+ 0.86 0.50 0.00 57571429
+ 0.86 0.50 0.00 64642857
+ 0.86 0.50 0.00 71714286
+ 0.86 0.50 0.00 78785714
+ 0.86 0.50 0.00 85857143
+ 0.86 0.50 0.00 92928571
+ 0.86 0.50 0.00 100000000
+ 0.86 0.50 0.07 1000000
+ 0.86 0.50 0.07 8071429
+ 0.86 0.50 0.07 15142857
+ 0.86 0.50 0.07 22214286
+ 0.86 0.50 0.07 29285714
+ 0.86 0.50 0.07 36357143
+ 0.86 0.50 0.07 43428571
+ 0.86 0.50 0.07 50500000
+ 0.86 0.50 0.07 57571429
+ 0.86 0.50 0.07 64642857
+ 0.86 0.50 0.07 71714286
+ 0.86 0.50 0.07 78785714
+ 0.86 0.50 0.07 85857143
+ 0.86 0.50 0.07 92928571
+ 0.86 0.50 0.07 100000000
+ 0.86 0.50 0.14 1000000
+ 0.86 0.50 0.14 8071429
+ 0.86 0.50 0.14 15142857
+ 0.86 0.50 0.14 22214286
+ 0.86 0.50 0.14 29285714
+ 0.86 0.50 0.14 36357143
+ 0.86 0.50 0.14 43428571
+ 0.86 0.50 0.14 50500000
+ 0.86 0.50 0.14 57571429
+ 0.86 0.50 0.14 64642857
+ 0.86 0.50 0.14 71714286
+ 0.86 0.50 0.14 78785714
+ 0.86 0.50 0.14 85857143
+ 0.86 0.50 0.14 92928571
+ 0.86 0.50 0.14 100000000
+ 0.86 0.50 0.21 1000000
+ 0.86 0.50 0.21 8071429
+ 0.86 0.50 0.21 15142857
+ 0.86 0.50 0.21 22214286
+ 0.86 0.50 0.21 29285714
+ 0.86 0.50 0.21 36357143
+ 0.86 0.50 0.21 43428571
+ 0.86 0.50 0.21 50500000
+ 0.86 0.50 0.21 57571429
+ 0.86 0.50 0.21 64642857
+ 0.86 0.50 0.21 71714286
+ 0.86 0.50 0.21 78785714
+ 0.86 0.50 0.21 85857143
+ 0.86 0.50 0.21 92928571
+ 0.86 0.50 0.21 100000000
+ 0.86 0.50 0.29 1000000
+ 0.86 0.50 0.29 8071429
+ 0.86 0.50 0.29 15142857
+ 0.86 0.50 0.29 22214286
+ 0.86 0.50 0.29 29285714
+ 0.86 0.50 0.29 36357143
+ 0.86 0.50 0.29 43428571
+ 0.86 0.50 0.29 50500000
+ 0.86 0.50 0.29 57571429
+ 0.86 0.50 0.29 64642857
+ 0.86 0.50 0.29 71714286
+ 0.86 0.50 0.29 78785714
+ 0.86 0.50 0.29 85857143
+ 0.86 0.50 0.29 92928571
+ 0.86 0.50 0.29 100000000
+ 0.86 0.50 0.36 1000000
+ 0.86 0.50 0.36 8071429
+ 0.86 0.50 0.36 15142857
+ 0.86 0.50 0.36 22214286
+ 0.86 0.50 0.36 29285714
+ 0.86 0.50 0.36 36357143
+ 0.86 0.50 0.36 43428571
+ 0.86 0.50 0.36 50500000
+ 0.86 0.50 0.36 57571429
+ 0.86 0.50 0.36 64642857
+ 0.86 0.50 0.36 71714286
+ 0.86 0.50 0.36 78785714
+ 0.86 0.50 0.36 85857143
+ 0.86 0.50 0.36 92928571
+ 0.86 0.50 0.36 100000000
+ 0.86 0.50 0.43 1000000
+ 0.86 0.50 0.43 8071429
+ 0.86 0.50 0.43 15142857
+ 0.86 0.50 0.43 22214286
+ 0.86 0.50 0.43 29285714
+ 0.86 0.50 0.43 36357143
+ 0.86 0.50 0.43 43428571
+ 0.86 0.50 0.43 50500000
+ 0.86 0.50 0.43 57571429
+ 0.86 0.50 0.43 64642857
+ 0.86 0.50 0.43 71714286
+ 0.86 0.50 0.43 78785714
+ 0.86 0.50 0.43 85857143
+ 0.86 0.50 0.43 92928571
+ 0.86 0.50 0.43 100000000
+ 0.86 0.50 0.50 1000000
+ 0.86 0.50 0.50 8071429
+ 0.86 0.50 0.50 15142857
+ 0.86 0.50 0.50 22214286
+ 0.86 0.50 0.50 29285714
+ 0.86 0.50 0.50 36357143
+ 0.86 0.50 0.50 43428571
+ 0.86 0.50 0.50 50500000
+ 0.86 0.50 0.50 57571429
+ 0.86 0.50 0.50 64642857
+ 0.86 0.50 0.50 71714286
+ 0.86 0.50 0.50 78785714
+ 0.86 0.50 0.50 85857143
+ 0.86 0.50 0.50 92928571
+ 0.86 0.50 0.50 100000000
+ 0.86 0.50 0.57 1000000
+ 0.86 0.50 0.57 8071429
+ 0.86 0.50 0.57 15142857
+ 0.86 0.50 0.57 22214286
+ 0.86 0.50 0.57 29285714
+ 0.86 0.50 0.57 36357143
+ 0.86 0.50 0.57 43428571
+ 0.86 0.50 0.57 50500000
+ 0.86 0.50 0.57 57571429
+ 0.86 0.50 0.57 64642857
+ 0.86 0.50 0.57 71714286
+ 0.86 0.50 0.57 78785714
+ 0.86 0.50 0.57 85857143
+ 0.86 0.50 0.57 92928571
+ 0.86 0.50 0.57 100000000
+ 0.86 0.50 0.64 1000000
+ 0.86 0.50 0.64 8071429
+ 0.86 0.50 0.64 15142857
+ 0.86 0.50 0.64 22214286
+ 0.86 0.50 0.64 29285714
+ 0.86 0.50 0.64 36357143
+ 0.86 0.50 0.64 43428571
+ 0.86 0.50 0.64 50500000
+ 0.86 0.50 0.64 57571429
+ 0.86 0.50 0.64 64642857
+ 0.86 0.50 0.64 71714286
+ 0.86 0.50 0.64 78785714
+ 0.86 0.50 0.64 85857143
+ 0.86 0.50 0.64 92928571
+ 0.86 0.50 0.64 100000000
+ 0.86 0.50 0.71 1000000
+ 0.86 0.50 0.71 8071429
+ 0.86 0.50 0.71 15142857
+ 0.86 0.50 0.71 22214286
+ 0.86 0.50 0.71 29285714
+ 0.86 0.50 0.71 36357143
+ 0.86 0.50 0.71 43428571
+ 0.86 0.50 0.71 50500000
+ 0.86 0.50 0.71 57571429
+ 0.86 0.50 0.71 64642857
+ 0.86 0.50 0.71 71714286
+ 0.86 0.50 0.71 78785714
+ 0.86 0.50 0.71 85857143
+ 0.86 0.50 0.71 92928571
+ 0.86 0.50 0.71 100000000
+ 0.86 0.50 0.79 1000000
+ 0.86 0.50 0.79 8071429
+ 0.86 0.50 0.79 15142857
+ 0.86 0.50 0.79 22214286
+ 0.86 0.50 0.79 29285714
+ 0.86 0.50 0.79 36357143
+ 0.86 0.50 0.79 43428571
+ 0.86 0.50 0.79 50500000
+ 0.86 0.50 0.79 57571429
+ 0.86 0.50 0.79 64642857
+ 0.86 0.50 0.79 71714286
+ 0.86 0.50 0.79 78785714
+ 0.86 0.50 0.79 85857143
+ 0.86 0.50 0.79 92928571
+ 0.86 0.50 0.79 100000000
+ 0.86 0.50 0.86 1000000
+ 0.86 0.50 0.86 8071429
+ 0.86 0.50 0.86 15142857
+ 0.86 0.50 0.86 22214286
+ 0.86 0.50 0.86 29285714
+ 0.86 0.50 0.86 36357143
+ 0.86 0.50 0.86 43428571
+ 0.86 0.50 0.86 50500000
+ 0.86 0.50 0.86 57571429
+ 0.86 0.50 0.86 64642857
+ 0.86 0.50 0.86 71714286
+ 0.86 0.50 0.86 78785714
+ 0.86 0.50 0.86 85857143
+ 0.86 0.50 0.86 92928571
+ 0.86 0.50 0.86 100000000
+ 0.86 0.50 0.93 1000000
+ 0.86 0.50 0.93 8071429
+ 0.86 0.50 0.93 15142857
+ 0.86 0.50 0.93 22214286
+ 0.86 0.50 0.93 29285714
+ 0.86 0.50 0.93 36357143
+ 0.86 0.50 0.93 43428571
+ 0.86 0.50 0.93 50500000
+ 0.86 0.50 0.93 57571429
+ 0.86 0.50 0.93 64642857
+ 0.86 0.50 0.93 71714286
+ 0.86 0.50 0.93 78785714
+ 0.86 0.50 0.93 85857143
+ 0.86 0.50 0.93 92928571
+ 0.86 0.50 0.93 100000000
+ 0.86 0.50 1.00 1000000
+ 0.86 0.50 1.00 8071429
+ 0.86 0.50 1.00 15142857
+ 0.86 0.50 1.00 22214286
+ 0.86 0.50 1.00 29285714
+ 0.86 0.50 1.00 36357143
+ 0.86 0.50 1.00 43428571
+ 0.86 0.50 1.00 50500000
+ 0.86 0.50 1.00 57571429
+ 0.86 0.50 1.00 64642857
+ 0.86 0.50 1.00 71714286
+ 0.86 0.50 1.00 78785714
+ 0.86 0.50 1.00 85857143
+ 0.86 0.50 1.00 92928571
+ 0.86 0.50 1.00 100000000
+ 0.86 0.57 0.00 1000000
+ 0.86 0.57 0.00 8071429
+ 0.86 0.57 0.00 15142857
+ 0.86 0.57 0.00 22214286
+ 0.86 0.57 0.00 29285714
+ 0.86 0.57 0.00 36357143
+ 0.86 0.57 0.00 43428571
+ 0.86 0.57 0.00 50500000
+ 0.86 0.57 0.00 57571429
+ 0.86 0.57 0.00 64642857
+ 0.86 0.57 0.00 71714286
+ 0.86 0.57 0.00 78785714
+ 0.86 0.57 0.00 85857143
+ 0.86 0.57 0.00 92928571
+ 0.86 0.57 0.00 100000000
+ 0.86 0.57 0.07 1000000
+ 0.86 0.57 0.07 8071429
+ 0.86 0.57 0.07 15142857
+ 0.86 0.57 0.07 22214286
+ 0.86 0.57 0.07 29285714
+ 0.86 0.57 0.07 36357143
+ 0.86 0.57 0.07 43428571
+ 0.86 0.57 0.07 50500000
+ 0.86 0.57 0.07 57571429
+ 0.86 0.57 0.07 64642857
+ 0.86 0.57 0.07 71714286
+ 0.86 0.57 0.07 78785714
+ 0.86 0.57 0.07 85857143
+ 0.86 0.57 0.07 92928571
+ 0.86 0.57 0.07 100000000
+ 0.86 0.57 0.14 1000000
+ 0.86 0.57 0.14 8071429
+ 0.86 0.57 0.14 15142857
+ 0.86 0.57 0.14 22214286
+ 0.86 0.57 0.14 29285714
+ 0.86 0.57 0.14 36357143
+ 0.86 0.57 0.14 43428571
+ 0.86 0.57 0.14 50500000
+ 0.86 0.57 0.14 57571429
+ 0.86 0.57 0.14 64642857
+ 0.86 0.57 0.14 71714286
+ 0.86 0.57 0.14 78785714
+ 0.86 0.57 0.14 85857143
+ 0.86 0.57 0.14 92928571
+ 0.86 0.57 0.14 100000000
+ 0.86 0.57 0.21 1000000
+ 0.86 0.57 0.21 8071429
+ 0.86 0.57 0.21 15142857
+ 0.86 0.57 0.21 22214286
+ 0.86 0.57 0.21 29285714
+ 0.86 0.57 0.21 36357143
+ 0.86 0.57 0.21 43428571
+ 0.86 0.57 0.21 50500000
+ 0.86 0.57 0.21 57571429
+ 0.86 0.57 0.21 64642857
+ 0.86 0.57 0.21 71714286
+ 0.86 0.57 0.21 78785714
+ 0.86 0.57 0.21 85857143
+ 0.86 0.57 0.21 92928571
+ 0.86 0.57 0.21 100000000
+ 0.86 0.57 0.29 1000000
+ 0.86 0.57 0.29 8071429
+ 0.86 0.57 0.29 15142857
+ 0.86 0.57 0.29 22214286
+ 0.86 0.57 0.29 29285714
+ 0.86 0.57 0.29 36357143
+ 0.86 0.57 0.29 43428571
+ 0.86 0.57 0.29 50500000
+ 0.86 0.57 0.29 57571429
+ 0.86 0.57 0.29 64642857
+ 0.86 0.57 0.29 71714286
+ 0.86 0.57 0.29 78785714
+ 0.86 0.57 0.29 85857143
+ 0.86 0.57 0.29 92928571
+ 0.86 0.57 0.29 100000000
+ 0.86 0.57 0.36 1000000
+ 0.86 0.57 0.36 8071429
+ 0.86 0.57 0.36 15142857
+ 0.86 0.57 0.36 22214286
+ 0.86 0.57 0.36 29285714
+ 0.86 0.57 0.36 36357143
+ 0.86 0.57 0.36 43428571
+ 0.86 0.57 0.36 50500000
+ 0.86 0.57 0.36 57571429
+ 0.86 0.57 0.36 64642857
+ 0.86 0.57 0.36 71714286
+ 0.86 0.57 0.36 78785714
+ 0.86 0.57 0.36 85857143
+ 0.86 0.57 0.36 92928571
+ 0.86 0.57 0.36 100000000
+ 0.86 0.57 0.43 1000000
+ 0.86 0.57 0.43 8071429
+ 0.86 0.57 0.43 15142857
+ 0.86 0.57 0.43 22214286
+ 0.86 0.57 0.43 29285714
+ 0.86 0.57 0.43 36357143
+ 0.86 0.57 0.43 43428571
+ 0.86 0.57 0.43 50500000
+ 0.86 0.57 0.43 57571429
+ 0.86 0.57 0.43 64642857
+ 0.86 0.57 0.43 71714286
+ 0.86 0.57 0.43 78785714
+ 0.86 0.57 0.43 85857143
+ 0.86 0.57 0.43 92928571
+ 0.86 0.57 0.43 100000000
+ 0.86 0.57 0.50 1000000
+ 0.86 0.57 0.50 8071429
+ 0.86 0.57 0.50 15142857
+ 0.86 0.57 0.50 22214286
+ 0.86 0.57 0.50 29285714
+ 0.86 0.57 0.50 36357143
+ 0.86 0.57 0.50 43428571
+ 0.86 0.57 0.50 50500000
+ 0.86 0.57 0.50 57571429
+ 0.86 0.57 0.50 64642857
+ 0.86 0.57 0.50 71714286
+ 0.86 0.57 0.50 78785714
+ 0.86 0.57 0.50 85857143
+ 0.86 0.57 0.50 92928571
+ 0.86 0.57 0.50 100000000
+ 0.86 0.57 0.57 1000000
+ 0.86 0.57 0.57 8071429
+ 0.86 0.57 0.57 15142857
+ 0.86 0.57 0.57 22214286
+ 0.86 0.57 0.57 29285714
+ 0.86 0.57 0.57 36357143
+ 0.86 0.57 0.57 43428571
+ 0.86 0.57 0.57 50500000
+ 0.86 0.57 0.57 57571429
+ 0.86 0.57 0.57 64642857
+ 0.86 0.57 0.57 71714286
+ 0.86 0.57 0.57 78785714
+ 0.86 0.57 0.57 85857143
+ 0.86 0.57 0.57 92928571
+ 0.86 0.57 0.57 100000000
+ 0.86 0.57 0.64 1000000
+ 0.86 0.57 0.64 8071429
+ 0.86 0.57 0.64 15142857
+ 0.86 0.57 0.64 22214286
+ 0.86 0.57 0.64 29285714
+ 0.86 0.57 0.64 36357143
+ 0.86 0.57 0.64 43428571
+ 0.86 0.57 0.64 50500000
+ 0.86 0.57 0.64 57571429
+ 0.86 0.57 0.64 64642857
+ 0.86 0.57 0.64 71714286
+ 0.86 0.57 0.64 78785714
+ 0.86 0.57 0.64 85857143
+ 0.86 0.57 0.64 92928571
+ 0.86 0.57 0.64 100000000
+ 0.86 0.57 0.71 1000000
+ 0.86 0.57 0.71 8071429
+ 0.86 0.57 0.71 15142857
+ 0.86 0.57 0.71 22214286
+ 0.86 0.57 0.71 29285714
+ 0.86 0.57 0.71 36357143
+ 0.86 0.57 0.71 43428571
+ 0.86 0.57 0.71 50500000
+ 0.86 0.57 0.71 57571429
+ 0.86 0.57 0.71 64642857
+ 0.86 0.57 0.71 71714286
+ 0.86 0.57 0.71 78785714
+ 0.86 0.57 0.71 85857143
+ 0.86 0.57 0.71 92928571
+ 0.86 0.57 0.71 100000000
+ 0.86 0.57 0.79 1000000
+ 0.86 0.57 0.79 8071429
+ 0.86 0.57 0.79 15142857
+ 0.86 0.57 0.79 22214286
+ 0.86 0.57 0.79 29285714
+ 0.86 0.57 0.79 36357143
+ 0.86 0.57 0.79 43428571
+ 0.86 0.57 0.79 50500000
+ 0.86 0.57 0.79 57571429
+ 0.86 0.57 0.79 64642857
+ 0.86 0.57 0.79 71714286
+ 0.86 0.57 0.79 78785714
+ 0.86 0.57 0.79 85857143
+ 0.86 0.57 0.79 92928571
+ 0.86 0.57 0.79 100000000
+ 0.86 0.57 0.86 1000000
+ 0.86 0.57 0.86 8071429
+ 0.86 0.57 0.86 15142857
+ 0.86 0.57 0.86 22214286
+ 0.86 0.57 0.86 29285714
+ 0.86 0.57 0.86 36357143
+ 0.86 0.57 0.86 43428571
+ 0.86 0.57 0.86 50500000
+ 0.86 0.57 0.86 57571429
+ 0.86 0.57 0.86 64642857
+ 0.86 0.57 0.86 71714286
+ 0.86 0.57 0.86 78785714
+ 0.86 0.57 0.86 85857143
+ 0.86 0.57 0.86 92928571
+ 0.86 0.57 0.86 100000000
+ 0.86 0.57 0.93 1000000
+ 0.86 0.57 0.93 8071429
+ 0.86 0.57 0.93 15142857
+ 0.86 0.57 0.93 22214286
+ 0.86 0.57 0.93 29285714
+ 0.86 0.57 0.93 36357143
+ 0.86 0.57 0.93 43428571
+ 0.86 0.57 0.93 50500000
+ 0.86 0.57 0.93 57571429
+ 0.86 0.57 0.93 64642857
+ 0.86 0.57 0.93 71714286
+ 0.86 0.57 0.93 78785714
+ 0.86 0.57 0.93 85857143
+ 0.86 0.57 0.93 92928571
+ 0.86 0.57 0.93 100000000
+ 0.86 0.57 1.00 1000000
+ 0.86 0.57 1.00 8071429
+ 0.86 0.57 1.00 15142857
+ 0.86 0.57 1.00 22214286
+ 0.86 0.57 1.00 29285714
+ 0.86 0.57 1.00 36357143
+ 0.86 0.57 1.00 43428571
+ 0.86 0.57 1.00 50500000
+ 0.86 0.57 1.00 57571429
+ 0.86 0.57 1.00 64642857
+ 0.86 0.57 1.00 71714286
+ 0.86 0.57 1.00 78785714
+ 0.86 0.57 1.00 85857143
+ 0.86 0.57 1.00 92928571
+ 0.86 0.57 1.00 100000000
+ 0.86 0.64 0.00 1000000
+ 0.86 0.64 0.00 8071429
+ 0.86 0.64 0.00 15142857
+ 0.86 0.64 0.00 22214286
+ 0.86 0.64 0.00 29285714
+ 0.86 0.64 0.00 36357143
+ 0.86 0.64 0.00 43428571
+ 0.86 0.64 0.00 50500000
+ 0.86 0.64 0.00 57571429
+ 0.86 0.64 0.00 64642857
+ 0.86 0.64 0.00 71714286
+ 0.86 0.64 0.00 78785714
+ 0.86 0.64 0.00 85857143
+ 0.86 0.64 0.00 92928571
+ 0.86 0.64 0.00 100000000
+ 0.86 0.64 0.07 1000000
+ 0.86 0.64 0.07 8071429
+ 0.86 0.64 0.07 15142857
+ 0.86 0.64 0.07 22214286
+ 0.86 0.64 0.07 29285714
+ 0.86 0.64 0.07 36357143
+ 0.86 0.64 0.07 43428571
+ 0.86 0.64 0.07 50500000
+ 0.86 0.64 0.07 57571429
+ 0.86 0.64 0.07 64642857
+ 0.86 0.64 0.07 71714286
+ 0.86 0.64 0.07 78785714
+ 0.86 0.64 0.07 85857143
+ 0.86 0.64 0.07 92928571
+ 0.86 0.64 0.07 100000000
+ 0.86 0.64 0.14 1000000
+ 0.86 0.64 0.14 8071429
+ 0.86 0.64 0.14 15142857
+ 0.86 0.64 0.14 22214286
+ 0.86 0.64 0.14 29285714
+ 0.86 0.64 0.14 36357143
+ 0.86 0.64 0.14 43428571
+ 0.86 0.64 0.14 50500000
+ 0.86 0.64 0.14 57571429
+ 0.86 0.64 0.14 64642857
+ 0.86 0.64 0.14 71714286
+ 0.86 0.64 0.14 78785714
+ 0.86 0.64 0.14 85857143
+ 0.86 0.64 0.14 92928571
+ 0.86 0.64 0.14 100000000
+ 0.86 0.64 0.21 1000000
+ 0.86 0.64 0.21 8071429
+ 0.86 0.64 0.21 15142857
+ 0.86 0.64 0.21 22214286
+ 0.86 0.64 0.21 29285714
+ 0.86 0.64 0.21 36357143
+ 0.86 0.64 0.21 43428571
+ 0.86 0.64 0.21 50500000
+ 0.86 0.64 0.21 57571429
+ 0.86 0.64 0.21 64642857
+ 0.86 0.64 0.21 71714286
+ 0.86 0.64 0.21 78785714
+ 0.86 0.64 0.21 85857143
+ 0.86 0.64 0.21 92928571
+ 0.86 0.64 0.21 100000000
+ 0.86 0.64 0.29 1000000
+ 0.86 0.64 0.29 8071429
+ 0.86 0.64 0.29 15142857
+ 0.86 0.64 0.29 22214286
+ 0.86 0.64 0.29 29285714
+ 0.86 0.64 0.29 36357143
+ 0.86 0.64 0.29 43428571
+ 0.86 0.64 0.29 50500000
+ 0.86 0.64 0.29 57571429
+ 0.86 0.64 0.29 64642857
+ 0.86 0.64 0.29 71714286
+ 0.86 0.64 0.29 78785714
+ 0.86 0.64 0.29 85857143
+ 0.86 0.64 0.29 92928571
+ 0.86 0.64 0.29 100000000
+ 0.86 0.64 0.36 1000000
+ 0.86 0.64 0.36 8071429
+ 0.86 0.64 0.36 15142857
+ 0.86 0.64 0.36 22214286
+ 0.86 0.64 0.36 29285714
+ 0.86 0.64 0.36 36357143
+ 0.86 0.64 0.36 43428571
+ 0.86 0.64 0.36 50500000
+ 0.86 0.64 0.36 57571429
+ 0.86 0.64 0.36 64642857
+ 0.86 0.64 0.36 71714286
+ 0.86 0.64 0.36 78785714
+ 0.86 0.64 0.36 85857143
+ 0.86 0.64 0.36 92928571
+ 0.86 0.64 0.36 100000000
+ 0.86 0.64 0.43 1000000
+ 0.86 0.64 0.43 8071429
+ 0.86 0.64 0.43 15142857
+ 0.86 0.64 0.43 22214286
+ 0.86 0.64 0.43 29285714
+ 0.86 0.64 0.43 36357143
+ 0.86 0.64 0.43 43428571
+ 0.86 0.64 0.43 50500000
+ 0.86 0.64 0.43 57571429
+ 0.86 0.64 0.43 64642857
+ 0.86 0.64 0.43 71714286
+ 0.86 0.64 0.43 78785714
+ 0.86 0.64 0.43 85857143
+ 0.86 0.64 0.43 92928571
+ 0.86 0.64 0.43 100000000
+ 0.86 0.64 0.50 1000000
+ 0.86 0.64 0.50 8071429
+ 0.86 0.64 0.50 15142857
+ 0.86 0.64 0.50 22214286
+ 0.86 0.64 0.50 29285714
+ 0.86 0.64 0.50 36357143
+ 0.86 0.64 0.50 43428571
+ 0.86 0.64 0.50 50500000
+ 0.86 0.64 0.50 57571429
+ 0.86 0.64 0.50 64642857
+ 0.86 0.64 0.50 71714286
+ 0.86 0.64 0.50 78785714
+ 0.86 0.64 0.50 85857143
+ 0.86 0.64 0.50 92928571
+ 0.86 0.64 0.50 100000000
+ 0.86 0.64 0.57 1000000
+ 0.86 0.64 0.57 8071429
+ 0.86 0.64 0.57 15142857
+ 0.86 0.64 0.57 22214286
+ 0.86 0.64 0.57 29285714
+ 0.86 0.64 0.57 36357143
+ 0.86 0.64 0.57 43428571
+ 0.86 0.64 0.57 50500000
+ 0.86 0.64 0.57 57571429
+ 0.86 0.64 0.57 64642857
+ 0.86 0.64 0.57 71714286
+ 0.86 0.64 0.57 78785714
+ 0.86 0.64 0.57 85857143
+ 0.86 0.64 0.57 92928571
+ 0.86 0.64 0.57 100000000
+ 0.86 0.64 0.64 1000000
+ 0.86 0.64 0.64 8071429
+ 0.86 0.64 0.64 15142857
+ 0.86 0.64 0.64 22214286
+ 0.86 0.64 0.64 29285714
+ 0.86 0.64 0.64 36357143
+ 0.86 0.64 0.64 43428571
+ 0.86 0.64 0.64 50500000
+ 0.86 0.64 0.64 57571429
+ 0.86 0.64 0.64 64642857
+ 0.86 0.64 0.64 71714286
+ 0.86 0.64 0.64 78785714
+ 0.86 0.64 0.64 85857143
+ 0.86 0.64 0.64 92928571
+ 0.86 0.64 0.64 100000000
+ 0.86 0.64 0.71 1000000
+ 0.86 0.64 0.71 8071429
+ 0.86 0.64 0.71 15142857
+ 0.86 0.64 0.71 22214286
+ 0.86 0.64 0.71 29285714
+ 0.86 0.64 0.71 36357143
+ 0.86 0.64 0.71 43428571
+ 0.86 0.64 0.71 50500000
+ 0.86 0.64 0.71 57571429
+ 0.86 0.64 0.71 64642857
+ 0.86 0.64 0.71 71714286
+ 0.86 0.64 0.71 78785714
+ 0.86 0.64 0.71 85857143
+ 0.86 0.64 0.71 92928571
+ 0.86 0.64 0.71 100000000
+ 0.86 0.64 0.79 1000000
+ 0.86 0.64 0.79 8071429
+ 0.86 0.64 0.79 15142857
+ 0.86 0.64 0.79 22214286
+ 0.86 0.64 0.79 29285714
+ 0.86 0.64 0.79 36357143
+ 0.86 0.64 0.79 43428571
+ 0.86 0.64 0.79 50500000
+ 0.86 0.64 0.79 57571429
+ 0.86 0.64 0.79 64642857
+ 0.86 0.64 0.79 71714286
+ 0.86 0.64 0.79 78785714
+ 0.86 0.64 0.79 85857143
+ 0.86 0.64 0.79 92928571
+ 0.86 0.64 0.79 100000000
+ 0.86 0.64 0.86 1000000
+ 0.86 0.64 0.86 8071429
+ 0.86 0.64 0.86 15142857
+ 0.86 0.64 0.86 22214286
+ 0.86 0.64 0.86 29285714
+ 0.86 0.64 0.86 36357143
+ 0.86 0.64 0.86 43428571
+ 0.86 0.64 0.86 50500000
+ 0.86 0.64 0.86 57571429
+ 0.86 0.64 0.86 64642857
+ 0.86 0.64 0.86 71714286
+ 0.86 0.64 0.86 78785714
+ 0.86 0.64 0.86 85857143
+ 0.86 0.64 0.86 92928571
+ 0.86 0.64 0.86 100000000
+ 0.86 0.64 0.93 1000000
+ 0.86 0.64 0.93 8071429
+ 0.86 0.64 0.93 15142857
+ 0.86 0.64 0.93 22214286
+ 0.86 0.64 0.93 29285714
+ 0.86 0.64 0.93 36357143
+ 0.86 0.64 0.93 43428571
+ 0.86 0.64 0.93 50500000
+ 0.86 0.64 0.93 57571429
+ 0.86 0.64 0.93 64642857
+ 0.86 0.64 0.93 71714286
+ 0.86 0.64 0.93 78785714
+ 0.86 0.64 0.93 85857143
+ 0.86 0.64 0.93 92928571
+ 0.86 0.64 0.93 100000000
+ 0.86 0.64 1.00 1000000
+ 0.86 0.64 1.00 8071429
+ 0.86 0.64 1.00 15142857
+ 0.86 0.64 1.00 22214286
+ 0.86 0.64 1.00 29285714
+ 0.86 0.64 1.00 36357143
+ 0.86 0.64 1.00 43428571
+ 0.86 0.64 1.00 50500000
+ 0.86 0.64 1.00 57571429
+ 0.86 0.64 1.00 64642857
+ 0.86 0.64 1.00 71714286
+ 0.86 0.64 1.00 78785714
+ 0.86 0.64 1.00 85857143
+ 0.86 0.64 1.00 92928571
+ 0.86 0.64 1.00 100000000
+ 0.86 0.71 0.00 1000000
+ 0.86 0.71 0.00 8071429
+ 0.86 0.71 0.00 15142857
+ 0.86 0.71 0.00 22214286
+ 0.86 0.71 0.00 29285714
+ 0.86 0.71 0.00 36357143
+ 0.86 0.71 0.00 43428571
+ 0.86 0.71 0.00 50500000
+ 0.86 0.71 0.00 57571429
+ 0.86 0.71 0.00 64642857
+ 0.86 0.71 0.00 71714286
+ 0.86 0.71 0.00 78785714
+ 0.86 0.71 0.00 85857143
+ 0.86 0.71 0.00 92928571
+ 0.86 0.71 0.00 100000000
+ 0.86 0.71 0.07 1000000
+ 0.86 0.71 0.07 8071429
+ 0.86 0.71 0.07 15142857
+ 0.86 0.71 0.07 22214286
+ 0.86 0.71 0.07 29285714
+ 0.86 0.71 0.07 36357143
+ 0.86 0.71 0.07 43428571
+ 0.86 0.71 0.07 50500000
+ 0.86 0.71 0.07 57571429
+ 0.86 0.71 0.07 64642857
+ 0.86 0.71 0.07 71714286
+ 0.86 0.71 0.07 78785714
+ 0.86 0.71 0.07 85857143
+ 0.86 0.71 0.07 92928571
+ 0.86 0.71 0.07 100000000
+ 0.86 0.71 0.14 1000000
+ 0.86 0.71 0.14 8071429
+ 0.86 0.71 0.14 15142857
+ 0.86 0.71 0.14 22214286
+ 0.86 0.71 0.14 29285714
+ 0.86 0.71 0.14 36357143
+ 0.86 0.71 0.14 43428571
+ 0.86 0.71 0.14 50500000
+ 0.86 0.71 0.14 57571429
+ 0.86 0.71 0.14 64642857
+ 0.86 0.71 0.14 71714286
+ 0.86 0.71 0.14 78785714
+ 0.86 0.71 0.14 85857143
+ 0.86 0.71 0.14 92928571
+ 0.86 0.71 0.14 100000000
+ 0.86 0.71 0.21 1000000
+ 0.86 0.71 0.21 8071429
+ 0.86 0.71 0.21 15142857
+ 0.86 0.71 0.21 22214286
+ 0.86 0.71 0.21 29285714
+ 0.86 0.71 0.21 36357143
+ 0.86 0.71 0.21 43428571
+ 0.86 0.71 0.21 50500000
+ 0.86 0.71 0.21 57571429
+ 0.86 0.71 0.21 64642857
+ 0.86 0.71 0.21 71714286
+ 0.86 0.71 0.21 78785714
+ 0.86 0.71 0.21 85857143
+ 0.86 0.71 0.21 92928571
+ 0.86 0.71 0.21 100000000
+ 0.86 0.71 0.29 1000000
+ 0.86 0.71 0.29 8071429
+ 0.86 0.71 0.29 15142857
+ 0.86 0.71 0.29 22214286
+ 0.86 0.71 0.29 29285714
+ 0.86 0.71 0.29 36357143
+ 0.86 0.71 0.29 43428571
+ 0.86 0.71 0.29 50500000
+ 0.86 0.71 0.29 57571429
+ 0.86 0.71 0.29 64642857
+ 0.86 0.71 0.29 71714286
+ 0.86 0.71 0.29 78785714
+ 0.86 0.71 0.29 85857143
+ 0.86 0.71 0.29 92928571
+ 0.86 0.71 0.29 100000000
+ 0.86 0.71 0.36 1000000
+ 0.86 0.71 0.36 8071429
+ 0.86 0.71 0.36 15142857
+ 0.86 0.71 0.36 22214286
+ 0.86 0.71 0.36 29285714
+ 0.86 0.71 0.36 36357143
+ 0.86 0.71 0.36 43428571
+ 0.86 0.71 0.36 50500000
+ 0.86 0.71 0.36 57571429
+ 0.86 0.71 0.36 64642857
+ 0.86 0.71 0.36 71714286
+ 0.86 0.71 0.36 78785714
+ 0.86 0.71 0.36 85857143
+ 0.86 0.71 0.36 92928571
+ 0.86 0.71 0.36 100000000
+ 0.86 0.71 0.43 1000000
+ 0.86 0.71 0.43 8071429
+ 0.86 0.71 0.43 15142857
+ 0.86 0.71 0.43 22214286
+ 0.86 0.71 0.43 29285714
+ 0.86 0.71 0.43 36357143
+ 0.86 0.71 0.43 43428571
+ 0.86 0.71 0.43 50500000
+ 0.86 0.71 0.43 57571429
+ 0.86 0.71 0.43 64642857
+ 0.86 0.71 0.43 71714286
+ 0.86 0.71 0.43 78785714
+ 0.86 0.71 0.43 85857143
+ 0.86 0.71 0.43 92928571
+ 0.86 0.71 0.43 100000000
+ 0.86 0.71 0.50 1000000
+ 0.86 0.71 0.50 8071429
+ 0.86 0.71 0.50 15142857
+ 0.86 0.71 0.50 22214286
+ 0.86 0.71 0.50 29285714
+ 0.86 0.71 0.50 36357143
+ 0.86 0.71 0.50 43428571
+ 0.86 0.71 0.50 50500000
+ 0.86 0.71 0.50 57571429
+ 0.86 0.71 0.50 64642857
+ 0.86 0.71 0.50 71714286
+ 0.86 0.71 0.50 78785714
+ 0.86 0.71 0.50 85857143
+ 0.86 0.71 0.50 92928571
+ 0.86 0.71 0.50 100000000
+ 0.86 0.71 0.57 1000000
+ 0.86 0.71 0.57 8071429
+ 0.86 0.71 0.57 15142857
+ 0.86 0.71 0.57 22214286
+ 0.86 0.71 0.57 29285714
+ 0.86 0.71 0.57 36357143
+ 0.86 0.71 0.57 43428571
+ 0.86 0.71 0.57 50500000
+ 0.86 0.71 0.57 57571429
+ 0.86 0.71 0.57 64642857
+ 0.86 0.71 0.57 71714286
+ 0.86 0.71 0.57 78785714
+ 0.86 0.71 0.57 85857143
+ 0.86 0.71 0.57 92928571
+ 0.86 0.71 0.57 100000000
+ 0.86 0.71 0.64 1000000
+ 0.86 0.71 0.64 8071429
+ 0.86 0.71 0.64 15142857
+ 0.86 0.71 0.64 22214286
+ 0.86 0.71 0.64 29285714
+ 0.86 0.71 0.64 36357143
+ 0.86 0.71 0.64 43428571
+ 0.86 0.71 0.64 50500000
+ 0.86 0.71 0.64 57571429
+ 0.86 0.71 0.64 64642857
+ 0.86 0.71 0.64 71714286
+ 0.86 0.71 0.64 78785714
+ 0.86 0.71 0.64 85857143
+ 0.86 0.71 0.64 92928571
+ 0.86 0.71 0.64 100000000
+ 0.86 0.71 0.71 1000000
+ 0.86 0.71 0.71 8071429
+ 0.86 0.71 0.71 15142857
+ 0.86 0.71 0.71 22214286
+ 0.86 0.71 0.71 29285714
+ 0.86 0.71 0.71 36357143
+ 0.86 0.71 0.71 43428571
+ 0.86 0.71 0.71 50500000
+ 0.86 0.71 0.71 57571429
+ 0.86 0.71 0.71 64642857
+ 0.86 0.71 0.71 71714286
+ 0.86 0.71 0.71 78785714
+ 0.86 0.71 0.71 85857143
+ 0.86 0.71 0.71 92928571
+ 0.86 0.71 0.71 100000000
+ 0.86 0.71 0.79 1000000
+ 0.86 0.71 0.79 8071429
+ 0.86 0.71 0.79 15142857
+ 0.86 0.71 0.79 22214286
+ 0.86 0.71 0.79 29285714
+ 0.86 0.71 0.79 36357143
+ 0.86 0.71 0.79 43428571
+ 0.86 0.71 0.79 50500000
+ 0.86 0.71 0.79 57571429
+ 0.86 0.71 0.79 64642857
+ 0.86 0.71 0.79 71714286
+ 0.86 0.71 0.79 78785714
+ 0.86 0.71 0.79 85857143
+ 0.86 0.71 0.79 92928571
+ 0.86 0.71 0.79 100000000
+ 0.86 0.71 0.86 1000000
+ 0.86 0.71 0.86 8071429
+ 0.86 0.71 0.86 15142857
+ 0.86 0.71 0.86 22214286
+ 0.86 0.71 0.86 29285714
+ 0.86 0.71 0.86 36357143
+ 0.86 0.71 0.86 43428571
+ 0.86 0.71 0.86 50500000
+ 0.86 0.71 0.86 57571429
+ 0.86 0.71 0.86 64642857
+ 0.86 0.71 0.86 71714286
+ 0.86 0.71 0.86 78785714
+ 0.86 0.71 0.86 85857143
+ 0.86 0.71 0.86 92928571
+ 0.86 0.71 0.86 100000000
+ 0.86 0.71 0.93 1000000
+ 0.86 0.71 0.93 8071429
+ 0.86 0.71 0.93 15142857
+ 0.86 0.71 0.93 22214286
+ 0.86 0.71 0.93 29285714
+ 0.86 0.71 0.93 36357143
+ 0.86 0.71 0.93 43428571
+ 0.86 0.71 0.93 50500000
+ 0.86 0.71 0.93 57571429
+ 0.86 0.71 0.93 64642857
+ 0.86 0.71 0.93 71714286
+ 0.86 0.71 0.93 78785714
+ 0.86 0.71 0.93 85857143
+ 0.86 0.71 0.93 92928571
+ 0.86 0.71 0.93 100000000
+ 0.86 0.71 1.00 1000000
+ 0.86 0.71 1.00 8071429
+ 0.86 0.71 1.00 15142857
+ 0.86 0.71 1.00 22214286
+ 0.86 0.71 1.00 29285714
+ 0.86 0.71 1.00 36357143
+ 0.86 0.71 1.00 43428571
+ 0.86 0.71 1.00 50500000
+ 0.86 0.71 1.00 57571429
+ 0.86 0.71 1.00 64642857
+ 0.86 0.71 1.00 71714286
+ 0.86 0.71 1.00 78785714
+ 0.86 0.71 1.00 85857143
+ 0.86 0.71 1.00 92928571
+ 0.86 0.71 1.00 100000000
+ 0.86 0.79 0.00 1000000
+ 0.86 0.79 0.00 8071429
+ 0.86 0.79 0.00 15142857
+ 0.86 0.79 0.00 22214286
+ 0.86 0.79 0.00 29285714
+ 0.86 0.79 0.00 36357143
+ 0.86 0.79 0.00 43428571
+ 0.86 0.79 0.00 50500000
+ 0.86 0.79 0.00 57571429
+ 0.86 0.79 0.00 64642857
+ 0.86 0.79 0.00 71714286
+ 0.86 0.79 0.00 78785714
+ 0.86 0.79 0.00 85857143
+ 0.86 0.79 0.00 92928571
+ 0.86 0.79 0.00 100000000
+ 0.86 0.79 0.07 1000000
+ 0.86 0.79 0.07 8071429
+ 0.86 0.79 0.07 15142857
+ 0.86 0.79 0.07 22214286
+ 0.86 0.79 0.07 29285714
+ 0.86 0.79 0.07 36357143
+ 0.86 0.79 0.07 43428571
+ 0.86 0.79 0.07 50500000
+ 0.86 0.79 0.07 57571429
+ 0.86 0.79 0.07 64642857
+ 0.86 0.79 0.07 71714286
+ 0.86 0.79 0.07 78785714
+ 0.86 0.79 0.07 85857143
+ 0.86 0.79 0.07 92928571
+ 0.86 0.79 0.07 100000000
+ 0.86 0.79 0.14 1000000
+ 0.86 0.79 0.14 8071429
+ 0.86 0.79 0.14 15142857
+ 0.86 0.79 0.14 22214286
+ 0.86 0.79 0.14 29285714
+ 0.86 0.79 0.14 36357143
+ 0.86 0.79 0.14 43428571
+ 0.86 0.79 0.14 50500000
+ 0.86 0.79 0.14 57571429
+ 0.86 0.79 0.14 64642857
+ 0.86 0.79 0.14 71714286
+ 0.86 0.79 0.14 78785714
+ 0.86 0.79 0.14 85857143
+ 0.86 0.79 0.14 92928571
+ 0.86 0.79 0.14 100000000
+ 0.86 0.79 0.21 1000000
+ 0.86 0.79 0.21 8071429
+ 0.86 0.79 0.21 15142857
+ 0.86 0.79 0.21 22214286
+ 0.86 0.79 0.21 29285714
+ 0.86 0.79 0.21 36357143
+ 0.86 0.79 0.21 43428571
+ 0.86 0.79 0.21 50500000
+ 0.86 0.79 0.21 57571429
+ 0.86 0.79 0.21 64642857
+ 0.86 0.79 0.21 71714286
+ 0.86 0.79 0.21 78785714
+ 0.86 0.79 0.21 85857143
+ 0.86 0.79 0.21 92928571
+ 0.86 0.79 0.21 100000000
+ 0.86 0.79 0.29 1000000
+ 0.86 0.79 0.29 8071429
+ 0.86 0.79 0.29 15142857
+ 0.86 0.79 0.29 22214286
+ 0.86 0.79 0.29 29285714
+ 0.86 0.79 0.29 36357143
+ 0.86 0.79 0.29 43428571
+ 0.86 0.79 0.29 50500000
+ 0.86 0.79 0.29 57571429
+ 0.86 0.79 0.29 64642857
+ 0.86 0.79 0.29 71714286
+ 0.86 0.79 0.29 78785714
+ 0.86 0.79 0.29 85857143
+ 0.86 0.79 0.29 92928571
+ 0.86 0.79 0.29 100000000
+ 0.86 0.79 0.36 1000000
+ 0.86 0.79 0.36 8071429
+ 0.86 0.79 0.36 15142857
+ 0.86 0.79 0.36 22214286
+ 0.86 0.79 0.36 29285714
+ 0.86 0.79 0.36 36357143
+ 0.86 0.79 0.36 43428571
+ 0.86 0.79 0.36 50500000
+ 0.86 0.79 0.36 57571429
+ 0.86 0.79 0.36 64642857
+ 0.86 0.79 0.36 71714286
+ 0.86 0.79 0.36 78785714
+ 0.86 0.79 0.36 85857143
+ 0.86 0.79 0.36 92928571
+ 0.86 0.79 0.36 100000000
+ 0.86 0.79 0.43 1000000
+ 0.86 0.79 0.43 8071429
+ 0.86 0.79 0.43 15142857
+ 0.86 0.79 0.43 22214286
+ 0.86 0.79 0.43 29285714
+ 0.86 0.79 0.43 36357143
+ 0.86 0.79 0.43 43428571
+ 0.86 0.79 0.43 50500000
+ 0.86 0.79 0.43 57571429
+ 0.86 0.79 0.43 64642857
+ 0.86 0.79 0.43 71714286
+ 0.86 0.79 0.43 78785714
+ 0.86 0.79 0.43 85857143
+ 0.86 0.79 0.43 92928571
+ 0.86 0.79 0.43 100000000
+ 0.86 0.79 0.50 1000000
+ 0.86 0.79 0.50 8071429
+ 0.86 0.79 0.50 15142857
+ 0.86 0.79 0.50 22214286
+ 0.86 0.79 0.50 29285714
+ 0.86 0.79 0.50 36357143
+ 0.86 0.79 0.50 43428571
+ 0.86 0.79 0.50 50500000
+ 0.86 0.79 0.50 57571429
+ 0.86 0.79 0.50 64642857
+ 0.86 0.79 0.50 71714286
+ 0.86 0.79 0.50 78785714
+ 0.86 0.79 0.50 85857143
+ 0.86 0.79 0.50 92928571
+ 0.86 0.79 0.50 100000000
+ 0.86 0.79 0.57 1000000
+ 0.86 0.79 0.57 8071429
+ 0.86 0.79 0.57 15142857
+ 0.86 0.79 0.57 22214286
+ 0.86 0.79 0.57 29285714
+ 0.86 0.79 0.57 36357143
+ 0.86 0.79 0.57 43428571
+ 0.86 0.79 0.57 50500000
+ 0.86 0.79 0.57 57571429
+ 0.86 0.79 0.57 64642857
+ 0.86 0.79 0.57 71714286
+ 0.86 0.79 0.57 78785714
+ 0.86 0.79 0.57 85857143
+ 0.86 0.79 0.57 92928571
+ 0.86 0.79 0.57 100000000
+ 0.86 0.79 0.64 1000000
+ 0.86 0.79 0.64 8071429
+ 0.86 0.79 0.64 15142857
+ 0.86 0.79 0.64 22214286
+ 0.86 0.79 0.64 29285714
+ 0.86 0.79 0.64 36357143
+ 0.86 0.79 0.64 43428571
+ 0.86 0.79 0.64 50500000
+ 0.86 0.79 0.64 57571429
+ 0.86 0.79 0.64 64642857
+ 0.86 0.79 0.64 71714286
+ 0.86 0.79 0.64 78785714
+ 0.86 0.79 0.64 85857143
+ 0.86 0.79 0.64 92928571
+ 0.86 0.79 0.64 100000000
+ 0.86 0.79 0.71 1000000
+ 0.86 0.79 0.71 8071429
+ 0.86 0.79 0.71 15142857
+ 0.86 0.79 0.71 22214286
+ 0.86 0.79 0.71 29285714
+ 0.86 0.79 0.71 36357143
+ 0.86 0.79 0.71 43428571
+ 0.86 0.79 0.71 50500000
+ 0.86 0.79 0.71 57571429
+ 0.86 0.79 0.71 64642857
+ 0.86 0.79 0.71 71714286
+ 0.86 0.79 0.71 78785714
+ 0.86 0.79 0.71 85857143
+ 0.86 0.79 0.71 92928571
+ 0.86 0.79 0.71 100000000
+ 0.86 0.79 0.79 1000000
+ 0.86 0.79 0.79 8071429
+ 0.86 0.79 0.79 15142857
+ 0.86 0.79 0.79 22214286
+ 0.86 0.79 0.79 29285714
+ 0.86 0.79 0.79 36357143
+ 0.86 0.79 0.79 43428571
+ 0.86 0.79 0.79 50500000
+ 0.86 0.79 0.79 57571429
+ 0.86 0.79 0.79 64642857
+ 0.86 0.79 0.79 71714286
+ 0.86 0.79 0.79 78785714
+ 0.86 0.79 0.79 85857143
+ 0.86 0.79 0.79 92928571
+ 0.86 0.79 0.79 100000000
+ 0.86 0.79 0.86 1000000
+ 0.86 0.79 0.86 8071429
+ 0.86 0.79 0.86 15142857
+ 0.86 0.79 0.86 22214286
+ 0.86 0.79 0.86 29285714
+ 0.86 0.79 0.86 36357143
+ 0.86 0.79 0.86 43428571
+ 0.86 0.79 0.86 50500000
+ 0.86 0.79 0.86 57571429
+ 0.86 0.79 0.86 64642857
+ 0.86 0.79 0.86 71714286
+ 0.86 0.79 0.86 78785714
+ 0.86 0.79 0.86 85857143
+ 0.86 0.79 0.86 92928571
+ 0.86 0.79 0.86 100000000
+ 0.86 0.79 0.93 1000000
+ 0.86 0.79 0.93 8071429
+ 0.86 0.79 0.93 15142857
+ 0.86 0.79 0.93 22214286
+ 0.86 0.79 0.93 29285714
+ 0.86 0.79 0.93 36357143
+ 0.86 0.79 0.93 43428571
+ 0.86 0.79 0.93 50500000
+ 0.86 0.79 0.93 57571429
+ 0.86 0.79 0.93 64642857
+ 0.86 0.79 0.93 71714286
+ 0.86 0.79 0.93 78785714
+ 0.86 0.79 0.93 85857143
+ 0.86 0.79 0.93 92928571
+ 0.86 0.79 0.93 100000000
+ 0.86 0.79 1.00 1000000
+ 0.86 0.79 1.00 8071429
+ 0.86 0.79 1.00 15142857
+ 0.86 0.79 1.00 22214286
+ 0.86 0.79 1.00 29285714
+ 0.86 0.79 1.00 36357143
+ 0.86 0.79 1.00 43428571
+ 0.86 0.79 1.00 50500000
+ 0.86 0.79 1.00 57571429
+ 0.86 0.79 1.00 64642857
+ 0.86 0.79 1.00 71714286
+ 0.86 0.79 1.00 78785714
+ 0.86 0.79 1.00 85857143
+ 0.86 0.79 1.00 92928571
+ 0.86 0.79 1.00 100000000
+ 0.86 0.86 0.00 1000000
+ 0.86 0.86 0.00 8071429
+ 0.86 0.86 0.00 15142857
+ 0.86 0.86 0.00 22214286
+ 0.86 0.86 0.00 29285714
+ 0.86 0.86 0.00 36357143
+ 0.86 0.86 0.00 43428571
+ 0.86 0.86 0.00 50500000
+ 0.86 0.86 0.00 57571429
+ 0.86 0.86 0.00 64642857
+ 0.86 0.86 0.00 71714286
+ 0.86 0.86 0.00 78785714
+ 0.86 0.86 0.00 85857143
+ 0.86 0.86 0.00 92928571
+ 0.86 0.86 0.00 100000000
+ 0.86 0.86 0.07 1000000
+ 0.86 0.86 0.07 8071429
+ 0.86 0.86 0.07 15142857
+ 0.86 0.86 0.07 22214286
+ 0.86 0.86 0.07 29285714
+ 0.86 0.86 0.07 36357143
+ 0.86 0.86 0.07 43428571
+ 0.86 0.86 0.07 50500000
+ 0.86 0.86 0.07 57571429
+ 0.86 0.86 0.07 64642857
+ 0.86 0.86 0.07 71714286
+ 0.86 0.86 0.07 78785714
+ 0.86 0.86 0.07 85857143
+ 0.86 0.86 0.07 92928571
+ 0.86 0.86 0.07 100000000
+ 0.86 0.86 0.14 1000000
+ 0.86 0.86 0.14 8071429
+ 0.86 0.86 0.14 15142857
+ 0.86 0.86 0.14 22214286
+ 0.86 0.86 0.14 29285714
+ 0.86 0.86 0.14 36357143
+ 0.86 0.86 0.14 43428571
+ 0.86 0.86 0.14 50500000
+ 0.86 0.86 0.14 57571429
+ 0.86 0.86 0.14 64642857
+ 0.86 0.86 0.14 71714286
+ 0.86 0.86 0.14 78785714
+ 0.86 0.86 0.14 85857143
+ 0.86 0.86 0.14 92928571
+ 0.86 0.86 0.14 100000000
+ 0.86 0.86 0.21 1000000
+ 0.86 0.86 0.21 8071429
+ 0.86 0.86 0.21 15142857
+ 0.86 0.86 0.21 22214286
+ 0.86 0.86 0.21 29285714
+ 0.86 0.86 0.21 36357143
+ 0.86 0.86 0.21 43428571
+ 0.86 0.86 0.21 50500000
+ 0.86 0.86 0.21 57571429
+ 0.86 0.86 0.21 64642857
+ 0.86 0.86 0.21 71714286
+ 0.86 0.86 0.21 78785714
+ 0.86 0.86 0.21 85857143
+ 0.86 0.86 0.21 92928571
+ 0.86 0.86 0.21 100000000
+ 0.86 0.86 0.29 1000000
+ 0.86 0.86 0.29 8071429
+ 0.86 0.86 0.29 15142857
+ 0.86 0.86 0.29 22214286
+ 0.86 0.86 0.29 29285714
+ 0.86 0.86 0.29 36357143
+ 0.86 0.86 0.29 43428571
+ 0.86 0.86 0.29 50500000
+ 0.86 0.86 0.29 57571429
+ 0.86 0.86 0.29 64642857
+ 0.86 0.86 0.29 71714286
+ 0.86 0.86 0.29 78785714
+ 0.86 0.86 0.29 85857143
+ 0.86 0.86 0.29 92928571
+ 0.86 0.86 0.29 100000000
+ 0.86 0.86 0.36 1000000
+ 0.86 0.86 0.36 8071429
+ 0.86 0.86 0.36 15142857
+ 0.86 0.86 0.36 22214286
+ 0.86 0.86 0.36 29285714
+ 0.86 0.86 0.36 36357143
+ 0.86 0.86 0.36 43428571
+ 0.86 0.86 0.36 50500000
+ 0.86 0.86 0.36 57571429
+ 0.86 0.86 0.36 64642857
+ 0.86 0.86 0.36 71714286
+ 0.86 0.86 0.36 78785714
+ 0.86 0.86 0.36 85857143
+ 0.86 0.86 0.36 92928571
+ 0.86 0.86 0.36 100000000
+ 0.86 0.86 0.43 1000000
+ 0.86 0.86 0.43 8071429
+ 0.86 0.86 0.43 15142857
+ 0.86 0.86 0.43 22214286
+ 0.86 0.86 0.43 29285714
+ 0.86 0.86 0.43 36357143
+ 0.86 0.86 0.43 43428571
+ 0.86 0.86 0.43 50500000
+ 0.86 0.86 0.43 57571429
+ 0.86 0.86 0.43 64642857
+ 0.86 0.86 0.43 71714286
+ 0.86 0.86 0.43 78785714
+ 0.86 0.86 0.43 85857143
+ 0.86 0.86 0.43 92928571
+ 0.86 0.86 0.43 100000000
+ 0.86 0.86 0.50 1000000
+ 0.86 0.86 0.50 8071429
+ 0.86 0.86 0.50 15142857
+ 0.86 0.86 0.50 22214286
+ 0.86 0.86 0.50 29285714
+ 0.86 0.86 0.50 36357143
+ 0.86 0.86 0.50 43428571
+ 0.86 0.86 0.50 50500000
+ 0.86 0.86 0.50 57571429
+ 0.86 0.86 0.50 64642857
+ 0.86 0.86 0.50 71714286
+ 0.86 0.86 0.50 78785714
+ 0.86 0.86 0.50 85857143
+ 0.86 0.86 0.50 92928571
+ 0.86 0.86 0.50 100000000
+ 0.86 0.86 0.57 1000000
+ 0.86 0.86 0.57 8071429
+ 0.86 0.86 0.57 15142857
+ 0.86 0.86 0.57 22214286
+ 0.86 0.86 0.57 29285714
+ 0.86 0.86 0.57 36357143
+ 0.86 0.86 0.57 43428571
+ 0.86 0.86 0.57 50500000
+ 0.86 0.86 0.57 57571429
+ 0.86 0.86 0.57 64642857
+ 0.86 0.86 0.57 71714286
+ 0.86 0.86 0.57 78785714
+ 0.86 0.86 0.57 85857143
+ 0.86 0.86 0.57 92928571
+ 0.86 0.86 0.57 100000000
+ 0.86 0.86 0.64 1000000
+ 0.86 0.86 0.64 8071429
+ 0.86 0.86 0.64 15142857
+ 0.86 0.86 0.64 22214286
+ 0.86 0.86 0.64 29285714
+ 0.86 0.86 0.64 36357143
+ 0.86 0.86 0.64 43428571
+ 0.86 0.86 0.64 50500000
+ 0.86 0.86 0.64 57571429
+ 0.86 0.86 0.64 64642857
+ 0.86 0.86 0.64 71714286
+ 0.86 0.86 0.64 78785714
+ 0.86 0.86 0.64 85857143
+ 0.86 0.86 0.64 92928571
+ 0.86 0.86 0.64 100000000
+ 0.86 0.86 0.71 1000000
+ 0.86 0.86 0.71 8071429
+ 0.86 0.86 0.71 15142857
+ 0.86 0.86 0.71 22214286
+ 0.86 0.86 0.71 29285714
+ 0.86 0.86 0.71 36357143
+ 0.86 0.86 0.71 43428571
+ 0.86 0.86 0.71 50500000
+ 0.86 0.86 0.71 57571429
+ 0.86 0.86 0.71 64642857
+ 0.86 0.86 0.71 71714286
+ 0.86 0.86 0.71 78785714
+ 0.86 0.86 0.71 85857143
+ 0.86 0.86 0.71 92928571
+ 0.86 0.86 0.71 100000000
+ 0.86 0.86 0.79 1000000
+ 0.86 0.86 0.79 8071429
+ 0.86 0.86 0.79 15142857
+ 0.86 0.86 0.79 22214286
+ 0.86 0.86 0.79 29285714
+ 0.86 0.86 0.79 36357143
+ 0.86 0.86 0.79 43428571
+ 0.86 0.86 0.79 50500000
+ 0.86 0.86 0.79 57571429
+ 0.86 0.86 0.79 64642857
+ 0.86 0.86 0.79 71714286
+ 0.86 0.86 0.79 78785714
+ 0.86 0.86 0.79 85857143
+ 0.86 0.86 0.79 92928571
+ 0.86 0.86 0.79 100000000
+ 0.86 0.86 0.86 1000000
+ 0.86 0.86 0.86 8071429
+ 0.86 0.86 0.86 15142857
+ 0.86 0.86 0.86 22214286
+ 0.86 0.86 0.86 29285714
+ 0.86 0.86 0.86 36357143
+ 0.86 0.86 0.86 43428571
+ 0.86 0.86 0.86 50500000
+ 0.86 0.86 0.86 57571429
+ 0.86 0.86 0.86 64642857
+ 0.86 0.86 0.86 71714286
+ 0.86 0.86 0.86 78785714
+ 0.86 0.86 0.86 85857143
+ 0.86 0.86 0.86 92928571
+ 0.86 0.86 0.86 100000000
+ 0.86 0.86 0.93 1000000
+ 0.86 0.86 0.93 8071429
+ 0.86 0.86 0.93 15142857
+ 0.86 0.86 0.93 22214286
+ 0.86 0.86 0.93 29285714
+ 0.86 0.86 0.93 36357143
+ 0.86 0.86 0.93 43428571
+ 0.86 0.86 0.93 50500000
+ 0.86 0.86 0.93 57571429
+ 0.86 0.86 0.93 64642857
+ 0.86 0.86 0.93 71714286
+ 0.86 0.86 0.93 78785714
+ 0.86 0.86 0.93 85857143
+ 0.86 0.86 0.93 92928571
+ 0.86 0.86 0.93 100000000
+ 0.86 0.86 1.00 1000000
+ 0.86 0.86 1.00 8071429
+ 0.86 0.86 1.00 15142857
+ 0.86 0.86 1.00 22214286
+ 0.86 0.86 1.00 29285714
+ 0.86 0.86 1.00 36357143
+ 0.86 0.86 1.00 43428571
+ 0.86 0.86 1.00 50500000
+ 0.86 0.86 1.00 57571429
+ 0.86 0.86 1.00 64642857
+ 0.86 0.86 1.00 71714286
+ 0.86 0.86 1.00 78785714
+ 0.86 0.86 1.00 85857143
+ 0.86 0.86 1.00 92928571
+ 0.86 0.86 1.00 100000000
+ 0.86 0.93 0.00 1000000
+ 0.86 0.93 0.00 8071429
+ 0.86 0.93 0.00 15142857
+ 0.86 0.93 0.00 22214286
+ 0.86 0.93 0.00 29285714
+ 0.86 0.93 0.00 36357143
+ 0.86 0.93 0.00 43428571
+ 0.86 0.93 0.00 50500000
+ 0.86 0.93 0.00 57571429
+ 0.86 0.93 0.00 64642857
+ 0.86 0.93 0.00 71714286
+ 0.86 0.93 0.00 78785714
+ 0.86 0.93 0.00 85857143
+ 0.86 0.93 0.00 92928571
+ 0.86 0.93 0.00 100000000
+ 0.86 0.93 0.07 1000000
+ 0.86 0.93 0.07 8071429
+ 0.86 0.93 0.07 15142857
+ 0.86 0.93 0.07 22214286
+ 0.86 0.93 0.07 29285714
+ 0.86 0.93 0.07 36357143
+ 0.86 0.93 0.07 43428571
+ 0.86 0.93 0.07 50500000
+ 0.86 0.93 0.07 57571429
+ 0.86 0.93 0.07 64642857
+ 0.86 0.93 0.07 71714286
+ 0.86 0.93 0.07 78785714
+ 0.86 0.93 0.07 85857143
+ 0.86 0.93 0.07 92928571
+ 0.86 0.93 0.07 100000000
+ 0.86 0.93 0.14 1000000
+ 0.86 0.93 0.14 8071429
+ 0.86 0.93 0.14 15142857
+ 0.86 0.93 0.14 22214286
+ 0.86 0.93 0.14 29285714
+ 0.86 0.93 0.14 36357143
+ 0.86 0.93 0.14 43428571
+ 0.86 0.93 0.14 50500000
+ 0.86 0.93 0.14 57571429
+ 0.86 0.93 0.14 64642857
+ 0.86 0.93 0.14 71714286
+ 0.86 0.93 0.14 78785714
+ 0.86 0.93 0.14 85857143
+ 0.86 0.93 0.14 92928571
+ 0.86 0.93 0.14 100000000
+ 0.86 0.93 0.21 1000000
+ 0.86 0.93 0.21 8071429
+ 0.86 0.93 0.21 15142857
+ 0.86 0.93 0.21 22214286
+ 0.86 0.93 0.21 29285714
+ 0.86 0.93 0.21 36357143
+ 0.86 0.93 0.21 43428571
+ 0.86 0.93 0.21 50500000
+ 0.86 0.93 0.21 57571429
+ 0.86 0.93 0.21 64642857
+ 0.86 0.93 0.21 71714286
+ 0.86 0.93 0.21 78785714
+ 0.86 0.93 0.21 85857143
+ 0.86 0.93 0.21 92928571
+ 0.86 0.93 0.21 100000000
+ 0.86 0.93 0.29 1000000
+ 0.86 0.93 0.29 8071429
+ 0.86 0.93 0.29 15142857
+ 0.86 0.93 0.29 22214286
+ 0.86 0.93 0.29 29285714
+ 0.86 0.93 0.29 36357143
+ 0.86 0.93 0.29 43428571
+ 0.86 0.93 0.29 50500000
+ 0.86 0.93 0.29 57571429
+ 0.86 0.93 0.29 64642857
+ 0.86 0.93 0.29 71714286
+ 0.86 0.93 0.29 78785714
+ 0.86 0.93 0.29 85857143
+ 0.86 0.93 0.29 92928571
+ 0.86 0.93 0.29 100000000
+ 0.86 0.93 0.36 1000000
+ 0.86 0.93 0.36 8071429
+ 0.86 0.93 0.36 15142857
+ 0.86 0.93 0.36 22214286
+ 0.86 0.93 0.36 29285714
+ 0.86 0.93 0.36 36357143
+ 0.86 0.93 0.36 43428571
+ 0.86 0.93 0.36 50500000
+ 0.86 0.93 0.36 57571429
+ 0.86 0.93 0.36 64642857
+ 0.86 0.93 0.36 71714286
+ 0.86 0.93 0.36 78785714
+ 0.86 0.93 0.36 85857143
+ 0.86 0.93 0.36 92928571
+ 0.86 0.93 0.36 100000000
+ 0.86 0.93 0.43 1000000
+ 0.86 0.93 0.43 8071429
+ 0.86 0.93 0.43 15142857
+ 0.86 0.93 0.43 22214286
+ 0.86 0.93 0.43 29285714
+ 0.86 0.93 0.43 36357143
+ 0.86 0.93 0.43 43428571
+ 0.86 0.93 0.43 50500000
+ 0.86 0.93 0.43 57571429
+ 0.86 0.93 0.43 64642857
+ 0.86 0.93 0.43 71714286
+ 0.86 0.93 0.43 78785714
+ 0.86 0.93 0.43 85857143
+ 0.86 0.93 0.43 92928571
+ 0.86 0.93 0.43 100000000
+ 0.86 0.93 0.50 1000000
+ 0.86 0.93 0.50 8071429
+ 0.86 0.93 0.50 15142857
+ 0.86 0.93 0.50 22214286
+ 0.86 0.93 0.50 29285714
+ 0.86 0.93 0.50 36357143
+ 0.86 0.93 0.50 43428571
+ 0.86 0.93 0.50 50500000
+ 0.86 0.93 0.50 57571429
+ 0.86 0.93 0.50 64642857
+ 0.86 0.93 0.50 71714286
+ 0.86 0.93 0.50 78785714
+ 0.86 0.93 0.50 85857143
+ 0.86 0.93 0.50 92928571
+ 0.86 0.93 0.50 100000000
+ 0.86 0.93 0.57 1000000
+ 0.86 0.93 0.57 8071429
+ 0.86 0.93 0.57 15142857
+ 0.86 0.93 0.57 22214286
+ 0.86 0.93 0.57 29285714
+ 0.86 0.93 0.57 36357143
+ 0.86 0.93 0.57 43428571
+ 0.86 0.93 0.57 50500000
+ 0.86 0.93 0.57 57571429
+ 0.86 0.93 0.57 64642857
+ 0.86 0.93 0.57 71714286
+ 0.86 0.93 0.57 78785714
+ 0.86 0.93 0.57 85857143
+ 0.86 0.93 0.57 92928571
+ 0.86 0.93 0.57 100000000
+ 0.86 0.93 0.64 1000000
+ 0.86 0.93 0.64 8071429
+ 0.86 0.93 0.64 15142857
+ 0.86 0.93 0.64 22214286
+ 0.86 0.93 0.64 29285714
+ 0.86 0.93 0.64 36357143
+ 0.86 0.93 0.64 43428571
+ 0.86 0.93 0.64 50500000
+ 0.86 0.93 0.64 57571429
+ 0.86 0.93 0.64 64642857
+ 0.86 0.93 0.64 71714286
+ 0.86 0.93 0.64 78785714
+ 0.86 0.93 0.64 85857143
+ 0.86 0.93 0.64 92928571
+ 0.86 0.93 0.64 100000000
+ 0.86 0.93 0.71 1000000
+ 0.86 0.93 0.71 8071429
+ 0.86 0.93 0.71 15142857
+ 0.86 0.93 0.71 22214286
+ 0.86 0.93 0.71 29285714
+ 0.86 0.93 0.71 36357143
+ 0.86 0.93 0.71 43428571
+ 0.86 0.93 0.71 50500000
+ 0.86 0.93 0.71 57571429
+ 0.86 0.93 0.71 64642857
+ 0.86 0.93 0.71 71714286
+ 0.86 0.93 0.71 78785714
+ 0.86 0.93 0.71 85857143
+ 0.86 0.93 0.71 92928571
+ 0.86 0.93 0.71 100000000
+ 0.86 0.93 0.79 1000000
+ 0.86 0.93 0.79 8071429
+ 0.86 0.93 0.79 15142857
+ 0.86 0.93 0.79 22214286
+ 0.86 0.93 0.79 29285714
+ 0.86 0.93 0.79 36357143
+ 0.86 0.93 0.79 43428571
+ 0.86 0.93 0.79 50500000
+ 0.86 0.93 0.79 57571429
+ 0.86 0.93 0.79 64642857
+ 0.86 0.93 0.79 71714286
+ 0.86 0.93 0.79 78785714
+ 0.86 0.93 0.79 85857143
+ 0.86 0.93 0.79 92928571
+ 0.86 0.93 0.79 100000000
+ 0.86 0.93 0.86 1000000
+ 0.86 0.93 0.86 8071429
+ 0.86 0.93 0.86 15142857
+ 0.86 0.93 0.86 22214286
+ 0.86 0.93 0.86 29285714
+ 0.86 0.93 0.86 36357143
+ 0.86 0.93 0.86 43428571
+ 0.86 0.93 0.86 50500000
+ 0.86 0.93 0.86 57571429
+ 0.86 0.93 0.86 64642857
+ 0.86 0.93 0.86 71714286
+ 0.86 0.93 0.86 78785714
+ 0.86 0.93 0.86 85857143
+ 0.86 0.93 0.86 92928571
+ 0.86 0.93 0.86 100000000
+ 0.86 0.93 0.93 1000000
+ 0.86 0.93 0.93 8071429
+ 0.86 0.93 0.93 15142857
+ 0.86 0.93 0.93 22214286
+ 0.86 0.93 0.93 29285714
+ 0.86 0.93 0.93 36357143
+ 0.86 0.93 0.93 43428571
+ 0.86 0.93 0.93 50500000
+ 0.86 0.93 0.93 57571429
+ 0.86 0.93 0.93 64642857
+ 0.86 0.93 0.93 71714286
+ 0.86 0.93 0.93 78785714
+ 0.86 0.93 0.93 85857143
+ 0.86 0.93 0.93 92928571
+ 0.86 0.93 0.93 100000000
+ 0.86 0.93 1.00 1000000
+ 0.86 0.93 1.00 8071429
+ 0.86 0.93 1.00 15142857
+ 0.86 0.93 1.00 22214286
+ 0.86 0.93 1.00 29285714
+ 0.86 0.93 1.00 36357143
+ 0.86 0.93 1.00 43428571
+ 0.86 0.93 1.00 50500000
+ 0.86 0.93 1.00 57571429
+ 0.86 0.93 1.00 64642857
+ 0.86 0.93 1.00 71714286
+ 0.86 0.93 1.00 78785714
+ 0.86 0.93 1.00 85857143
+ 0.86 0.93 1.00 92928571
+ 0.86 0.93 1.00 100000000
+ 0.86 1.00 0.00 1000000
+ 0.86 1.00 0.00 8071429
+ 0.86 1.00 0.00 15142857
+ 0.86 1.00 0.00 22214286
+ 0.86 1.00 0.00 29285714
+ 0.86 1.00 0.00 36357143
+ 0.86 1.00 0.00 43428571
+ 0.86 1.00 0.00 50500000
+ 0.86 1.00 0.00 57571429
+ 0.86 1.00 0.00 64642857
+ 0.86 1.00 0.00 71714286
+ 0.86 1.00 0.00 78785714
+ 0.86 1.00 0.00 85857143
+ 0.86 1.00 0.00 92928571
+ 0.86 1.00 0.00 100000000
+ 0.86 1.00 0.07 1000000
+ 0.86 1.00 0.07 8071429
+ 0.86 1.00 0.07 15142857
+ 0.86 1.00 0.07 22214286
+ 0.86 1.00 0.07 29285714
+ 0.86 1.00 0.07 36357143
+ 0.86 1.00 0.07 43428571
+ 0.86 1.00 0.07 50500000
+ 0.86 1.00 0.07 57571429
+ 0.86 1.00 0.07 64642857
+ 0.86 1.00 0.07 71714286
+ 0.86 1.00 0.07 78785714
+ 0.86 1.00 0.07 85857143
+ 0.86 1.00 0.07 92928571
+ 0.86 1.00 0.07 100000000
+ 0.86 1.00 0.14 1000000
+ 0.86 1.00 0.14 8071429
+ 0.86 1.00 0.14 15142857
+ 0.86 1.00 0.14 22214286
+ 0.86 1.00 0.14 29285714
+ 0.86 1.00 0.14 36357143
+ 0.86 1.00 0.14 43428571
+ 0.86 1.00 0.14 50500000
+ 0.86 1.00 0.14 57571429
+ 0.86 1.00 0.14 64642857
+ 0.86 1.00 0.14 71714286
+ 0.86 1.00 0.14 78785714
+ 0.86 1.00 0.14 85857143
+ 0.86 1.00 0.14 92928571
+ 0.86 1.00 0.14 100000000
+ 0.86 1.00 0.21 1000000
+ 0.86 1.00 0.21 8071429
+ 0.86 1.00 0.21 15142857
+ 0.86 1.00 0.21 22214286
+ 0.86 1.00 0.21 29285714
+ 0.86 1.00 0.21 36357143
+ 0.86 1.00 0.21 43428571
+ 0.86 1.00 0.21 50500000
+ 0.86 1.00 0.21 57571429
+ 0.86 1.00 0.21 64642857
+ 0.86 1.00 0.21 71714286
+ 0.86 1.00 0.21 78785714
+ 0.86 1.00 0.21 85857143
+ 0.86 1.00 0.21 92928571
+ 0.86 1.00 0.21 100000000
+ 0.86 1.00 0.29 1000000
+ 0.86 1.00 0.29 8071429
+ 0.86 1.00 0.29 15142857
+ 0.86 1.00 0.29 22214286
+ 0.86 1.00 0.29 29285714
+ 0.86 1.00 0.29 36357143
+ 0.86 1.00 0.29 43428571
+ 0.86 1.00 0.29 50500000
+ 0.86 1.00 0.29 57571429
+ 0.86 1.00 0.29 64642857
+ 0.86 1.00 0.29 71714286
+ 0.86 1.00 0.29 78785714
+ 0.86 1.00 0.29 85857143
+ 0.86 1.00 0.29 92928571
+ 0.86 1.00 0.29 100000000
+ 0.86 1.00 0.36 1000000
+ 0.86 1.00 0.36 8071429
+ 0.86 1.00 0.36 15142857
+ 0.86 1.00 0.36 22214286
+ 0.86 1.00 0.36 29285714
+ 0.86 1.00 0.36 36357143
+ 0.86 1.00 0.36 43428571
+ 0.86 1.00 0.36 50500000
+ 0.86 1.00 0.36 57571429
+ 0.86 1.00 0.36 64642857
+ 0.86 1.00 0.36 71714286
+ 0.86 1.00 0.36 78785714
+ 0.86 1.00 0.36 85857143
+ 0.86 1.00 0.36 92928571
+ 0.86 1.00 0.36 100000000
+ 0.86 1.00 0.43 1000000
+ 0.86 1.00 0.43 8071429
+ 0.86 1.00 0.43 15142857
+ 0.86 1.00 0.43 22214286
+ 0.86 1.00 0.43 29285714
+ 0.86 1.00 0.43 36357143
+ 0.86 1.00 0.43 43428571
+ 0.86 1.00 0.43 50500000
+ 0.86 1.00 0.43 57571429
+ 0.86 1.00 0.43 64642857
+ 0.86 1.00 0.43 71714286
+ 0.86 1.00 0.43 78785714
+ 0.86 1.00 0.43 85857143
+ 0.86 1.00 0.43 92928571
+ 0.86 1.00 0.43 100000000
+ 0.86 1.00 0.50 1000000
+ 0.86 1.00 0.50 8071429
+ 0.86 1.00 0.50 15142857
+ 0.86 1.00 0.50 22214286
+ 0.86 1.00 0.50 29285714
+ 0.86 1.00 0.50 36357143
+ 0.86 1.00 0.50 43428571
+ 0.86 1.00 0.50 50500000
+ 0.86 1.00 0.50 57571429
+ 0.86 1.00 0.50 64642857
+ 0.86 1.00 0.50 71714286
+ 0.86 1.00 0.50 78785714
+ 0.86 1.00 0.50 85857143
+ 0.86 1.00 0.50 92928571
+ 0.86 1.00 0.50 100000000
+ 0.86 1.00 0.57 1000000
+ 0.86 1.00 0.57 8071429
+ 0.86 1.00 0.57 15142857
+ 0.86 1.00 0.57 22214286
+ 0.86 1.00 0.57 29285714
+ 0.86 1.00 0.57 36357143
+ 0.86 1.00 0.57 43428571
+ 0.86 1.00 0.57 50500000
+ 0.86 1.00 0.57 57571429
+ 0.86 1.00 0.57 64642857
+ 0.86 1.00 0.57 71714286
+ 0.86 1.00 0.57 78785714
+ 0.86 1.00 0.57 85857143
+ 0.86 1.00 0.57 92928571
+ 0.86 1.00 0.57 100000000
+ 0.86 1.00 0.64 1000000
+ 0.86 1.00 0.64 8071429
+ 0.86 1.00 0.64 15142857
+ 0.86 1.00 0.64 22214286
+ 0.86 1.00 0.64 29285714
+ 0.86 1.00 0.64 36357143
+ 0.86 1.00 0.64 43428571
+ 0.86 1.00 0.64 50500000
+ 0.86 1.00 0.64 57571429
+ 0.86 1.00 0.64 64642857
+ 0.86 1.00 0.64 71714286
+ 0.86 1.00 0.64 78785714
+ 0.86 1.00 0.64 85857143
+ 0.86 1.00 0.64 92928571
+ 0.86 1.00 0.64 100000000
+ 0.86 1.00 0.71 1000000
+ 0.86 1.00 0.71 8071429
+ 0.86 1.00 0.71 15142857
+ 0.86 1.00 0.71 22214286
+ 0.86 1.00 0.71 29285714
+ 0.86 1.00 0.71 36357143
+ 0.86 1.00 0.71 43428571
+ 0.86 1.00 0.71 50500000
+ 0.86 1.00 0.71 57571429
+ 0.86 1.00 0.71 64642857
+ 0.86 1.00 0.71 71714286
+ 0.86 1.00 0.71 78785714
+ 0.86 1.00 0.71 85857143
+ 0.86 1.00 0.71 92928571
+ 0.86 1.00 0.71 100000000
+ 0.86 1.00 0.79 1000000
+ 0.86 1.00 0.79 8071429
+ 0.86 1.00 0.79 15142857
+ 0.86 1.00 0.79 22214286
+ 0.86 1.00 0.79 29285714
+ 0.86 1.00 0.79 36357143
+ 0.86 1.00 0.79 43428571
+ 0.86 1.00 0.79 50500000
+ 0.86 1.00 0.79 57571429
+ 0.86 1.00 0.79 64642857
+ 0.86 1.00 0.79 71714286
+ 0.86 1.00 0.79 78785714
+ 0.86 1.00 0.79 85857143
+ 0.86 1.00 0.79 92928571
+ 0.86 1.00 0.79 100000000
+ 0.86 1.00 0.86 1000000
+ 0.86 1.00 0.86 8071429
+ 0.86 1.00 0.86 15142857
+ 0.86 1.00 0.86 22214286
+ 0.86 1.00 0.86 29285714
+ 0.86 1.00 0.86 36357143
+ 0.86 1.00 0.86 43428571
+ 0.86 1.00 0.86 50500000
+ 0.86 1.00 0.86 57571429
+ 0.86 1.00 0.86 64642857
+ 0.86 1.00 0.86 71714286
+ 0.86 1.00 0.86 78785714
+ 0.86 1.00 0.86 85857143
+ 0.86 1.00 0.86 92928571
+ 0.86 1.00 0.86 100000000
+ 0.86 1.00 0.93 1000000
+ 0.86 1.00 0.93 8071429
+ 0.86 1.00 0.93 15142857
+ 0.86 1.00 0.93 22214286
+ 0.86 1.00 0.93 29285714
+ 0.86 1.00 0.93 36357143
+ 0.86 1.00 0.93 43428571
+ 0.86 1.00 0.93 50500000
+ 0.86 1.00 0.93 57571429
+ 0.86 1.00 0.93 64642857
+ 0.86 1.00 0.93 71714286
+ 0.86 1.00 0.93 78785714
+ 0.86 1.00 0.93 85857143
+ 0.86 1.00 0.93 92928571
+ 0.86 1.00 0.93 100000000
+ 0.86 1.00 1.00 1000000
+ 0.86 1.00 1.00 8071429
+ 0.86 1.00 1.00 15142857
+ 0.86 1.00 1.00 22214286
+ 0.86 1.00 1.00 29285714
+ 0.86 1.00 1.00 36357143
+ 0.86 1.00 1.00 43428571
+ 0.86 1.00 1.00 50500000
+ 0.86 1.00 1.00 57571429
+ 0.86 1.00 1.00 64642857
+ 0.86 1.00 1.00 71714286
+ 0.86 1.00 1.00 78785714
+ 0.86 1.00 1.00 85857143
+ 0.86 1.00 1.00 92928571
+ 0.86 1.00 1.00 100000000
+ 0.93 0.00 0.00 1000000
+ 0.93 0.00 0.00 8071429
+ 0.93 0.00 0.00 15142857
+ 0.93 0.00 0.00 22214286
+ 0.93 0.00 0.00 29285714
+ 0.93 0.00 0.00 36357143
+ 0.93 0.00 0.00 43428571
+ 0.93 0.00 0.00 50500000
+ 0.93 0.00 0.00 57571429
+ 0.93 0.00 0.00 64642857
+ 0.93 0.00 0.00 71714286
+ 0.93 0.00 0.00 78785714
+ 0.93 0.00 0.00 85857143
+ 0.93 0.00 0.00 92928571
+ 0.93 0.00 0.00 100000000
+ 0.93 0.00 0.07 1000000
+ 0.93 0.00 0.07 8071429
+ 0.93 0.00 0.07 15142857
+ 0.93 0.00 0.07 22214286
+ 0.93 0.00 0.07 29285714
+ 0.93 0.00 0.07 36357143
+ 0.93 0.00 0.07 43428571
+ 0.93 0.00 0.07 50500000
+ 0.93 0.00 0.07 57571429
+ 0.93 0.00 0.07 64642857
+ 0.93 0.00 0.07 71714286
+ 0.93 0.00 0.07 78785714
+ 0.93 0.00 0.07 85857143
+ 0.93 0.00 0.07 92928571
+ 0.93 0.00 0.07 100000000
+ 0.93 0.00 0.14 1000000
+ 0.93 0.00 0.14 8071429
+ 0.93 0.00 0.14 15142857
+ 0.93 0.00 0.14 22214286
+ 0.93 0.00 0.14 29285714
+ 0.93 0.00 0.14 36357143
+ 0.93 0.00 0.14 43428571
+ 0.93 0.00 0.14 50500000
+ 0.93 0.00 0.14 57571429
+ 0.93 0.00 0.14 64642857
+ 0.93 0.00 0.14 71714286
+ 0.93 0.00 0.14 78785714
+ 0.93 0.00 0.14 85857143
+ 0.93 0.00 0.14 92928571
+ 0.93 0.00 0.14 100000000
+ 0.93 0.00 0.21 1000000
+ 0.93 0.00 0.21 8071429
+ 0.93 0.00 0.21 15142857
+ 0.93 0.00 0.21 22214286
+ 0.93 0.00 0.21 29285714
+ 0.93 0.00 0.21 36357143
+ 0.93 0.00 0.21 43428571
+ 0.93 0.00 0.21 50500000
+ 0.93 0.00 0.21 57571429
+ 0.93 0.00 0.21 64642857
+ 0.93 0.00 0.21 71714286
+ 0.93 0.00 0.21 78785714
+ 0.93 0.00 0.21 85857143
+ 0.93 0.00 0.21 92928571
+ 0.93 0.00 0.21 100000000
+ 0.93 0.00 0.29 1000000
+ 0.93 0.00 0.29 8071429
+ 0.93 0.00 0.29 15142857
+ 0.93 0.00 0.29 22214286
+ 0.93 0.00 0.29 29285714
+ 0.93 0.00 0.29 36357143
+ 0.93 0.00 0.29 43428571
+ 0.93 0.00 0.29 50500000
+ 0.93 0.00 0.29 57571429
+ 0.93 0.00 0.29 64642857
+ 0.93 0.00 0.29 71714286
+ 0.93 0.00 0.29 78785714
+ 0.93 0.00 0.29 85857143
+ 0.93 0.00 0.29 92928571
+ 0.93 0.00 0.29 100000000
+ 0.93 0.00 0.36 1000000
+ 0.93 0.00 0.36 8071429
+ 0.93 0.00 0.36 15142857
+ 0.93 0.00 0.36 22214286
+ 0.93 0.00 0.36 29285714
+ 0.93 0.00 0.36 36357143
+ 0.93 0.00 0.36 43428571
+ 0.93 0.00 0.36 50500000
+ 0.93 0.00 0.36 57571429
+ 0.93 0.00 0.36 64642857
+ 0.93 0.00 0.36 71714286
+ 0.93 0.00 0.36 78785714
+ 0.93 0.00 0.36 85857143
+ 0.93 0.00 0.36 92928571
+ 0.93 0.00 0.36 100000000
+ 0.93 0.00 0.43 1000000
+ 0.93 0.00 0.43 8071429
+ 0.93 0.00 0.43 15142857
+ 0.93 0.00 0.43 22214286
+ 0.93 0.00 0.43 29285714
+ 0.93 0.00 0.43 36357143
+ 0.93 0.00 0.43 43428571
+ 0.93 0.00 0.43 50500000
+ 0.93 0.00 0.43 57571429
+ 0.93 0.00 0.43 64642857
+ 0.93 0.00 0.43 71714286
+ 0.93 0.00 0.43 78785714
+ 0.93 0.00 0.43 85857143
+ 0.93 0.00 0.43 92928571
+ 0.93 0.00 0.43 100000000
+ 0.93 0.00 0.50 1000000
+ 0.93 0.00 0.50 8071429
+ 0.93 0.00 0.50 15142857
+ 0.93 0.00 0.50 22214286
+ 0.93 0.00 0.50 29285714
+ 0.93 0.00 0.50 36357143
+ 0.93 0.00 0.50 43428571
+ 0.93 0.00 0.50 50500000
+ 0.93 0.00 0.50 57571429
+ 0.93 0.00 0.50 64642857
+ 0.93 0.00 0.50 71714286
+ 0.93 0.00 0.50 78785714
+ 0.93 0.00 0.50 85857143
+ 0.93 0.00 0.50 92928571
+ 0.93 0.00 0.50 100000000
+ 0.93 0.00 0.57 1000000
+ 0.93 0.00 0.57 8071429
+ 0.93 0.00 0.57 15142857
+ 0.93 0.00 0.57 22214286
+ 0.93 0.00 0.57 29285714
+ 0.93 0.00 0.57 36357143
+ 0.93 0.00 0.57 43428571
+ 0.93 0.00 0.57 50500000
+ 0.93 0.00 0.57 57571429
+ 0.93 0.00 0.57 64642857
+ 0.93 0.00 0.57 71714286
+ 0.93 0.00 0.57 78785714
+ 0.93 0.00 0.57 85857143
+ 0.93 0.00 0.57 92928571
+ 0.93 0.00 0.57 100000000
+ 0.93 0.00 0.64 1000000
+ 0.93 0.00 0.64 8071429
+ 0.93 0.00 0.64 15142857
+ 0.93 0.00 0.64 22214286
+ 0.93 0.00 0.64 29285714
+ 0.93 0.00 0.64 36357143
+ 0.93 0.00 0.64 43428571
+ 0.93 0.00 0.64 50500000
+ 0.93 0.00 0.64 57571429
+ 0.93 0.00 0.64 64642857
+ 0.93 0.00 0.64 71714286
+ 0.93 0.00 0.64 78785714
+ 0.93 0.00 0.64 85857143
+ 0.93 0.00 0.64 92928571
+ 0.93 0.00 0.64 100000000
+ 0.93 0.00 0.71 1000000
+ 0.93 0.00 0.71 8071429
+ 0.93 0.00 0.71 15142857
+ 0.93 0.00 0.71 22214286
+ 0.93 0.00 0.71 29285714
+ 0.93 0.00 0.71 36357143
+ 0.93 0.00 0.71 43428571
+ 0.93 0.00 0.71 50500000
+ 0.93 0.00 0.71 57571429
+ 0.93 0.00 0.71 64642857
+ 0.93 0.00 0.71 71714286
+ 0.93 0.00 0.71 78785714
+ 0.93 0.00 0.71 85857143
+ 0.93 0.00 0.71 92928571
+ 0.93 0.00 0.71 100000000
+ 0.93 0.00 0.79 1000000
+ 0.93 0.00 0.79 8071429
+ 0.93 0.00 0.79 15142857
+ 0.93 0.00 0.79 22214286
+ 0.93 0.00 0.79 29285714
+ 0.93 0.00 0.79 36357143
+ 0.93 0.00 0.79 43428571
+ 0.93 0.00 0.79 50500000
+ 0.93 0.00 0.79 57571429
+ 0.93 0.00 0.79 64642857
+ 0.93 0.00 0.79 71714286
+ 0.93 0.00 0.79 78785714
+ 0.93 0.00 0.79 85857143
+ 0.93 0.00 0.79 92928571
+ 0.93 0.00 0.79 100000000
+ 0.93 0.00 0.86 1000000
+ 0.93 0.00 0.86 8071429
+ 0.93 0.00 0.86 15142857
+ 0.93 0.00 0.86 22214286
+ 0.93 0.00 0.86 29285714
+ 0.93 0.00 0.86 36357143
+ 0.93 0.00 0.86 43428571
+ 0.93 0.00 0.86 50500000
+ 0.93 0.00 0.86 57571429
+ 0.93 0.00 0.86 64642857
+ 0.93 0.00 0.86 71714286
+ 0.93 0.00 0.86 78785714
+ 0.93 0.00 0.86 85857143
+ 0.93 0.00 0.86 92928571
+ 0.93 0.00 0.86 100000000
+ 0.93 0.00 0.93 1000000
+ 0.93 0.00 0.93 8071429
+ 0.93 0.00 0.93 15142857
+ 0.93 0.00 0.93 22214286
+ 0.93 0.00 0.93 29285714
+ 0.93 0.00 0.93 36357143
+ 0.93 0.00 0.93 43428571
+ 0.93 0.00 0.93 50500000
+ 0.93 0.00 0.93 57571429
+ 0.93 0.00 0.93 64642857
+ 0.93 0.00 0.93 71714286
+ 0.93 0.00 0.93 78785714
+ 0.93 0.00 0.93 85857143
+ 0.93 0.00 0.93 92928571
+ 0.93 0.00 0.93 100000000
+ 0.93 0.00 1.00 1000000
+ 0.93 0.00 1.00 8071429
+ 0.93 0.00 1.00 15142857
+ 0.93 0.00 1.00 22214286
+ 0.93 0.00 1.00 29285714
+ 0.93 0.00 1.00 36357143
+ 0.93 0.00 1.00 43428571
+ 0.93 0.00 1.00 50500000
+ 0.93 0.00 1.00 57571429
+ 0.93 0.00 1.00 64642857
+ 0.93 0.00 1.00 71714286
+ 0.93 0.00 1.00 78785714
+ 0.93 0.00 1.00 85857143
+ 0.93 0.00 1.00 92928571
+ 0.93 0.00 1.00 100000000
+ 0.93 0.07 0.00 1000000
+ 0.93 0.07 0.00 8071429
+ 0.93 0.07 0.00 15142857
+ 0.93 0.07 0.00 22214286
+ 0.93 0.07 0.00 29285714
+ 0.93 0.07 0.00 36357143
+ 0.93 0.07 0.00 43428571
+ 0.93 0.07 0.00 50500000
+ 0.93 0.07 0.00 57571429
+ 0.93 0.07 0.00 64642857
+ 0.93 0.07 0.00 71714286
+ 0.93 0.07 0.00 78785714
+ 0.93 0.07 0.00 85857143
+ 0.93 0.07 0.00 92928571
+ 0.93 0.07 0.00 100000000
+ 0.93 0.07 0.07 1000000
+ 0.93 0.07 0.07 8071429
+ 0.93 0.07 0.07 15142857
+ 0.93 0.07 0.07 22214286
+ 0.93 0.07 0.07 29285714
+ 0.93 0.07 0.07 36357143
+ 0.93 0.07 0.07 43428571
+ 0.93 0.07 0.07 50500000
+ 0.93 0.07 0.07 57571429
+ 0.93 0.07 0.07 64642857
+ 0.93 0.07 0.07 71714286
+ 0.93 0.07 0.07 78785714
+ 0.93 0.07 0.07 85857143
+ 0.93 0.07 0.07 92928571
+ 0.93 0.07 0.07 100000000
+ 0.93 0.07 0.14 1000000
+ 0.93 0.07 0.14 8071429
+ 0.93 0.07 0.14 15142857
+ 0.93 0.07 0.14 22214286
+ 0.93 0.07 0.14 29285714
+ 0.93 0.07 0.14 36357143
+ 0.93 0.07 0.14 43428571
+ 0.93 0.07 0.14 50500000
+ 0.93 0.07 0.14 57571429
+ 0.93 0.07 0.14 64642857
+ 0.93 0.07 0.14 71714286
+ 0.93 0.07 0.14 78785714
+ 0.93 0.07 0.14 85857143
+ 0.93 0.07 0.14 92928571
+ 0.93 0.07 0.14 100000000
+ 0.93 0.07 0.21 1000000
+ 0.93 0.07 0.21 8071429
+ 0.93 0.07 0.21 15142857
+ 0.93 0.07 0.21 22214286
+ 0.93 0.07 0.21 29285714
+ 0.93 0.07 0.21 36357143
+ 0.93 0.07 0.21 43428571
+ 0.93 0.07 0.21 50500000
+ 0.93 0.07 0.21 57571429
+ 0.93 0.07 0.21 64642857
+ 0.93 0.07 0.21 71714286
+ 0.93 0.07 0.21 78785714
+ 0.93 0.07 0.21 85857143
+ 0.93 0.07 0.21 92928571
+ 0.93 0.07 0.21 100000000
+ 0.93 0.07 0.29 1000000
+ 0.93 0.07 0.29 8071429
+ 0.93 0.07 0.29 15142857
+ 0.93 0.07 0.29 22214286
+ 0.93 0.07 0.29 29285714
+ 0.93 0.07 0.29 36357143
+ 0.93 0.07 0.29 43428571
+ 0.93 0.07 0.29 50500000
+ 0.93 0.07 0.29 57571429
+ 0.93 0.07 0.29 64642857
+ 0.93 0.07 0.29 71714286
+ 0.93 0.07 0.29 78785714
+ 0.93 0.07 0.29 85857143
+ 0.93 0.07 0.29 92928571
+ 0.93 0.07 0.29 100000000
+ 0.93 0.07 0.36 1000000
+ 0.93 0.07 0.36 8071429
+ 0.93 0.07 0.36 15142857
+ 0.93 0.07 0.36 22214286
+ 0.93 0.07 0.36 29285714
+ 0.93 0.07 0.36 36357143
+ 0.93 0.07 0.36 43428571
+ 0.93 0.07 0.36 50500000
+ 0.93 0.07 0.36 57571429
+ 0.93 0.07 0.36 64642857
+ 0.93 0.07 0.36 71714286
+ 0.93 0.07 0.36 78785714
+ 0.93 0.07 0.36 85857143
+ 0.93 0.07 0.36 92928571
+ 0.93 0.07 0.36 100000000
+ 0.93 0.07 0.43 1000000
+ 0.93 0.07 0.43 8071429
+ 0.93 0.07 0.43 15142857
+ 0.93 0.07 0.43 22214286
+ 0.93 0.07 0.43 29285714
+ 0.93 0.07 0.43 36357143
+ 0.93 0.07 0.43 43428571
+ 0.93 0.07 0.43 50500000
+ 0.93 0.07 0.43 57571429
+ 0.93 0.07 0.43 64642857
+ 0.93 0.07 0.43 71714286
+ 0.93 0.07 0.43 78785714
+ 0.93 0.07 0.43 85857143
+ 0.93 0.07 0.43 92928571
+ 0.93 0.07 0.43 100000000
+ 0.93 0.07 0.50 1000000
+ 0.93 0.07 0.50 8071429
+ 0.93 0.07 0.50 15142857
+ 0.93 0.07 0.50 22214286
+ 0.93 0.07 0.50 29285714
+ 0.93 0.07 0.50 36357143
+ 0.93 0.07 0.50 43428571
+ 0.93 0.07 0.50 50500000
+ 0.93 0.07 0.50 57571429
+ 0.93 0.07 0.50 64642857
+ 0.93 0.07 0.50 71714286
+ 0.93 0.07 0.50 78785714
+ 0.93 0.07 0.50 85857143
+ 0.93 0.07 0.50 92928571
+ 0.93 0.07 0.50 100000000
+ 0.93 0.07 0.57 1000000
+ 0.93 0.07 0.57 8071429
+ 0.93 0.07 0.57 15142857
+ 0.93 0.07 0.57 22214286
+ 0.93 0.07 0.57 29285714
+ 0.93 0.07 0.57 36357143
+ 0.93 0.07 0.57 43428571
+ 0.93 0.07 0.57 50500000
+ 0.93 0.07 0.57 57571429
+ 0.93 0.07 0.57 64642857
+ 0.93 0.07 0.57 71714286
+ 0.93 0.07 0.57 78785714
+ 0.93 0.07 0.57 85857143
+ 0.93 0.07 0.57 92928571
+ 0.93 0.07 0.57 100000000
+ 0.93 0.07 0.64 1000000
+ 0.93 0.07 0.64 8071429
+ 0.93 0.07 0.64 15142857
+ 0.93 0.07 0.64 22214286
+ 0.93 0.07 0.64 29285714
+ 0.93 0.07 0.64 36357143
+ 0.93 0.07 0.64 43428571
+ 0.93 0.07 0.64 50500000
+ 0.93 0.07 0.64 57571429
+ 0.93 0.07 0.64 64642857
+ 0.93 0.07 0.64 71714286
+ 0.93 0.07 0.64 78785714
+ 0.93 0.07 0.64 85857143
+ 0.93 0.07 0.64 92928571
+ 0.93 0.07 0.64 100000000
+ 0.93 0.07 0.71 1000000
+ 0.93 0.07 0.71 8071429
+ 0.93 0.07 0.71 15142857
+ 0.93 0.07 0.71 22214286
+ 0.93 0.07 0.71 29285714
+ 0.93 0.07 0.71 36357143
+ 0.93 0.07 0.71 43428571
+ 0.93 0.07 0.71 50500000
+ 0.93 0.07 0.71 57571429
+ 0.93 0.07 0.71 64642857
+ 0.93 0.07 0.71 71714286
+ 0.93 0.07 0.71 78785714
+ 0.93 0.07 0.71 85857143
+ 0.93 0.07 0.71 92928571
+ 0.93 0.07 0.71 100000000
+ 0.93 0.07 0.79 1000000
+ 0.93 0.07 0.79 8071429
+ 0.93 0.07 0.79 15142857
+ 0.93 0.07 0.79 22214286
+ 0.93 0.07 0.79 29285714
+ 0.93 0.07 0.79 36357143
+ 0.93 0.07 0.79 43428571
+ 0.93 0.07 0.79 50500000
+ 0.93 0.07 0.79 57571429
+ 0.93 0.07 0.79 64642857
+ 0.93 0.07 0.79 71714286
+ 0.93 0.07 0.79 78785714
+ 0.93 0.07 0.79 85857143
+ 0.93 0.07 0.79 92928571
+ 0.93 0.07 0.79 100000000
+ 0.93 0.07 0.86 1000000
+ 0.93 0.07 0.86 8071429
+ 0.93 0.07 0.86 15142857
+ 0.93 0.07 0.86 22214286
+ 0.93 0.07 0.86 29285714
+ 0.93 0.07 0.86 36357143
+ 0.93 0.07 0.86 43428571
+ 0.93 0.07 0.86 50500000
+ 0.93 0.07 0.86 57571429
+ 0.93 0.07 0.86 64642857
+ 0.93 0.07 0.86 71714286
+ 0.93 0.07 0.86 78785714
+ 0.93 0.07 0.86 85857143
+ 0.93 0.07 0.86 92928571
+ 0.93 0.07 0.86 100000000
+ 0.93 0.07 0.93 1000000
+ 0.93 0.07 0.93 8071429
+ 0.93 0.07 0.93 15142857
+ 0.93 0.07 0.93 22214286
+ 0.93 0.07 0.93 29285714
+ 0.93 0.07 0.93 36357143
+ 0.93 0.07 0.93 43428571
+ 0.93 0.07 0.93 50500000
+ 0.93 0.07 0.93 57571429
+ 0.93 0.07 0.93 64642857
+ 0.93 0.07 0.93 71714286
+ 0.93 0.07 0.93 78785714
+ 0.93 0.07 0.93 85857143
+ 0.93 0.07 0.93 92928571
+ 0.93 0.07 0.93 100000000
+ 0.93 0.07 1.00 1000000
+ 0.93 0.07 1.00 8071429
+ 0.93 0.07 1.00 15142857
+ 0.93 0.07 1.00 22214286
+ 0.93 0.07 1.00 29285714
+ 0.93 0.07 1.00 36357143
+ 0.93 0.07 1.00 43428571
+ 0.93 0.07 1.00 50500000
+ 0.93 0.07 1.00 57571429
+ 0.93 0.07 1.00 64642857
+ 0.93 0.07 1.00 71714286
+ 0.93 0.07 1.00 78785714
+ 0.93 0.07 1.00 85857143
+ 0.93 0.07 1.00 92928571
+ 0.93 0.07 1.00 100000000
+ 0.93 0.14 0.00 1000000
+ 0.93 0.14 0.00 8071429
+ 0.93 0.14 0.00 15142857
+ 0.93 0.14 0.00 22214286
+ 0.93 0.14 0.00 29285714
+ 0.93 0.14 0.00 36357143
+ 0.93 0.14 0.00 43428571
+ 0.93 0.14 0.00 50500000
+ 0.93 0.14 0.00 57571429
+ 0.93 0.14 0.00 64642857
+ 0.93 0.14 0.00 71714286
+ 0.93 0.14 0.00 78785714
+ 0.93 0.14 0.00 85857143
+ 0.93 0.14 0.00 92928571
+ 0.93 0.14 0.00 100000000
+ 0.93 0.14 0.07 1000000
+ 0.93 0.14 0.07 8071429
+ 0.93 0.14 0.07 15142857
+ 0.93 0.14 0.07 22214286
+ 0.93 0.14 0.07 29285714
+ 0.93 0.14 0.07 36357143
+ 0.93 0.14 0.07 43428571
+ 0.93 0.14 0.07 50500000
+ 0.93 0.14 0.07 57571429
+ 0.93 0.14 0.07 64642857
+ 0.93 0.14 0.07 71714286
+ 0.93 0.14 0.07 78785714
+ 0.93 0.14 0.07 85857143
+ 0.93 0.14 0.07 92928571
+ 0.93 0.14 0.07 100000000
+ 0.93 0.14 0.14 1000000
+ 0.93 0.14 0.14 8071429
+ 0.93 0.14 0.14 15142857
+ 0.93 0.14 0.14 22214286
+ 0.93 0.14 0.14 29285714
+ 0.93 0.14 0.14 36357143
+ 0.93 0.14 0.14 43428571
+ 0.93 0.14 0.14 50500000
+ 0.93 0.14 0.14 57571429
+ 0.93 0.14 0.14 64642857
+ 0.93 0.14 0.14 71714286
+ 0.93 0.14 0.14 78785714
+ 0.93 0.14 0.14 85857143
+ 0.93 0.14 0.14 92928571
+ 0.93 0.14 0.14 100000000
+ 0.93 0.14 0.21 1000000
+ 0.93 0.14 0.21 8071429
+ 0.93 0.14 0.21 15142857
+ 0.93 0.14 0.21 22214286
+ 0.93 0.14 0.21 29285714
+ 0.93 0.14 0.21 36357143
+ 0.93 0.14 0.21 43428571
+ 0.93 0.14 0.21 50500000
+ 0.93 0.14 0.21 57571429
+ 0.93 0.14 0.21 64642857
+ 0.93 0.14 0.21 71714286
+ 0.93 0.14 0.21 78785714
+ 0.93 0.14 0.21 85857143
+ 0.93 0.14 0.21 92928571
+ 0.93 0.14 0.21 100000000
+ 0.93 0.14 0.29 1000000
+ 0.93 0.14 0.29 8071429
+ 0.93 0.14 0.29 15142857
+ 0.93 0.14 0.29 22214286
+ 0.93 0.14 0.29 29285714
+ 0.93 0.14 0.29 36357143
+ 0.93 0.14 0.29 43428571
+ 0.93 0.14 0.29 50500000
+ 0.93 0.14 0.29 57571429
+ 0.93 0.14 0.29 64642857
+ 0.93 0.14 0.29 71714286
+ 0.93 0.14 0.29 78785714
+ 0.93 0.14 0.29 85857143
+ 0.93 0.14 0.29 92928571
+ 0.93 0.14 0.29 100000000
+ 0.93 0.14 0.36 1000000
+ 0.93 0.14 0.36 8071429
+ 0.93 0.14 0.36 15142857
+ 0.93 0.14 0.36 22214286
+ 0.93 0.14 0.36 29285714
+ 0.93 0.14 0.36 36357143
+ 0.93 0.14 0.36 43428571
+ 0.93 0.14 0.36 50500000
+ 0.93 0.14 0.36 57571429
+ 0.93 0.14 0.36 64642857
+ 0.93 0.14 0.36 71714286
+ 0.93 0.14 0.36 78785714
+ 0.93 0.14 0.36 85857143
+ 0.93 0.14 0.36 92928571
+ 0.93 0.14 0.36 100000000
+ 0.93 0.14 0.43 1000000
+ 0.93 0.14 0.43 8071429
+ 0.93 0.14 0.43 15142857
+ 0.93 0.14 0.43 22214286
+ 0.93 0.14 0.43 29285714
+ 0.93 0.14 0.43 36357143
+ 0.93 0.14 0.43 43428571
+ 0.93 0.14 0.43 50500000
+ 0.93 0.14 0.43 57571429
+ 0.93 0.14 0.43 64642857
+ 0.93 0.14 0.43 71714286
+ 0.93 0.14 0.43 78785714
+ 0.93 0.14 0.43 85857143
+ 0.93 0.14 0.43 92928571
+ 0.93 0.14 0.43 100000000
+ 0.93 0.14 0.50 1000000
+ 0.93 0.14 0.50 8071429
+ 0.93 0.14 0.50 15142857
+ 0.93 0.14 0.50 22214286
+ 0.93 0.14 0.50 29285714
+ 0.93 0.14 0.50 36357143
+ 0.93 0.14 0.50 43428571
+ 0.93 0.14 0.50 50500000
+ 0.93 0.14 0.50 57571429
+ 0.93 0.14 0.50 64642857
+ 0.93 0.14 0.50 71714286
+ 0.93 0.14 0.50 78785714
+ 0.93 0.14 0.50 85857143
+ 0.93 0.14 0.50 92928571
+ 0.93 0.14 0.50 100000000
+ 0.93 0.14 0.57 1000000
+ 0.93 0.14 0.57 8071429
+ 0.93 0.14 0.57 15142857
+ 0.93 0.14 0.57 22214286
+ 0.93 0.14 0.57 29285714
+ 0.93 0.14 0.57 36357143
+ 0.93 0.14 0.57 43428571
+ 0.93 0.14 0.57 50500000
+ 0.93 0.14 0.57 57571429
+ 0.93 0.14 0.57 64642857
+ 0.93 0.14 0.57 71714286
+ 0.93 0.14 0.57 78785714
+ 0.93 0.14 0.57 85857143
+ 0.93 0.14 0.57 92928571
+ 0.93 0.14 0.57 100000000
+ 0.93 0.14 0.64 1000000
+ 0.93 0.14 0.64 8071429
+ 0.93 0.14 0.64 15142857
+ 0.93 0.14 0.64 22214286
+ 0.93 0.14 0.64 29285714
+ 0.93 0.14 0.64 36357143
+ 0.93 0.14 0.64 43428571
+ 0.93 0.14 0.64 50500000
+ 0.93 0.14 0.64 57571429
+ 0.93 0.14 0.64 64642857
+ 0.93 0.14 0.64 71714286
+ 0.93 0.14 0.64 78785714
+ 0.93 0.14 0.64 85857143
+ 0.93 0.14 0.64 92928571
+ 0.93 0.14 0.64 100000000
+ 0.93 0.14 0.71 1000000
+ 0.93 0.14 0.71 8071429
+ 0.93 0.14 0.71 15142857
+ 0.93 0.14 0.71 22214286
+ 0.93 0.14 0.71 29285714
+ 0.93 0.14 0.71 36357143
+ 0.93 0.14 0.71 43428571
+ 0.93 0.14 0.71 50500000
+ 0.93 0.14 0.71 57571429
+ 0.93 0.14 0.71 64642857
+ 0.93 0.14 0.71 71714286
+ 0.93 0.14 0.71 78785714
+ 0.93 0.14 0.71 85857143
+ 0.93 0.14 0.71 92928571
+ 0.93 0.14 0.71 100000000
+ 0.93 0.14 0.79 1000000
+ 0.93 0.14 0.79 8071429
+ 0.93 0.14 0.79 15142857
+ 0.93 0.14 0.79 22214286
+ 0.93 0.14 0.79 29285714
+ 0.93 0.14 0.79 36357143
+ 0.93 0.14 0.79 43428571
+ 0.93 0.14 0.79 50500000
+ 0.93 0.14 0.79 57571429
+ 0.93 0.14 0.79 64642857
+ 0.93 0.14 0.79 71714286
+ 0.93 0.14 0.79 78785714
+ 0.93 0.14 0.79 85857143
+ 0.93 0.14 0.79 92928571
+ 0.93 0.14 0.79 100000000
+ 0.93 0.14 0.86 1000000
+ 0.93 0.14 0.86 8071429
+ 0.93 0.14 0.86 15142857
+ 0.93 0.14 0.86 22214286
+ 0.93 0.14 0.86 29285714
+ 0.93 0.14 0.86 36357143
+ 0.93 0.14 0.86 43428571
+ 0.93 0.14 0.86 50500000
+ 0.93 0.14 0.86 57571429
+ 0.93 0.14 0.86 64642857
+ 0.93 0.14 0.86 71714286
+ 0.93 0.14 0.86 78785714
+ 0.93 0.14 0.86 85857143
+ 0.93 0.14 0.86 92928571
+ 0.93 0.14 0.86 100000000
+ 0.93 0.14 0.93 1000000
+ 0.93 0.14 0.93 8071429
+ 0.93 0.14 0.93 15142857
+ 0.93 0.14 0.93 22214286
+ 0.93 0.14 0.93 29285714
+ 0.93 0.14 0.93 36357143
+ 0.93 0.14 0.93 43428571
+ 0.93 0.14 0.93 50500000
+ 0.93 0.14 0.93 57571429
+ 0.93 0.14 0.93 64642857
+ 0.93 0.14 0.93 71714286
+ 0.93 0.14 0.93 78785714
+ 0.93 0.14 0.93 85857143
+ 0.93 0.14 0.93 92928571
+ 0.93 0.14 0.93 100000000
+ 0.93 0.14 1.00 1000000
+ 0.93 0.14 1.00 8071429
+ 0.93 0.14 1.00 15142857
+ 0.93 0.14 1.00 22214286
+ 0.93 0.14 1.00 29285714
+ 0.93 0.14 1.00 36357143
+ 0.93 0.14 1.00 43428571
+ 0.93 0.14 1.00 50500000
+ 0.93 0.14 1.00 57571429
+ 0.93 0.14 1.00 64642857
+ 0.93 0.14 1.00 71714286
+ 0.93 0.14 1.00 78785714
+ 0.93 0.14 1.00 85857143
+ 0.93 0.14 1.00 92928571
+ 0.93 0.14 1.00 100000000
+ 0.93 0.21 0.00 1000000
+ 0.93 0.21 0.00 8071429
+ 0.93 0.21 0.00 15142857
+ 0.93 0.21 0.00 22214286
+ 0.93 0.21 0.00 29285714
+ 0.93 0.21 0.00 36357143
+ 0.93 0.21 0.00 43428571
+ 0.93 0.21 0.00 50500000
+ 0.93 0.21 0.00 57571429
+ 0.93 0.21 0.00 64642857
+ 0.93 0.21 0.00 71714286
+ 0.93 0.21 0.00 78785714
+ 0.93 0.21 0.00 85857143
+ 0.93 0.21 0.00 92928571
+ 0.93 0.21 0.00 100000000
+ 0.93 0.21 0.07 1000000
+ 0.93 0.21 0.07 8071429
+ 0.93 0.21 0.07 15142857
+ 0.93 0.21 0.07 22214286
+ 0.93 0.21 0.07 29285714
+ 0.93 0.21 0.07 36357143
+ 0.93 0.21 0.07 43428571
+ 0.93 0.21 0.07 50500000
+ 0.93 0.21 0.07 57571429
+ 0.93 0.21 0.07 64642857
+ 0.93 0.21 0.07 71714286
+ 0.93 0.21 0.07 78785714
+ 0.93 0.21 0.07 85857143
+ 0.93 0.21 0.07 92928571
+ 0.93 0.21 0.07 100000000
+ 0.93 0.21 0.14 1000000
+ 0.93 0.21 0.14 8071429
+ 0.93 0.21 0.14 15142857
+ 0.93 0.21 0.14 22214286
+ 0.93 0.21 0.14 29285714
+ 0.93 0.21 0.14 36357143
+ 0.93 0.21 0.14 43428571
+ 0.93 0.21 0.14 50500000
+ 0.93 0.21 0.14 57571429
+ 0.93 0.21 0.14 64642857
+ 0.93 0.21 0.14 71714286
+ 0.93 0.21 0.14 78785714
+ 0.93 0.21 0.14 85857143
+ 0.93 0.21 0.14 92928571
+ 0.93 0.21 0.14 100000000
+ 0.93 0.21 0.21 1000000
+ 0.93 0.21 0.21 8071429
+ 0.93 0.21 0.21 15142857
+ 0.93 0.21 0.21 22214286
+ 0.93 0.21 0.21 29285714
+ 0.93 0.21 0.21 36357143
+ 0.93 0.21 0.21 43428571
+ 0.93 0.21 0.21 50500000
+ 0.93 0.21 0.21 57571429
+ 0.93 0.21 0.21 64642857
+ 0.93 0.21 0.21 71714286
+ 0.93 0.21 0.21 78785714
+ 0.93 0.21 0.21 85857143
+ 0.93 0.21 0.21 92928571
+ 0.93 0.21 0.21 100000000
+ 0.93 0.21 0.29 1000000
+ 0.93 0.21 0.29 8071429
+ 0.93 0.21 0.29 15142857
+ 0.93 0.21 0.29 22214286
+ 0.93 0.21 0.29 29285714
+ 0.93 0.21 0.29 36357143
+ 0.93 0.21 0.29 43428571
+ 0.93 0.21 0.29 50500000
+ 0.93 0.21 0.29 57571429
+ 0.93 0.21 0.29 64642857
+ 0.93 0.21 0.29 71714286
+ 0.93 0.21 0.29 78785714
+ 0.93 0.21 0.29 85857143
+ 0.93 0.21 0.29 92928571
+ 0.93 0.21 0.29 100000000
+ 0.93 0.21 0.36 1000000
+ 0.93 0.21 0.36 8071429
+ 0.93 0.21 0.36 15142857
+ 0.93 0.21 0.36 22214286
+ 0.93 0.21 0.36 29285714
+ 0.93 0.21 0.36 36357143
+ 0.93 0.21 0.36 43428571
+ 0.93 0.21 0.36 50500000
+ 0.93 0.21 0.36 57571429
+ 0.93 0.21 0.36 64642857
+ 0.93 0.21 0.36 71714286
+ 0.93 0.21 0.36 78785714
+ 0.93 0.21 0.36 85857143
+ 0.93 0.21 0.36 92928571
+ 0.93 0.21 0.36 100000000
+ 0.93 0.21 0.43 1000000
+ 0.93 0.21 0.43 8071429
+ 0.93 0.21 0.43 15142857
+ 0.93 0.21 0.43 22214286
+ 0.93 0.21 0.43 29285714
+ 0.93 0.21 0.43 36357143
+ 0.93 0.21 0.43 43428571
+ 0.93 0.21 0.43 50500000
+ 0.93 0.21 0.43 57571429
+ 0.93 0.21 0.43 64642857
+ 0.93 0.21 0.43 71714286
+ 0.93 0.21 0.43 78785714
+ 0.93 0.21 0.43 85857143
+ 0.93 0.21 0.43 92928571
+ 0.93 0.21 0.43 100000000
+ 0.93 0.21 0.50 1000000
+ 0.93 0.21 0.50 8071429
+ 0.93 0.21 0.50 15142857
+ 0.93 0.21 0.50 22214286
+ 0.93 0.21 0.50 29285714
+ 0.93 0.21 0.50 36357143
+ 0.93 0.21 0.50 43428571
+ 0.93 0.21 0.50 50500000
+ 0.93 0.21 0.50 57571429
+ 0.93 0.21 0.50 64642857
+ 0.93 0.21 0.50 71714286
+ 0.93 0.21 0.50 78785714
+ 0.93 0.21 0.50 85857143
+ 0.93 0.21 0.50 92928571
+ 0.93 0.21 0.50 100000000
+ 0.93 0.21 0.57 1000000
+ 0.93 0.21 0.57 8071429
+ 0.93 0.21 0.57 15142857
+ 0.93 0.21 0.57 22214286
+ 0.93 0.21 0.57 29285714
+ 0.93 0.21 0.57 36357143
+ 0.93 0.21 0.57 43428571
+ 0.93 0.21 0.57 50500000
+ 0.93 0.21 0.57 57571429
+ 0.93 0.21 0.57 64642857
+ 0.93 0.21 0.57 71714286
+ 0.93 0.21 0.57 78785714
+ 0.93 0.21 0.57 85857143
+ 0.93 0.21 0.57 92928571
+ 0.93 0.21 0.57 100000000
+ 0.93 0.21 0.64 1000000
+ 0.93 0.21 0.64 8071429
+ 0.93 0.21 0.64 15142857
+ 0.93 0.21 0.64 22214286
+ 0.93 0.21 0.64 29285714
+ 0.93 0.21 0.64 36357143
+ 0.93 0.21 0.64 43428571
+ 0.93 0.21 0.64 50500000
+ 0.93 0.21 0.64 57571429
+ 0.93 0.21 0.64 64642857
+ 0.93 0.21 0.64 71714286
+ 0.93 0.21 0.64 78785714
+ 0.93 0.21 0.64 85857143
+ 0.93 0.21 0.64 92928571
+ 0.93 0.21 0.64 100000000
+ 0.93 0.21 0.71 1000000
+ 0.93 0.21 0.71 8071429
+ 0.93 0.21 0.71 15142857
+ 0.93 0.21 0.71 22214286
+ 0.93 0.21 0.71 29285714
+ 0.93 0.21 0.71 36357143
+ 0.93 0.21 0.71 43428571
+ 0.93 0.21 0.71 50500000
+ 0.93 0.21 0.71 57571429
+ 0.93 0.21 0.71 64642857
+ 0.93 0.21 0.71 71714286
+ 0.93 0.21 0.71 78785714
+ 0.93 0.21 0.71 85857143
+ 0.93 0.21 0.71 92928571
+ 0.93 0.21 0.71 100000000
+ 0.93 0.21 0.79 1000000
+ 0.93 0.21 0.79 8071429
+ 0.93 0.21 0.79 15142857
+ 0.93 0.21 0.79 22214286
+ 0.93 0.21 0.79 29285714
+ 0.93 0.21 0.79 36357143
+ 0.93 0.21 0.79 43428571
+ 0.93 0.21 0.79 50500000
+ 0.93 0.21 0.79 57571429
+ 0.93 0.21 0.79 64642857
+ 0.93 0.21 0.79 71714286
+ 0.93 0.21 0.79 78785714
+ 0.93 0.21 0.79 85857143
+ 0.93 0.21 0.79 92928571
+ 0.93 0.21 0.79 100000000
+ 0.93 0.21 0.86 1000000
+ 0.93 0.21 0.86 8071429
+ 0.93 0.21 0.86 15142857
+ 0.93 0.21 0.86 22214286
+ 0.93 0.21 0.86 29285714
+ 0.93 0.21 0.86 36357143
+ 0.93 0.21 0.86 43428571
+ 0.93 0.21 0.86 50500000
+ 0.93 0.21 0.86 57571429
+ 0.93 0.21 0.86 64642857
+ 0.93 0.21 0.86 71714286
+ 0.93 0.21 0.86 78785714
+ 0.93 0.21 0.86 85857143
+ 0.93 0.21 0.86 92928571
+ 0.93 0.21 0.86 100000000
+ 0.93 0.21 0.93 1000000
+ 0.93 0.21 0.93 8071429
+ 0.93 0.21 0.93 15142857
+ 0.93 0.21 0.93 22214286
+ 0.93 0.21 0.93 29285714
+ 0.93 0.21 0.93 36357143
+ 0.93 0.21 0.93 43428571
+ 0.93 0.21 0.93 50500000
+ 0.93 0.21 0.93 57571429
+ 0.93 0.21 0.93 64642857
+ 0.93 0.21 0.93 71714286
+ 0.93 0.21 0.93 78785714
+ 0.93 0.21 0.93 85857143
+ 0.93 0.21 0.93 92928571
+ 0.93 0.21 0.93 100000000
+ 0.93 0.21 1.00 1000000
+ 0.93 0.21 1.00 8071429
+ 0.93 0.21 1.00 15142857
+ 0.93 0.21 1.00 22214286
+ 0.93 0.21 1.00 29285714
+ 0.93 0.21 1.00 36357143
+ 0.93 0.21 1.00 43428571
+ 0.93 0.21 1.00 50500000
+ 0.93 0.21 1.00 57571429
+ 0.93 0.21 1.00 64642857
+ 0.93 0.21 1.00 71714286
+ 0.93 0.21 1.00 78785714
+ 0.93 0.21 1.00 85857143
+ 0.93 0.21 1.00 92928571
+ 0.93 0.21 1.00 100000000
+ 0.93 0.29 0.00 1000000
+ 0.93 0.29 0.00 8071429
+ 0.93 0.29 0.00 15142857
+ 0.93 0.29 0.00 22214286
+ 0.93 0.29 0.00 29285714
+ 0.93 0.29 0.00 36357143
+ 0.93 0.29 0.00 43428571
+ 0.93 0.29 0.00 50500000
+ 0.93 0.29 0.00 57571429
+ 0.93 0.29 0.00 64642857
+ 0.93 0.29 0.00 71714286
+ 0.93 0.29 0.00 78785714
+ 0.93 0.29 0.00 85857143
+ 0.93 0.29 0.00 92928571
+ 0.93 0.29 0.00 100000000
+ 0.93 0.29 0.07 1000000
+ 0.93 0.29 0.07 8071429
+ 0.93 0.29 0.07 15142857
+ 0.93 0.29 0.07 22214286
+ 0.93 0.29 0.07 29285714
+ 0.93 0.29 0.07 36357143
+ 0.93 0.29 0.07 43428571
+ 0.93 0.29 0.07 50500000
+ 0.93 0.29 0.07 57571429
+ 0.93 0.29 0.07 64642857
+ 0.93 0.29 0.07 71714286
+ 0.93 0.29 0.07 78785714
+ 0.93 0.29 0.07 85857143
+ 0.93 0.29 0.07 92928571
+ 0.93 0.29 0.07 100000000
+ 0.93 0.29 0.14 1000000
+ 0.93 0.29 0.14 8071429
+ 0.93 0.29 0.14 15142857
+ 0.93 0.29 0.14 22214286
+ 0.93 0.29 0.14 29285714
+ 0.93 0.29 0.14 36357143
+ 0.93 0.29 0.14 43428571
+ 0.93 0.29 0.14 50500000
+ 0.93 0.29 0.14 57571429
+ 0.93 0.29 0.14 64642857
+ 0.93 0.29 0.14 71714286
+ 0.93 0.29 0.14 78785714
+ 0.93 0.29 0.14 85857143
+ 0.93 0.29 0.14 92928571
+ 0.93 0.29 0.14 100000000
+ 0.93 0.29 0.21 1000000
+ 0.93 0.29 0.21 8071429
+ 0.93 0.29 0.21 15142857
+ 0.93 0.29 0.21 22214286
+ 0.93 0.29 0.21 29285714
+ 0.93 0.29 0.21 36357143
+ 0.93 0.29 0.21 43428571
+ 0.93 0.29 0.21 50500000
+ 0.93 0.29 0.21 57571429
+ 0.93 0.29 0.21 64642857
+ 0.93 0.29 0.21 71714286
+ 0.93 0.29 0.21 78785714
+ 0.93 0.29 0.21 85857143
+ 0.93 0.29 0.21 92928571
+ 0.93 0.29 0.21 100000000
+ 0.93 0.29 0.29 1000000
+ 0.93 0.29 0.29 8071429
+ 0.93 0.29 0.29 15142857
+ 0.93 0.29 0.29 22214286
+ 0.93 0.29 0.29 29285714
+ 0.93 0.29 0.29 36357143
+ 0.93 0.29 0.29 43428571
+ 0.93 0.29 0.29 50500000
+ 0.93 0.29 0.29 57571429
+ 0.93 0.29 0.29 64642857
+ 0.93 0.29 0.29 71714286
+ 0.93 0.29 0.29 78785714
+ 0.93 0.29 0.29 85857143
+ 0.93 0.29 0.29 92928571
+ 0.93 0.29 0.29 100000000
+ 0.93 0.29 0.36 1000000
+ 0.93 0.29 0.36 8071429
+ 0.93 0.29 0.36 15142857
+ 0.93 0.29 0.36 22214286
+ 0.93 0.29 0.36 29285714
+ 0.93 0.29 0.36 36357143
+ 0.93 0.29 0.36 43428571
+ 0.93 0.29 0.36 50500000
+ 0.93 0.29 0.36 57571429
+ 0.93 0.29 0.36 64642857
+ 0.93 0.29 0.36 71714286
+ 0.93 0.29 0.36 78785714
+ 0.93 0.29 0.36 85857143
+ 0.93 0.29 0.36 92928571
+ 0.93 0.29 0.36 100000000
+ 0.93 0.29 0.43 1000000
+ 0.93 0.29 0.43 8071429
+ 0.93 0.29 0.43 15142857
+ 0.93 0.29 0.43 22214286
+ 0.93 0.29 0.43 29285714
+ 0.93 0.29 0.43 36357143
+ 0.93 0.29 0.43 43428571
+ 0.93 0.29 0.43 50500000
+ 0.93 0.29 0.43 57571429
+ 0.93 0.29 0.43 64642857
+ 0.93 0.29 0.43 71714286
+ 0.93 0.29 0.43 78785714
+ 0.93 0.29 0.43 85857143
+ 0.93 0.29 0.43 92928571
+ 0.93 0.29 0.43 100000000
+ 0.93 0.29 0.50 1000000
+ 0.93 0.29 0.50 8071429
+ 0.93 0.29 0.50 15142857
+ 0.93 0.29 0.50 22214286
+ 0.93 0.29 0.50 29285714
+ 0.93 0.29 0.50 36357143
+ 0.93 0.29 0.50 43428571
+ 0.93 0.29 0.50 50500000
+ 0.93 0.29 0.50 57571429
+ 0.93 0.29 0.50 64642857
+ 0.93 0.29 0.50 71714286
+ 0.93 0.29 0.50 78785714
+ 0.93 0.29 0.50 85857143
+ 0.93 0.29 0.50 92928571
+ 0.93 0.29 0.50 100000000
+ 0.93 0.29 0.57 1000000
+ 0.93 0.29 0.57 8071429
+ 0.93 0.29 0.57 15142857
+ 0.93 0.29 0.57 22214286
+ 0.93 0.29 0.57 29285714
+ 0.93 0.29 0.57 36357143
+ 0.93 0.29 0.57 43428571
+ 0.93 0.29 0.57 50500000
+ 0.93 0.29 0.57 57571429
+ 0.93 0.29 0.57 64642857
+ 0.93 0.29 0.57 71714286
+ 0.93 0.29 0.57 78785714
+ 0.93 0.29 0.57 85857143
+ 0.93 0.29 0.57 92928571
+ 0.93 0.29 0.57 100000000
+ 0.93 0.29 0.64 1000000
+ 0.93 0.29 0.64 8071429
+ 0.93 0.29 0.64 15142857
+ 0.93 0.29 0.64 22214286
+ 0.93 0.29 0.64 29285714
+ 0.93 0.29 0.64 36357143
+ 0.93 0.29 0.64 43428571
+ 0.93 0.29 0.64 50500000
+ 0.93 0.29 0.64 57571429
+ 0.93 0.29 0.64 64642857
+ 0.93 0.29 0.64 71714286
+ 0.93 0.29 0.64 78785714
+ 0.93 0.29 0.64 85857143
+ 0.93 0.29 0.64 92928571
+ 0.93 0.29 0.64 100000000
+ 0.93 0.29 0.71 1000000
+ 0.93 0.29 0.71 8071429
+ 0.93 0.29 0.71 15142857
+ 0.93 0.29 0.71 22214286
+ 0.93 0.29 0.71 29285714
+ 0.93 0.29 0.71 36357143
+ 0.93 0.29 0.71 43428571
+ 0.93 0.29 0.71 50500000
+ 0.93 0.29 0.71 57571429
+ 0.93 0.29 0.71 64642857
+ 0.93 0.29 0.71 71714286
+ 0.93 0.29 0.71 78785714
+ 0.93 0.29 0.71 85857143
+ 0.93 0.29 0.71 92928571
+ 0.93 0.29 0.71 100000000
+ 0.93 0.29 0.79 1000000
+ 0.93 0.29 0.79 8071429
+ 0.93 0.29 0.79 15142857
+ 0.93 0.29 0.79 22214286
+ 0.93 0.29 0.79 29285714
+ 0.93 0.29 0.79 36357143
+ 0.93 0.29 0.79 43428571
+ 0.93 0.29 0.79 50500000
+ 0.93 0.29 0.79 57571429
+ 0.93 0.29 0.79 64642857
+ 0.93 0.29 0.79 71714286
+ 0.93 0.29 0.79 78785714
+ 0.93 0.29 0.79 85857143
+ 0.93 0.29 0.79 92928571
+ 0.93 0.29 0.79 100000000
+ 0.93 0.29 0.86 1000000
+ 0.93 0.29 0.86 8071429
+ 0.93 0.29 0.86 15142857
+ 0.93 0.29 0.86 22214286
+ 0.93 0.29 0.86 29285714
+ 0.93 0.29 0.86 36357143
+ 0.93 0.29 0.86 43428571
+ 0.93 0.29 0.86 50500000
+ 0.93 0.29 0.86 57571429
+ 0.93 0.29 0.86 64642857
+ 0.93 0.29 0.86 71714286
+ 0.93 0.29 0.86 78785714
+ 0.93 0.29 0.86 85857143
+ 0.93 0.29 0.86 92928571
+ 0.93 0.29 0.86 100000000
+ 0.93 0.29 0.93 1000000
+ 0.93 0.29 0.93 8071429
+ 0.93 0.29 0.93 15142857
+ 0.93 0.29 0.93 22214286
+ 0.93 0.29 0.93 29285714
+ 0.93 0.29 0.93 36357143
+ 0.93 0.29 0.93 43428571
+ 0.93 0.29 0.93 50500000
+ 0.93 0.29 0.93 57571429
+ 0.93 0.29 0.93 64642857
+ 0.93 0.29 0.93 71714286
+ 0.93 0.29 0.93 78785714
+ 0.93 0.29 0.93 85857143
+ 0.93 0.29 0.93 92928571
+ 0.93 0.29 0.93 100000000
+ 0.93 0.29 1.00 1000000
+ 0.93 0.29 1.00 8071429
+ 0.93 0.29 1.00 15142857
+ 0.93 0.29 1.00 22214286
+ 0.93 0.29 1.00 29285714
+ 0.93 0.29 1.00 36357143
+ 0.93 0.29 1.00 43428571
+ 0.93 0.29 1.00 50500000
+ 0.93 0.29 1.00 57571429
+ 0.93 0.29 1.00 64642857
+ 0.93 0.29 1.00 71714286
+ 0.93 0.29 1.00 78785714
+ 0.93 0.29 1.00 85857143
+ 0.93 0.29 1.00 92928571
+ 0.93 0.29 1.00 100000000
+ 0.93 0.36 0.00 1000000
+ 0.93 0.36 0.00 8071429
+ 0.93 0.36 0.00 15142857
+ 0.93 0.36 0.00 22214286
+ 0.93 0.36 0.00 29285714
+ 0.93 0.36 0.00 36357143
+ 0.93 0.36 0.00 43428571
+ 0.93 0.36 0.00 50500000
+ 0.93 0.36 0.00 57571429
+ 0.93 0.36 0.00 64642857
+ 0.93 0.36 0.00 71714286
+ 0.93 0.36 0.00 78785714
+ 0.93 0.36 0.00 85857143
+ 0.93 0.36 0.00 92928571
+ 0.93 0.36 0.00 100000000
+ 0.93 0.36 0.07 1000000
+ 0.93 0.36 0.07 8071429
+ 0.93 0.36 0.07 15142857
+ 0.93 0.36 0.07 22214286
+ 0.93 0.36 0.07 29285714
+ 0.93 0.36 0.07 36357143
+ 0.93 0.36 0.07 43428571
+ 0.93 0.36 0.07 50500000
+ 0.93 0.36 0.07 57571429
+ 0.93 0.36 0.07 64642857
+ 0.93 0.36 0.07 71714286
+ 0.93 0.36 0.07 78785714
+ 0.93 0.36 0.07 85857143
+ 0.93 0.36 0.07 92928571
+ 0.93 0.36 0.07 100000000
+ 0.93 0.36 0.14 1000000
+ 0.93 0.36 0.14 8071429
+ 0.93 0.36 0.14 15142857
+ 0.93 0.36 0.14 22214286
+ 0.93 0.36 0.14 29285714
+ 0.93 0.36 0.14 36357143
+ 0.93 0.36 0.14 43428571
+ 0.93 0.36 0.14 50500000
+ 0.93 0.36 0.14 57571429
+ 0.93 0.36 0.14 64642857
+ 0.93 0.36 0.14 71714286
+ 0.93 0.36 0.14 78785714
+ 0.93 0.36 0.14 85857143
+ 0.93 0.36 0.14 92928571
+ 0.93 0.36 0.14 100000000
+ 0.93 0.36 0.21 1000000
+ 0.93 0.36 0.21 8071429
+ 0.93 0.36 0.21 15142857
+ 0.93 0.36 0.21 22214286
+ 0.93 0.36 0.21 29285714
+ 0.93 0.36 0.21 36357143
+ 0.93 0.36 0.21 43428571
+ 0.93 0.36 0.21 50500000
+ 0.93 0.36 0.21 57571429
+ 0.93 0.36 0.21 64642857
+ 0.93 0.36 0.21 71714286
+ 0.93 0.36 0.21 78785714
+ 0.93 0.36 0.21 85857143
+ 0.93 0.36 0.21 92928571
+ 0.93 0.36 0.21 100000000
+ 0.93 0.36 0.29 1000000
+ 0.93 0.36 0.29 8071429
+ 0.93 0.36 0.29 15142857
+ 0.93 0.36 0.29 22214286
+ 0.93 0.36 0.29 29285714
+ 0.93 0.36 0.29 36357143
+ 0.93 0.36 0.29 43428571
+ 0.93 0.36 0.29 50500000
+ 0.93 0.36 0.29 57571429
+ 0.93 0.36 0.29 64642857
+ 0.93 0.36 0.29 71714286
+ 0.93 0.36 0.29 78785714
+ 0.93 0.36 0.29 85857143
+ 0.93 0.36 0.29 92928571
+ 0.93 0.36 0.29 100000000
+ 0.93 0.36 0.36 1000000
+ 0.93 0.36 0.36 8071429
+ 0.93 0.36 0.36 15142857
+ 0.93 0.36 0.36 22214286
+ 0.93 0.36 0.36 29285714
+ 0.93 0.36 0.36 36357143
+ 0.93 0.36 0.36 43428571
+ 0.93 0.36 0.36 50500000
+ 0.93 0.36 0.36 57571429
+ 0.93 0.36 0.36 64642857
+ 0.93 0.36 0.36 71714286
+ 0.93 0.36 0.36 78785714
+ 0.93 0.36 0.36 85857143
+ 0.93 0.36 0.36 92928571
+ 0.93 0.36 0.36 100000000
+ 0.93 0.36 0.43 1000000
+ 0.93 0.36 0.43 8071429
+ 0.93 0.36 0.43 15142857
+ 0.93 0.36 0.43 22214286
+ 0.93 0.36 0.43 29285714
+ 0.93 0.36 0.43 36357143
+ 0.93 0.36 0.43 43428571
+ 0.93 0.36 0.43 50500000
+ 0.93 0.36 0.43 57571429
+ 0.93 0.36 0.43 64642857
+ 0.93 0.36 0.43 71714286
+ 0.93 0.36 0.43 78785714
+ 0.93 0.36 0.43 85857143
+ 0.93 0.36 0.43 92928571
+ 0.93 0.36 0.43 100000000
+ 0.93 0.36 0.50 1000000
+ 0.93 0.36 0.50 8071429
+ 0.93 0.36 0.50 15142857
+ 0.93 0.36 0.50 22214286
+ 0.93 0.36 0.50 29285714
+ 0.93 0.36 0.50 36357143
+ 0.93 0.36 0.50 43428571
+ 0.93 0.36 0.50 50500000
+ 0.93 0.36 0.50 57571429
+ 0.93 0.36 0.50 64642857
+ 0.93 0.36 0.50 71714286
+ 0.93 0.36 0.50 78785714
+ 0.93 0.36 0.50 85857143
+ 0.93 0.36 0.50 92928571
+ 0.93 0.36 0.50 100000000
+ 0.93 0.36 0.57 1000000
+ 0.93 0.36 0.57 8071429
+ 0.93 0.36 0.57 15142857
+ 0.93 0.36 0.57 22214286
+ 0.93 0.36 0.57 29285714
+ 0.93 0.36 0.57 36357143
+ 0.93 0.36 0.57 43428571
+ 0.93 0.36 0.57 50500000
+ 0.93 0.36 0.57 57571429
+ 0.93 0.36 0.57 64642857
+ 0.93 0.36 0.57 71714286
+ 0.93 0.36 0.57 78785714
+ 0.93 0.36 0.57 85857143
+ 0.93 0.36 0.57 92928571
+ 0.93 0.36 0.57 100000000
+ 0.93 0.36 0.64 1000000
+ 0.93 0.36 0.64 8071429
+ 0.93 0.36 0.64 15142857
+ 0.93 0.36 0.64 22214286
+ 0.93 0.36 0.64 29285714
+ 0.93 0.36 0.64 36357143
+ 0.93 0.36 0.64 43428571
+ 0.93 0.36 0.64 50500000
+ 0.93 0.36 0.64 57571429
+ 0.93 0.36 0.64 64642857
+ 0.93 0.36 0.64 71714286
+ 0.93 0.36 0.64 78785714
+ 0.93 0.36 0.64 85857143
+ 0.93 0.36 0.64 92928571
+ 0.93 0.36 0.64 100000000
+ 0.93 0.36 0.71 1000000
+ 0.93 0.36 0.71 8071429
+ 0.93 0.36 0.71 15142857
+ 0.93 0.36 0.71 22214286
+ 0.93 0.36 0.71 29285714
+ 0.93 0.36 0.71 36357143
+ 0.93 0.36 0.71 43428571
+ 0.93 0.36 0.71 50500000
+ 0.93 0.36 0.71 57571429
+ 0.93 0.36 0.71 64642857
+ 0.93 0.36 0.71 71714286
+ 0.93 0.36 0.71 78785714
+ 0.93 0.36 0.71 85857143
+ 0.93 0.36 0.71 92928571
+ 0.93 0.36 0.71 100000000
+ 0.93 0.36 0.79 1000000
+ 0.93 0.36 0.79 8071429
+ 0.93 0.36 0.79 15142857
+ 0.93 0.36 0.79 22214286
+ 0.93 0.36 0.79 29285714
+ 0.93 0.36 0.79 36357143
+ 0.93 0.36 0.79 43428571
+ 0.93 0.36 0.79 50500000
+ 0.93 0.36 0.79 57571429
+ 0.93 0.36 0.79 64642857
+ 0.93 0.36 0.79 71714286
+ 0.93 0.36 0.79 78785714
+ 0.93 0.36 0.79 85857143
+ 0.93 0.36 0.79 92928571
+ 0.93 0.36 0.79 100000000
+ 0.93 0.36 0.86 1000000
+ 0.93 0.36 0.86 8071429
+ 0.93 0.36 0.86 15142857
+ 0.93 0.36 0.86 22214286
+ 0.93 0.36 0.86 29285714
+ 0.93 0.36 0.86 36357143
+ 0.93 0.36 0.86 43428571
+ 0.93 0.36 0.86 50500000
+ 0.93 0.36 0.86 57571429
+ 0.93 0.36 0.86 64642857
+ 0.93 0.36 0.86 71714286
+ 0.93 0.36 0.86 78785714
+ 0.93 0.36 0.86 85857143
+ 0.93 0.36 0.86 92928571
+ 0.93 0.36 0.86 100000000
+ 0.93 0.36 0.93 1000000
+ 0.93 0.36 0.93 8071429
+ 0.93 0.36 0.93 15142857
+ 0.93 0.36 0.93 22214286
+ 0.93 0.36 0.93 29285714
+ 0.93 0.36 0.93 36357143
+ 0.93 0.36 0.93 43428571
+ 0.93 0.36 0.93 50500000
+ 0.93 0.36 0.93 57571429
+ 0.93 0.36 0.93 64642857
+ 0.93 0.36 0.93 71714286
+ 0.93 0.36 0.93 78785714
+ 0.93 0.36 0.93 85857143
+ 0.93 0.36 0.93 92928571
+ 0.93 0.36 0.93 100000000
+ 0.93 0.36 1.00 1000000
+ 0.93 0.36 1.00 8071429
+ 0.93 0.36 1.00 15142857
+ 0.93 0.36 1.00 22214286
+ 0.93 0.36 1.00 29285714
+ 0.93 0.36 1.00 36357143
+ 0.93 0.36 1.00 43428571
+ 0.93 0.36 1.00 50500000
+ 0.93 0.36 1.00 57571429
+ 0.93 0.36 1.00 64642857
+ 0.93 0.36 1.00 71714286
+ 0.93 0.36 1.00 78785714
+ 0.93 0.36 1.00 85857143
+ 0.93 0.36 1.00 92928571
+ 0.93 0.36 1.00 100000000
+ 0.93 0.43 0.00 1000000
+ 0.93 0.43 0.00 8071429
+ 0.93 0.43 0.00 15142857
+ 0.93 0.43 0.00 22214286
+ 0.93 0.43 0.00 29285714
+ 0.93 0.43 0.00 36357143
+ 0.93 0.43 0.00 43428571
+ 0.93 0.43 0.00 50500000
+ 0.93 0.43 0.00 57571429
+ 0.93 0.43 0.00 64642857
+ 0.93 0.43 0.00 71714286
+ 0.93 0.43 0.00 78785714
+ 0.93 0.43 0.00 85857143
+ 0.93 0.43 0.00 92928571
+ 0.93 0.43 0.00 100000000
+ 0.93 0.43 0.07 1000000
+ 0.93 0.43 0.07 8071429
+ 0.93 0.43 0.07 15142857
+ 0.93 0.43 0.07 22214286
+ 0.93 0.43 0.07 29285714
+ 0.93 0.43 0.07 36357143
+ 0.93 0.43 0.07 43428571
+ 0.93 0.43 0.07 50500000
+ 0.93 0.43 0.07 57571429
+ 0.93 0.43 0.07 64642857
+ 0.93 0.43 0.07 71714286
+ 0.93 0.43 0.07 78785714
+ 0.93 0.43 0.07 85857143
+ 0.93 0.43 0.07 92928571
+ 0.93 0.43 0.07 100000000
+ 0.93 0.43 0.14 1000000
+ 0.93 0.43 0.14 8071429
+ 0.93 0.43 0.14 15142857
+ 0.93 0.43 0.14 22214286
+ 0.93 0.43 0.14 29285714
+ 0.93 0.43 0.14 36357143
+ 0.93 0.43 0.14 43428571
+ 0.93 0.43 0.14 50500000
+ 0.93 0.43 0.14 57571429
+ 0.93 0.43 0.14 64642857
+ 0.93 0.43 0.14 71714286
+ 0.93 0.43 0.14 78785714
+ 0.93 0.43 0.14 85857143
+ 0.93 0.43 0.14 92928571
+ 0.93 0.43 0.14 100000000
+ 0.93 0.43 0.21 1000000
+ 0.93 0.43 0.21 8071429
+ 0.93 0.43 0.21 15142857
+ 0.93 0.43 0.21 22214286
+ 0.93 0.43 0.21 29285714
+ 0.93 0.43 0.21 36357143
+ 0.93 0.43 0.21 43428571
+ 0.93 0.43 0.21 50500000
+ 0.93 0.43 0.21 57571429
+ 0.93 0.43 0.21 64642857
+ 0.93 0.43 0.21 71714286
+ 0.93 0.43 0.21 78785714
+ 0.93 0.43 0.21 85857143
+ 0.93 0.43 0.21 92928571
+ 0.93 0.43 0.21 100000000
+ 0.93 0.43 0.29 1000000
+ 0.93 0.43 0.29 8071429
+ 0.93 0.43 0.29 15142857
+ 0.93 0.43 0.29 22214286
+ 0.93 0.43 0.29 29285714
+ 0.93 0.43 0.29 36357143
+ 0.93 0.43 0.29 43428571
+ 0.93 0.43 0.29 50500000
+ 0.93 0.43 0.29 57571429
+ 0.93 0.43 0.29 64642857
+ 0.93 0.43 0.29 71714286
+ 0.93 0.43 0.29 78785714
+ 0.93 0.43 0.29 85857143
+ 0.93 0.43 0.29 92928571
+ 0.93 0.43 0.29 100000000
+ 0.93 0.43 0.36 1000000
+ 0.93 0.43 0.36 8071429
+ 0.93 0.43 0.36 15142857
+ 0.93 0.43 0.36 22214286
+ 0.93 0.43 0.36 29285714
+ 0.93 0.43 0.36 36357143
+ 0.93 0.43 0.36 43428571
+ 0.93 0.43 0.36 50500000
+ 0.93 0.43 0.36 57571429
+ 0.93 0.43 0.36 64642857
+ 0.93 0.43 0.36 71714286
+ 0.93 0.43 0.36 78785714
+ 0.93 0.43 0.36 85857143
+ 0.93 0.43 0.36 92928571
+ 0.93 0.43 0.36 100000000
+ 0.93 0.43 0.43 1000000
+ 0.93 0.43 0.43 8071429
+ 0.93 0.43 0.43 15142857
+ 0.93 0.43 0.43 22214286
+ 0.93 0.43 0.43 29285714
+ 0.93 0.43 0.43 36357143
+ 0.93 0.43 0.43 43428571
+ 0.93 0.43 0.43 50500000
+ 0.93 0.43 0.43 57571429
+ 0.93 0.43 0.43 64642857
+ 0.93 0.43 0.43 71714286
+ 0.93 0.43 0.43 78785714
+ 0.93 0.43 0.43 85857143
+ 0.93 0.43 0.43 92928571
+ 0.93 0.43 0.43 100000000
+ 0.93 0.43 0.50 1000000
+ 0.93 0.43 0.50 8071429
+ 0.93 0.43 0.50 15142857
+ 0.93 0.43 0.50 22214286
+ 0.93 0.43 0.50 29285714
+ 0.93 0.43 0.50 36357143
+ 0.93 0.43 0.50 43428571
+ 0.93 0.43 0.50 50500000
+ 0.93 0.43 0.50 57571429
+ 0.93 0.43 0.50 64642857
+ 0.93 0.43 0.50 71714286
+ 0.93 0.43 0.50 78785714
+ 0.93 0.43 0.50 85857143
+ 0.93 0.43 0.50 92928571
+ 0.93 0.43 0.50 100000000
+ 0.93 0.43 0.57 1000000
+ 0.93 0.43 0.57 8071429
+ 0.93 0.43 0.57 15142857
+ 0.93 0.43 0.57 22214286
+ 0.93 0.43 0.57 29285714
+ 0.93 0.43 0.57 36357143
+ 0.93 0.43 0.57 43428571
+ 0.93 0.43 0.57 50500000
+ 0.93 0.43 0.57 57571429
+ 0.93 0.43 0.57 64642857
+ 0.93 0.43 0.57 71714286
+ 0.93 0.43 0.57 78785714
+ 0.93 0.43 0.57 85857143
+ 0.93 0.43 0.57 92928571
+ 0.93 0.43 0.57 100000000
+ 0.93 0.43 0.64 1000000
+ 0.93 0.43 0.64 8071429
+ 0.93 0.43 0.64 15142857
+ 0.93 0.43 0.64 22214286
+ 0.93 0.43 0.64 29285714
+ 0.93 0.43 0.64 36357143
+ 0.93 0.43 0.64 43428571
+ 0.93 0.43 0.64 50500000
+ 0.93 0.43 0.64 57571429
+ 0.93 0.43 0.64 64642857
+ 0.93 0.43 0.64 71714286
+ 0.93 0.43 0.64 78785714
+ 0.93 0.43 0.64 85857143
+ 0.93 0.43 0.64 92928571
+ 0.93 0.43 0.64 100000000
+ 0.93 0.43 0.71 1000000
+ 0.93 0.43 0.71 8071429
+ 0.93 0.43 0.71 15142857
+ 0.93 0.43 0.71 22214286
+ 0.93 0.43 0.71 29285714
+ 0.93 0.43 0.71 36357143
+ 0.93 0.43 0.71 43428571
+ 0.93 0.43 0.71 50500000
+ 0.93 0.43 0.71 57571429
+ 0.93 0.43 0.71 64642857
+ 0.93 0.43 0.71 71714286
+ 0.93 0.43 0.71 78785714
+ 0.93 0.43 0.71 85857143
+ 0.93 0.43 0.71 92928571
+ 0.93 0.43 0.71 100000000
+ 0.93 0.43 0.79 1000000
+ 0.93 0.43 0.79 8071429
+ 0.93 0.43 0.79 15142857
+ 0.93 0.43 0.79 22214286
+ 0.93 0.43 0.79 29285714
+ 0.93 0.43 0.79 36357143
+ 0.93 0.43 0.79 43428571
+ 0.93 0.43 0.79 50500000
+ 0.93 0.43 0.79 57571429
+ 0.93 0.43 0.79 64642857
+ 0.93 0.43 0.79 71714286
+ 0.93 0.43 0.79 78785714
+ 0.93 0.43 0.79 85857143
+ 0.93 0.43 0.79 92928571
+ 0.93 0.43 0.79 100000000
+ 0.93 0.43 0.86 1000000
+ 0.93 0.43 0.86 8071429
+ 0.93 0.43 0.86 15142857
+ 0.93 0.43 0.86 22214286
+ 0.93 0.43 0.86 29285714
+ 0.93 0.43 0.86 36357143
+ 0.93 0.43 0.86 43428571
+ 0.93 0.43 0.86 50500000
+ 0.93 0.43 0.86 57571429
+ 0.93 0.43 0.86 64642857
+ 0.93 0.43 0.86 71714286
+ 0.93 0.43 0.86 78785714
+ 0.93 0.43 0.86 85857143
+ 0.93 0.43 0.86 92928571
+ 0.93 0.43 0.86 100000000
+ 0.93 0.43 0.93 1000000
+ 0.93 0.43 0.93 8071429
+ 0.93 0.43 0.93 15142857
+ 0.93 0.43 0.93 22214286
+ 0.93 0.43 0.93 29285714
+ 0.93 0.43 0.93 36357143
+ 0.93 0.43 0.93 43428571
+ 0.93 0.43 0.93 50500000
+ 0.93 0.43 0.93 57571429
+ 0.93 0.43 0.93 64642857
+ 0.93 0.43 0.93 71714286
+ 0.93 0.43 0.93 78785714
+ 0.93 0.43 0.93 85857143
+ 0.93 0.43 0.93 92928571
+ 0.93 0.43 0.93 100000000
+ 0.93 0.43 1.00 1000000
+ 0.93 0.43 1.00 8071429
+ 0.93 0.43 1.00 15142857
+ 0.93 0.43 1.00 22214286
+ 0.93 0.43 1.00 29285714
+ 0.93 0.43 1.00 36357143
+ 0.93 0.43 1.00 43428571
+ 0.93 0.43 1.00 50500000
+ 0.93 0.43 1.00 57571429
+ 0.93 0.43 1.00 64642857
+ 0.93 0.43 1.00 71714286
+ 0.93 0.43 1.00 78785714
+ 0.93 0.43 1.00 85857143
+ 0.93 0.43 1.00 92928571
+ 0.93 0.43 1.00 100000000
+ 0.93 0.50 0.00 1000000
+ 0.93 0.50 0.00 8071429
+ 0.93 0.50 0.00 15142857
+ 0.93 0.50 0.00 22214286
+ 0.93 0.50 0.00 29285714
+ 0.93 0.50 0.00 36357143
+ 0.93 0.50 0.00 43428571
+ 0.93 0.50 0.00 50500000
+ 0.93 0.50 0.00 57571429
+ 0.93 0.50 0.00 64642857
+ 0.93 0.50 0.00 71714286
+ 0.93 0.50 0.00 78785714
+ 0.93 0.50 0.00 85857143
+ 0.93 0.50 0.00 92928571
+ 0.93 0.50 0.00 100000000
+ 0.93 0.50 0.07 1000000
+ 0.93 0.50 0.07 8071429
+ 0.93 0.50 0.07 15142857
+ 0.93 0.50 0.07 22214286
+ 0.93 0.50 0.07 29285714
+ 0.93 0.50 0.07 36357143
+ 0.93 0.50 0.07 43428571
+ 0.93 0.50 0.07 50500000
+ 0.93 0.50 0.07 57571429
+ 0.93 0.50 0.07 64642857
+ 0.93 0.50 0.07 71714286
+ 0.93 0.50 0.07 78785714
+ 0.93 0.50 0.07 85857143
+ 0.93 0.50 0.07 92928571
+ 0.93 0.50 0.07 100000000
+ 0.93 0.50 0.14 1000000
+ 0.93 0.50 0.14 8071429
+ 0.93 0.50 0.14 15142857
+ 0.93 0.50 0.14 22214286
+ 0.93 0.50 0.14 29285714
+ 0.93 0.50 0.14 36357143
+ 0.93 0.50 0.14 43428571
+ 0.93 0.50 0.14 50500000
+ 0.93 0.50 0.14 57571429
+ 0.93 0.50 0.14 64642857
+ 0.93 0.50 0.14 71714286
+ 0.93 0.50 0.14 78785714
+ 0.93 0.50 0.14 85857143
+ 0.93 0.50 0.14 92928571
+ 0.93 0.50 0.14 100000000
+ 0.93 0.50 0.21 1000000
+ 0.93 0.50 0.21 8071429
+ 0.93 0.50 0.21 15142857
+ 0.93 0.50 0.21 22214286
+ 0.93 0.50 0.21 29285714
+ 0.93 0.50 0.21 36357143
+ 0.93 0.50 0.21 43428571
+ 0.93 0.50 0.21 50500000
+ 0.93 0.50 0.21 57571429
+ 0.93 0.50 0.21 64642857
+ 0.93 0.50 0.21 71714286
+ 0.93 0.50 0.21 78785714
+ 0.93 0.50 0.21 85857143
+ 0.93 0.50 0.21 92928571
+ 0.93 0.50 0.21 100000000
+ 0.93 0.50 0.29 1000000
+ 0.93 0.50 0.29 8071429
+ 0.93 0.50 0.29 15142857
+ 0.93 0.50 0.29 22214286
+ 0.93 0.50 0.29 29285714
+ 0.93 0.50 0.29 36357143
+ 0.93 0.50 0.29 43428571
+ 0.93 0.50 0.29 50500000
+ 0.93 0.50 0.29 57571429
+ 0.93 0.50 0.29 64642857
+ 0.93 0.50 0.29 71714286
+ 0.93 0.50 0.29 78785714
+ 0.93 0.50 0.29 85857143
+ 0.93 0.50 0.29 92928571
+ 0.93 0.50 0.29 100000000
+ 0.93 0.50 0.36 1000000
+ 0.93 0.50 0.36 8071429
+ 0.93 0.50 0.36 15142857
+ 0.93 0.50 0.36 22214286
+ 0.93 0.50 0.36 29285714
+ 0.93 0.50 0.36 36357143
+ 0.93 0.50 0.36 43428571
+ 0.93 0.50 0.36 50500000
+ 0.93 0.50 0.36 57571429
+ 0.93 0.50 0.36 64642857
+ 0.93 0.50 0.36 71714286
+ 0.93 0.50 0.36 78785714
+ 0.93 0.50 0.36 85857143
+ 0.93 0.50 0.36 92928571
+ 0.93 0.50 0.36 100000000
+ 0.93 0.50 0.43 1000000
+ 0.93 0.50 0.43 8071429
+ 0.93 0.50 0.43 15142857
+ 0.93 0.50 0.43 22214286
+ 0.93 0.50 0.43 29285714
+ 0.93 0.50 0.43 36357143
+ 0.93 0.50 0.43 43428571
+ 0.93 0.50 0.43 50500000
+ 0.93 0.50 0.43 57571429
+ 0.93 0.50 0.43 64642857
+ 0.93 0.50 0.43 71714286
+ 0.93 0.50 0.43 78785714
+ 0.93 0.50 0.43 85857143
+ 0.93 0.50 0.43 92928571
+ 0.93 0.50 0.43 100000000
+ 0.93 0.50 0.50 1000000
+ 0.93 0.50 0.50 8071429
+ 0.93 0.50 0.50 15142857
+ 0.93 0.50 0.50 22214286
+ 0.93 0.50 0.50 29285714
+ 0.93 0.50 0.50 36357143
+ 0.93 0.50 0.50 43428571
+ 0.93 0.50 0.50 50500000
+ 0.93 0.50 0.50 57571429
+ 0.93 0.50 0.50 64642857
+ 0.93 0.50 0.50 71714286
+ 0.93 0.50 0.50 78785714
+ 0.93 0.50 0.50 85857143
+ 0.93 0.50 0.50 92928571
+ 0.93 0.50 0.50 100000000
+ 0.93 0.50 0.57 1000000
+ 0.93 0.50 0.57 8071429
+ 0.93 0.50 0.57 15142857
+ 0.93 0.50 0.57 22214286
+ 0.93 0.50 0.57 29285714
+ 0.93 0.50 0.57 36357143
+ 0.93 0.50 0.57 43428571
+ 0.93 0.50 0.57 50500000
+ 0.93 0.50 0.57 57571429
+ 0.93 0.50 0.57 64642857
+ 0.93 0.50 0.57 71714286
+ 0.93 0.50 0.57 78785714
+ 0.93 0.50 0.57 85857143
+ 0.93 0.50 0.57 92928571
+ 0.93 0.50 0.57 100000000
+ 0.93 0.50 0.64 1000000
+ 0.93 0.50 0.64 8071429
+ 0.93 0.50 0.64 15142857
+ 0.93 0.50 0.64 22214286
+ 0.93 0.50 0.64 29285714
+ 0.93 0.50 0.64 36357143
+ 0.93 0.50 0.64 43428571
+ 0.93 0.50 0.64 50500000
+ 0.93 0.50 0.64 57571429
+ 0.93 0.50 0.64 64642857
+ 0.93 0.50 0.64 71714286
+ 0.93 0.50 0.64 78785714
+ 0.93 0.50 0.64 85857143
+ 0.93 0.50 0.64 92928571
+ 0.93 0.50 0.64 100000000
+ 0.93 0.50 0.71 1000000
+ 0.93 0.50 0.71 8071429
+ 0.93 0.50 0.71 15142857
+ 0.93 0.50 0.71 22214286
+ 0.93 0.50 0.71 29285714
+ 0.93 0.50 0.71 36357143
+ 0.93 0.50 0.71 43428571
+ 0.93 0.50 0.71 50500000
+ 0.93 0.50 0.71 57571429
+ 0.93 0.50 0.71 64642857
+ 0.93 0.50 0.71 71714286
+ 0.93 0.50 0.71 78785714
+ 0.93 0.50 0.71 85857143
+ 0.93 0.50 0.71 92928571
+ 0.93 0.50 0.71 100000000
+ 0.93 0.50 0.79 1000000
+ 0.93 0.50 0.79 8071429
+ 0.93 0.50 0.79 15142857
+ 0.93 0.50 0.79 22214286
+ 0.93 0.50 0.79 29285714
+ 0.93 0.50 0.79 36357143
+ 0.93 0.50 0.79 43428571
+ 0.93 0.50 0.79 50500000
+ 0.93 0.50 0.79 57571429
+ 0.93 0.50 0.79 64642857
+ 0.93 0.50 0.79 71714286
+ 0.93 0.50 0.79 78785714
+ 0.93 0.50 0.79 85857143
+ 0.93 0.50 0.79 92928571
+ 0.93 0.50 0.79 100000000
+ 0.93 0.50 0.86 1000000
+ 0.93 0.50 0.86 8071429
+ 0.93 0.50 0.86 15142857
+ 0.93 0.50 0.86 22214286
+ 0.93 0.50 0.86 29285714
+ 0.93 0.50 0.86 36357143
+ 0.93 0.50 0.86 43428571
+ 0.93 0.50 0.86 50500000
+ 0.93 0.50 0.86 57571429
+ 0.93 0.50 0.86 64642857
+ 0.93 0.50 0.86 71714286
+ 0.93 0.50 0.86 78785714
+ 0.93 0.50 0.86 85857143
+ 0.93 0.50 0.86 92928571
+ 0.93 0.50 0.86 100000000
+ 0.93 0.50 0.93 1000000
+ 0.93 0.50 0.93 8071429
+ 0.93 0.50 0.93 15142857
+ 0.93 0.50 0.93 22214286
+ 0.93 0.50 0.93 29285714
+ 0.93 0.50 0.93 36357143
+ 0.93 0.50 0.93 43428571
+ 0.93 0.50 0.93 50500000
+ 0.93 0.50 0.93 57571429
+ 0.93 0.50 0.93 64642857
+ 0.93 0.50 0.93 71714286
+ 0.93 0.50 0.93 78785714
+ 0.93 0.50 0.93 85857143
+ 0.93 0.50 0.93 92928571
+ 0.93 0.50 0.93 100000000
+ 0.93 0.50 1.00 1000000
+ 0.93 0.50 1.00 8071429
+ 0.93 0.50 1.00 15142857
+ 0.93 0.50 1.00 22214286
+ 0.93 0.50 1.00 29285714
+ 0.93 0.50 1.00 36357143
+ 0.93 0.50 1.00 43428571
+ 0.93 0.50 1.00 50500000
+ 0.93 0.50 1.00 57571429
+ 0.93 0.50 1.00 64642857
+ 0.93 0.50 1.00 71714286
+ 0.93 0.50 1.00 78785714
+ 0.93 0.50 1.00 85857143
+ 0.93 0.50 1.00 92928571
+ 0.93 0.50 1.00 100000000
+ 0.93 0.57 0.00 1000000
+ 0.93 0.57 0.00 8071429
+ 0.93 0.57 0.00 15142857
+ 0.93 0.57 0.00 22214286
+ 0.93 0.57 0.00 29285714
+ 0.93 0.57 0.00 36357143
+ 0.93 0.57 0.00 43428571
+ 0.93 0.57 0.00 50500000
+ 0.93 0.57 0.00 57571429
+ 0.93 0.57 0.00 64642857
+ 0.93 0.57 0.00 71714286
+ 0.93 0.57 0.00 78785714
+ 0.93 0.57 0.00 85857143
+ 0.93 0.57 0.00 92928571
+ 0.93 0.57 0.00 100000000
+ 0.93 0.57 0.07 1000000
+ 0.93 0.57 0.07 8071429
+ 0.93 0.57 0.07 15142857
+ 0.93 0.57 0.07 22214286
+ 0.93 0.57 0.07 29285714
+ 0.93 0.57 0.07 36357143
+ 0.93 0.57 0.07 43428571
+ 0.93 0.57 0.07 50500000
+ 0.93 0.57 0.07 57571429
+ 0.93 0.57 0.07 64642857
+ 0.93 0.57 0.07 71714286
+ 0.93 0.57 0.07 78785714
+ 0.93 0.57 0.07 85857143
+ 0.93 0.57 0.07 92928571
+ 0.93 0.57 0.07 100000000
+ 0.93 0.57 0.14 1000000
+ 0.93 0.57 0.14 8071429
+ 0.93 0.57 0.14 15142857
+ 0.93 0.57 0.14 22214286
+ 0.93 0.57 0.14 29285714
+ 0.93 0.57 0.14 36357143
+ 0.93 0.57 0.14 43428571
+ 0.93 0.57 0.14 50500000
+ 0.93 0.57 0.14 57571429
+ 0.93 0.57 0.14 64642857
+ 0.93 0.57 0.14 71714286
+ 0.93 0.57 0.14 78785714
+ 0.93 0.57 0.14 85857143
+ 0.93 0.57 0.14 92928571
+ 0.93 0.57 0.14 100000000
+ 0.93 0.57 0.21 1000000
+ 0.93 0.57 0.21 8071429
+ 0.93 0.57 0.21 15142857
+ 0.93 0.57 0.21 22214286
+ 0.93 0.57 0.21 29285714
+ 0.93 0.57 0.21 36357143
+ 0.93 0.57 0.21 43428571
+ 0.93 0.57 0.21 50500000
+ 0.93 0.57 0.21 57571429
+ 0.93 0.57 0.21 64642857
+ 0.93 0.57 0.21 71714286
+ 0.93 0.57 0.21 78785714
+ 0.93 0.57 0.21 85857143
+ 0.93 0.57 0.21 92928571
+ 0.93 0.57 0.21 100000000
+ 0.93 0.57 0.29 1000000
+ 0.93 0.57 0.29 8071429
+ 0.93 0.57 0.29 15142857
+ 0.93 0.57 0.29 22214286
+ 0.93 0.57 0.29 29285714
+ 0.93 0.57 0.29 36357143
+ 0.93 0.57 0.29 43428571
+ 0.93 0.57 0.29 50500000
+ 0.93 0.57 0.29 57571429
+ 0.93 0.57 0.29 64642857
+ 0.93 0.57 0.29 71714286
+ 0.93 0.57 0.29 78785714
+ 0.93 0.57 0.29 85857143
+ 0.93 0.57 0.29 92928571
+ 0.93 0.57 0.29 100000000
+ 0.93 0.57 0.36 1000000
+ 0.93 0.57 0.36 8071429
+ 0.93 0.57 0.36 15142857
+ 0.93 0.57 0.36 22214286
+ 0.93 0.57 0.36 29285714
+ 0.93 0.57 0.36 36357143
+ 0.93 0.57 0.36 43428571
+ 0.93 0.57 0.36 50500000
+ 0.93 0.57 0.36 57571429
+ 0.93 0.57 0.36 64642857
+ 0.93 0.57 0.36 71714286
+ 0.93 0.57 0.36 78785714
+ 0.93 0.57 0.36 85857143
+ 0.93 0.57 0.36 92928571
+ 0.93 0.57 0.36 100000000
+ 0.93 0.57 0.43 1000000
+ 0.93 0.57 0.43 8071429
+ 0.93 0.57 0.43 15142857
+ 0.93 0.57 0.43 22214286
+ 0.93 0.57 0.43 29285714
+ 0.93 0.57 0.43 36357143
+ 0.93 0.57 0.43 43428571
+ 0.93 0.57 0.43 50500000
+ 0.93 0.57 0.43 57571429
+ 0.93 0.57 0.43 64642857
+ 0.93 0.57 0.43 71714286
+ 0.93 0.57 0.43 78785714
+ 0.93 0.57 0.43 85857143
+ 0.93 0.57 0.43 92928571
+ 0.93 0.57 0.43 100000000
+ 0.93 0.57 0.50 1000000
+ 0.93 0.57 0.50 8071429
+ 0.93 0.57 0.50 15142857
+ 0.93 0.57 0.50 22214286
+ 0.93 0.57 0.50 29285714
+ 0.93 0.57 0.50 36357143
+ 0.93 0.57 0.50 43428571
+ 0.93 0.57 0.50 50500000
+ 0.93 0.57 0.50 57571429
+ 0.93 0.57 0.50 64642857
+ 0.93 0.57 0.50 71714286
+ 0.93 0.57 0.50 78785714
+ 0.93 0.57 0.50 85857143
+ 0.93 0.57 0.50 92928571
+ 0.93 0.57 0.50 100000000
+ 0.93 0.57 0.57 1000000
+ 0.93 0.57 0.57 8071429
+ 0.93 0.57 0.57 15142857
+ 0.93 0.57 0.57 22214286
+ 0.93 0.57 0.57 29285714
+ 0.93 0.57 0.57 36357143
+ 0.93 0.57 0.57 43428571
+ 0.93 0.57 0.57 50500000
+ 0.93 0.57 0.57 57571429
+ 0.93 0.57 0.57 64642857
+ 0.93 0.57 0.57 71714286
+ 0.93 0.57 0.57 78785714
+ 0.93 0.57 0.57 85857143
+ 0.93 0.57 0.57 92928571
+ 0.93 0.57 0.57 100000000
+ 0.93 0.57 0.64 1000000
+ 0.93 0.57 0.64 8071429
+ 0.93 0.57 0.64 15142857
+ 0.93 0.57 0.64 22214286
+ 0.93 0.57 0.64 29285714
+ 0.93 0.57 0.64 36357143
+ 0.93 0.57 0.64 43428571
+ 0.93 0.57 0.64 50500000
+ 0.93 0.57 0.64 57571429
+ 0.93 0.57 0.64 64642857
+ 0.93 0.57 0.64 71714286
+ 0.93 0.57 0.64 78785714
+ 0.93 0.57 0.64 85857143
+ 0.93 0.57 0.64 92928571
+ 0.93 0.57 0.64 100000000
+ 0.93 0.57 0.71 1000000
+ 0.93 0.57 0.71 8071429
+ 0.93 0.57 0.71 15142857
+ 0.93 0.57 0.71 22214286
+ 0.93 0.57 0.71 29285714
+ 0.93 0.57 0.71 36357143
+ 0.93 0.57 0.71 43428571
+ 0.93 0.57 0.71 50500000
+ 0.93 0.57 0.71 57571429
+ 0.93 0.57 0.71 64642857
+ 0.93 0.57 0.71 71714286
+ 0.93 0.57 0.71 78785714
+ 0.93 0.57 0.71 85857143
+ 0.93 0.57 0.71 92928571
+ 0.93 0.57 0.71 100000000
+ 0.93 0.57 0.79 1000000
+ 0.93 0.57 0.79 8071429
+ 0.93 0.57 0.79 15142857
+ 0.93 0.57 0.79 22214286
+ 0.93 0.57 0.79 29285714
+ 0.93 0.57 0.79 36357143
+ 0.93 0.57 0.79 43428571
+ 0.93 0.57 0.79 50500000
+ 0.93 0.57 0.79 57571429
+ 0.93 0.57 0.79 64642857
+ 0.93 0.57 0.79 71714286
+ 0.93 0.57 0.79 78785714
+ 0.93 0.57 0.79 85857143
+ 0.93 0.57 0.79 92928571
+ 0.93 0.57 0.79 100000000
+ 0.93 0.57 0.86 1000000
+ 0.93 0.57 0.86 8071429
+ 0.93 0.57 0.86 15142857
+ 0.93 0.57 0.86 22214286
+ 0.93 0.57 0.86 29285714
+ 0.93 0.57 0.86 36357143
+ 0.93 0.57 0.86 43428571
+ 0.93 0.57 0.86 50500000
+ 0.93 0.57 0.86 57571429
+ 0.93 0.57 0.86 64642857
+ 0.93 0.57 0.86 71714286
+ 0.93 0.57 0.86 78785714
+ 0.93 0.57 0.86 85857143
+ 0.93 0.57 0.86 92928571
+ 0.93 0.57 0.86 100000000
+ 0.93 0.57 0.93 1000000
+ 0.93 0.57 0.93 8071429
+ 0.93 0.57 0.93 15142857
+ 0.93 0.57 0.93 22214286
+ 0.93 0.57 0.93 29285714
+ 0.93 0.57 0.93 36357143
+ 0.93 0.57 0.93 43428571
+ 0.93 0.57 0.93 50500000
+ 0.93 0.57 0.93 57571429
+ 0.93 0.57 0.93 64642857
+ 0.93 0.57 0.93 71714286
+ 0.93 0.57 0.93 78785714
+ 0.93 0.57 0.93 85857143
+ 0.93 0.57 0.93 92928571
+ 0.93 0.57 0.93 100000000
+ 0.93 0.57 1.00 1000000
+ 0.93 0.57 1.00 8071429
+ 0.93 0.57 1.00 15142857
+ 0.93 0.57 1.00 22214286
+ 0.93 0.57 1.00 29285714
+ 0.93 0.57 1.00 36357143
+ 0.93 0.57 1.00 43428571
+ 0.93 0.57 1.00 50500000
+ 0.93 0.57 1.00 57571429
+ 0.93 0.57 1.00 64642857
+ 0.93 0.57 1.00 71714286
+ 0.93 0.57 1.00 78785714
+ 0.93 0.57 1.00 85857143
+ 0.93 0.57 1.00 92928571
+ 0.93 0.57 1.00 100000000
+ 0.93 0.64 0.00 1000000
+ 0.93 0.64 0.00 8071429
+ 0.93 0.64 0.00 15142857
+ 0.93 0.64 0.00 22214286
+ 0.93 0.64 0.00 29285714
+ 0.93 0.64 0.00 36357143
+ 0.93 0.64 0.00 43428571
+ 0.93 0.64 0.00 50500000
+ 0.93 0.64 0.00 57571429
+ 0.93 0.64 0.00 64642857
+ 0.93 0.64 0.00 71714286
+ 0.93 0.64 0.00 78785714
+ 0.93 0.64 0.00 85857143
+ 0.93 0.64 0.00 92928571
+ 0.93 0.64 0.00 100000000
+ 0.93 0.64 0.07 1000000
+ 0.93 0.64 0.07 8071429
+ 0.93 0.64 0.07 15142857
+ 0.93 0.64 0.07 22214286
+ 0.93 0.64 0.07 29285714
+ 0.93 0.64 0.07 36357143
+ 0.93 0.64 0.07 43428571
+ 0.93 0.64 0.07 50500000
+ 0.93 0.64 0.07 57571429
+ 0.93 0.64 0.07 64642857
+ 0.93 0.64 0.07 71714286
+ 0.93 0.64 0.07 78785714
+ 0.93 0.64 0.07 85857143
+ 0.93 0.64 0.07 92928571
+ 0.93 0.64 0.07 100000000
+ 0.93 0.64 0.14 1000000
+ 0.93 0.64 0.14 8071429
+ 0.93 0.64 0.14 15142857
+ 0.93 0.64 0.14 22214286
+ 0.93 0.64 0.14 29285714
+ 0.93 0.64 0.14 36357143
+ 0.93 0.64 0.14 43428571
+ 0.93 0.64 0.14 50500000
+ 0.93 0.64 0.14 57571429
+ 0.93 0.64 0.14 64642857
+ 0.93 0.64 0.14 71714286
+ 0.93 0.64 0.14 78785714
+ 0.93 0.64 0.14 85857143
+ 0.93 0.64 0.14 92928571
+ 0.93 0.64 0.14 100000000
+ 0.93 0.64 0.21 1000000
+ 0.93 0.64 0.21 8071429
+ 0.93 0.64 0.21 15142857
+ 0.93 0.64 0.21 22214286
+ 0.93 0.64 0.21 29285714
+ 0.93 0.64 0.21 36357143
+ 0.93 0.64 0.21 43428571
+ 0.93 0.64 0.21 50500000
+ 0.93 0.64 0.21 57571429
+ 0.93 0.64 0.21 64642857
+ 0.93 0.64 0.21 71714286
+ 0.93 0.64 0.21 78785714
+ 0.93 0.64 0.21 85857143
+ 0.93 0.64 0.21 92928571
+ 0.93 0.64 0.21 100000000
+ 0.93 0.64 0.29 1000000
+ 0.93 0.64 0.29 8071429
+ 0.93 0.64 0.29 15142857
+ 0.93 0.64 0.29 22214286
+ 0.93 0.64 0.29 29285714
+ 0.93 0.64 0.29 36357143
+ 0.93 0.64 0.29 43428571
+ 0.93 0.64 0.29 50500000
+ 0.93 0.64 0.29 57571429
+ 0.93 0.64 0.29 64642857
+ 0.93 0.64 0.29 71714286
+ 0.93 0.64 0.29 78785714
+ 0.93 0.64 0.29 85857143
+ 0.93 0.64 0.29 92928571
+ 0.93 0.64 0.29 100000000
+ 0.93 0.64 0.36 1000000
+ 0.93 0.64 0.36 8071429
+ 0.93 0.64 0.36 15142857
+ 0.93 0.64 0.36 22214286
+ 0.93 0.64 0.36 29285714
+ 0.93 0.64 0.36 36357143
+ 0.93 0.64 0.36 43428571
+ 0.93 0.64 0.36 50500000
+ 0.93 0.64 0.36 57571429
+ 0.93 0.64 0.36 64642857
+ 0.93 0.64 0.36 71714286
+ 0.93 0.64 0.36 78785714
+ 0.93 0.64 0.36 85857143
+ 0.93 0.64 0.36 92928571
+ 0.93 0.64 0.36 100000000
+ 0.93 0.64 0.43 1000000
+ 0.93 0.64 0.43 8071429
+ 0.93 0.64 0.43 15142857
+ 0.93 0.64 0.43 22214286
+ 0.93 0.64 0.43 29285714
+ 0.93 0.64 0.43 36357143
+ 0.93 0.64 0.43 43428571
+ 0.93 0.64 0.43 50500000
+ 0.93 0.64 0.43 57571429
+ 0.93 0.64 0.43 64642857
+ 0.93 0.64 0.43 71714286
+ 0.93 0.64 0.43 78785714
+ 0.93 0.64 0.43 85857143
+ 0.93 0.64 0.43 92928571
+ 0.93 0.64 0.43 100000000
+ 0.93 0.64 0.50 1000000
+ 0.93 0.64 0.50 8071429
+ 0.93 0.64 0.50 15142857
+ 0.93 0.64 0.50 22214286
+ 0.93 0.64 0.50 29285714
+ 0.93 0.64 0.50 36357143
+ 0.93 0.64 0.50 43428571
+ 0.93 0.64 0.50 50500000
+ 0.93 0.64 0.50 57571429
+ 0.93 0.64 0.50 64642857
+ 0.93 0.64 0.50 71714286
+ 0.93 0.64 0.50 78785714
+ 0.93 0.64 0.50 85857143
+ 0.93 0.64 0.50 92928571
+ 0.93 0.64 0.50 100000000
+ 0.93 0.64 0.57 1000000
+ 0.93 0.64 0.57 8071429
+ 0.93 0.64 0.57 15142857
+ 0.93 0.64 0.57 22214286
+ 0.93 0.64 0.57 29285714
+ 0.93 0.64 0.57 36357143
+ 0.93 0.64 0.57 43428571
+ 0.93 0.64 0.57 50500000
+ 0.93 0.64 0.57 57571429
+ 0.93 0.64 0.57 64642857
+ 0.93 0.64 0.57 71714286
+ 0.93 0.64 0.57 78785714
+ 0.93 0.64 0.57 85857143
+ 0.93 0.64 0.57 92928571
+ 0.93 0.64 0.57 100000000
+ 0.93 0.64 0.64 1000000
+ 0.93 0.64 0.64 8071429
+ 0.93 0.64 0.64 15142857
+ 0.93 0.64 0.64 22214286
+ 0.93 0.64 0.64 29285714
+ 0.93 0.64 0.64 36357143
+ 0.93 0.64 0.64 43428571
+ 0.93 0.64 0.64 50500000
+ 0.93 0.64 0.64 57571429
+ 0.93 0.64 0.64 64642857
+ 0.93 0.64 0.64 71714286
+ 0.93 0.64 0.64 78785714
+ 0.93 0.64 0.64 85857143
+ 0.93 0.64 0.64 92928571
+ 0.93 0.64 0.64 100000000
+ 0.93 0.64 0.71 1000000
+ 0.93 0.64 0.71 8071429
+ 0.93 0.64 0.71 15142857
+ 0.93 0.64 0.71 22214286
+ 0.93 0.64 0.71 29285714
+ 0.93 0.64 0.71 36357143
+ 0.93 0.64 0.71 43428571
+ 0.93 0.64 0.71 50500000
+ 0.93 0.64 0.71 57571429
+ 0.93 0.64 0.71 64642857
+ 0.93 0.64 0.71 71714286
+ 0.93 0.64 0.71 78785714
+ 0.93 0.64 0.71 85857143
+ 0.93 0.64 0.71 92928571
+ 0.93 0.64 0.71 100000000
+ 0.93 0.64 0.79 1000000
+ 0.93 0.64 0.79 8071429
+ 0.93 0.64 0.79 15142857
+ 0.93 0.64 0.79 22214286
+ 0.93 0.64 0.79 29285714
+ 0.93 0.64 0.79 36357143
+ 0.93 0.64 0.79 43428571
+ 0.93 0.64 0.79 50500000
+ 0.93 0.64 0.79 57571429
+ 0.93 0.64 0.79 64642857
+ 0.93 0.64 0.79 71714286
+ 0.93 0.64 0.79 78785714
+ 0.93 0.64 0.79 85857143
+ 0.93 0.64 0.79 92928571
+ 0.93 0.64 0.79 100000000
+ 0.93 0.64 0.86 1000000
+ 0.93 0.64 0.86 8071429
+ 0.93 0.64 0.86 15142857
+ 0.93 0.64 0.86 22214286
+ 0.93 0.64 0.86 29285714
+ 0.93 0.64 0.86 36357143
+ 0.93 0.64 0.86 43428571
+ 0.93 0.64 0.86 50500000
+ 0.93 0.64 0.86 57571429
+ 0.93 0.64 0.86 64642857
+ 0.93 0.64 0.86 71714286
+ 0.93 0.64 0.86 78785714
+ 0.93 0.64 0.86 85857143
+ 0.93 0.64 0.86 92928571
+ 0.93 0.64 0.86 100000000
+ 0.93 0.64 0.93 1000000
+ 0.93 0.64 0.93 8071429
+ 0.93 0.64 0.93 15142857
+ 0.93 0.64 0.93 22214286
+ 0.93 0.64 0.93 29285714
+ 0.93 0.64 0.93 36357143
+ 0.93 0.64 0.93 43428571
+ 0.93 0.64 0.93 50500000
+ 0.93 0.64 0.93 57571429
+ 0.93 0.64 0.93 64642857
+ 0.93 0.64 0.93 71714286
+ 0.93 0.64 0.93 78785714
+ 0.93 0.64 0.93 85857143
+ 0.93 0.64 0.93 92928571
+ 0.93 0.64 0.93 100000000
+ 0.93 0.64 1.00 1000000
+ 0.93 0.64 1.00 8071429
+ 0.93 0.64 1.00 15142857
+ 0.93 0.64 1.00 22214286
+ 0.93 0.64 1.00 29285714
+ 0.93 0.64 1.00 36357143
+ 0.93 0.64 1.00 43428571
+ 0.93 0.64 1.00 50500000
+ 0.93 0.64 1.00 57571429
+ 0.93 0.64 1.00 64642857
+ 0.93 0.64 1.00 71714286
+ 0.93 0.64 1.00 78785714
+ 0.93 0.64 1.00 85857143
+ 0.93 0.64 1.00 92928571
+ 0.93 0.64 1.00 100000000
+ 0.93 0.71 0.00 1000000
+ 0.93 0.71 0.00 8071429
+ 0.93 0.71 0.00 15142857
+ 0.93 0.71 0.00 22214286
+ 0.93 0.71 0.00 29285714
+ 0.93 0.71 0.00 36357143
+ 0.93 0.71 0.00 43428571
+ 0.93 0.71 0.00 50500000
+ 0.93 0.71 0.00 57571429
+ 0.93 0.71 0.00 64642857
+ 0.93 0.71 0.00 71714286
+ 0.93 0.71 0.00 78785714
+ 0.93 0.71 0.00 85857143
+ 0.93 0.71 0.00 92928571
+ 0.93 0.71 0.00 100000000
+ 0.93 0.71 0.07 1000000
+ 0.93 0.71 0.07 8071429
+ 0.93 0.71 0.07 15142857
+ 0.93 0.71 0.07 22214286
+ 0.93 0.71 0.07 29285714
+ 0.93 0.71 0.07 36357143
+ 0.93 0.71 0.07 43428571
+ 0.93 0.71 0.07 50500000
+ 0.93 0.71 0.07 57571429
+ 0.93 0.71 0.07 64642857
+ 0.93 0.71 0.07 71714286
+ 0.93 0.71 0.07 78785714
+ 0.93 0.71 0.07 85857143
+ 0.93 0.71 0.07 92928571
+ 0.93 0.71 0.07 100000000
+ 0.93 0.71 0.14 1000000
+ 0.93 0.71 0.14 8071429
+ 0.93 0.71 0.14 15142857
+ 0.93 0.71 0.14 22214286
+ 0.93 0.71 0.14 29285714
+ 0.93 0.71 0.14 36357143
+ 0.93 0.71 0.14 43428571
+ 0.93 0.71 0.14 50500000
+ 0.93 0.71 0.14 57571429
+ 0.93 0.71 0.14 64642857
+ 0.93 0.71 0.14 71714286
+ 0.93 0.71 0.14 78785714
+ 0.93 0.71 0.14 85857143
+ 0.93 0.71 0.14 92928571
+ 0.93 0.71 0.14 100000000
+ 0.93 0.71 0.21 1000000
+ 0.93 0.71 0.21 8071429
+ 0.93 0.71 0.21 15142857
+ 0.93 0.71 0.21 22214286
+ 0.93 0.71 0.21 29285714
+ 0.93 0.71 0.21 36357143
+ 0.93 0.71 0.21 43428571
+ 0.93 0.71 0.21 50500000
+ 0.93 0.71 0.21 57571429
+ 0.93 0.71 0.21 64642857
+ 0.93 0.71 0.21 71714286
+ 0.93 0.71 0.21 78785714
+ 0.93 0.71 0.21 85857143
+ 0.93 0.71 0.21 92928571
+ 0.93 0.71 0.21 100000000
+ 0.93 0.71 0.29 1000000
+ 0.93 0.71 0.29 8071429
+ 0.93 0.71 0.29 15142857
+ 0.93 0.71 0.29 22214286
+ 0.93 0.71 0.29 29285714
+ 0.93 0.71 0.29 36357143
+ 0.93 0.71 0.29 43428571
+ 0.93 0.71 0.29 50500000
+ 0.93 0.71 0.29 57571429
+ 0.93 0.71 0.29 64642857
+ 0.93 0.71 0.29 71714286
+ 0.93 0.71 0.29 78785714
+ 0.93 0.71 0.29 85857143
+ 0.93 0.71 0.29 92928571
+ 0.93 0.71 0.29 100000000
+ 0.93 0.71 0.36 1000000
+ 0.93 0.71 0.36 8071429
+ 0.93 0.71 0.36 15142857
+ 0.93 0.71 0.36 22214286
+ 0.93 0.71 0.36 29285714
+ 0.93 0.71 0.36 36357143
+ 0.93 0.71 0.36 43428571
+ 0.93 0.71 0.36 50500000
+ 0.93 0.71 0.36 57571429
+ 0.93 0.71 0.36 64642857
+ 0.93 0.71 0.36 71714286
+ 0.93 0.71 0.36 78785714
+ 0.93 0.71 0.36 85857143
+ 0.93 0.71 0.36 92928571
+ 0.93 0.71 0.36 100000000
+ 0.93 0.71 0.43 1000000
+ 0.93 0.71 0.43 8071429
+ 0.93 0.71 0.43 15142857
+ 0.93 0.71 0.43 22214286
+ 0.93 0.71 0.43 29285714
+ 0.93 0.71 0.43 36357143
+ 0.93 0.71 0.43 43428571
+ 0.93 0.71 0.43 50500000
+ 0.93 0.71 0.43 57571429
+ 0.93 0.71 0.43 64642857
+ 0.93 0.71 0.43 71714286
+ 0.93 0.71 0.43 78785714
+ 0.93 0.71 0.43 85857143
+ 0.93 0.71 0.43 92928571
+ 0.93 0.71 0.43 100000000
+ 0.93 0.71 0.50 1000000
+ 0.93 0.71 0.50 8071429
+ 0.93 0.71 0.50 15142857
+ 0.93 0.71 0.50 22214286
+ 0.93 0.71 0.50 29285714
+ 0.93 0.71 0.50 36357143
+ 0.93 0.71 0.50 43428571
+ 0.93 0.71 0.50 50500000
+ 0.93 0.71 0.50 57571429
+ 0.93 0.71 0.50 64642857
+ 0.93 0.71 0.50 71714286
+ 0.93 0.71 0.50 78785714
+ 0.93 0.71 0.50 85857143
+ 0.93 0.71 0.50 92928571
+ 0.93 0.71 0.50 100000000
+ 0.93 0.71 0.57 1000000
+ 0.93 0.71 0.57 8071429
+ 0.93 0.71 0.57 15142857
+ 0.93 0.71 0.57 22214286
+ 0.93 0.71 0.57 29285714
+ 0.93 0.71 0.57 36357143
+ 0.93 0.71 0.57 43428571
+ 0.93 0.71 0.57 50500000
+ 0.93 0.71 0.57 57571429
+ 0.93 0.71 0.57 64642857
+ 0.93 0.71 0.57 71714286
+ 0.93 0.71 0.57 78785714
+ 0.93 0.71 0.57 85857143
+ 0.93 0.71 0.57 92928571
+ 0.93 0.71 0.57 100000000
+ 0.93 0.71 0.64 1000000
+ 0.93 0.71 0.64 8071429
+ 0.93 0.71 0.64 15142857
+ 0.93 0.71 0.64 22214286
+ 0.93 0.71 0.64 29285714
+ 0.93 0.71 0.64 36357143
+ 0.93 0.71 0.64 43428571
+ 0.93 0.71 0.64 50500000
+ 0.93 0.71 0.64 57571429
+ 0.93 0.71 0.64 64642857
+ 0.93 0.71 0.64 71714286
+ 0.93 0.71 0.64 78785714
+ 0.93 0.71 0.64 85857143
+ 0.93 0.71 0.64 92928571
+ 0.93 0.71 0.64 100000000
+ 0.93 0.71 0.71 1000000
+ 0.93 0.71 0.71 8071429
+ 0.93 0.71 0.71 15142857
+ 0.93 0.71 0.71 22214286
+ 0.93 0.71 0.71 29285714
+ 0.93 0.71 0.71 36357143
+ 0.93 0.71 0.71 43428571
+ 0.93 0.71 0.71 50500000
+ 0.93 0.71 0.71 57571429
+ 0.93 0.71 0.71 64642857
+ 0.93 0.71 0.71 71714286
+ 0.93 0.71 0.71 78785714
+ 0.93 0.71 0.71 85857143
+ 0.93 0.71 0.71 92928571
+ 0.93 0.71 0.71 100000000
+ 0.93 0.71 0.79 1000000
+ 0.93 0.71 0.79 8071429
+ 0.93 0.71 0.79 15142857
+ 0.93 0.71 0.79 22214286
+ 0.93 0.71 0.79 29285714
+ 0.93 0.71 0.79 36357143
+ 0.93 0.71 0.79 43428571
+ 0.93 0.71 0.79 50500000
+ 0.93 0.71 0.79 57571429
+ 0.93 0.71 0.79 64642857
+ 0.93 0.71 0.79 71714286
+ 0.93 0.71 0.79 78785714
+ 0.93 0.71 0.79 85857143
+ 0.93 0.71 0.79 92928571
+ 0.93 0.71 0.79 100000000
+ 0.93 0.71 0.86 1000000
+ 0.93 0.71 0.86 8071429
+ 0.93 0.71 0.86 15142857
+ 0.93 0.71 0.86 22214286
+ 0.93 0.71 0.86 29285714
+ 0.93 0.71 0.86 36357143
+ 0.93 0.71 0.86 43428571
+ 0.93 0.71 0.86 50500000
+ 0.93 0.71 0.86 57571429
+ 0.93 0.71 0.86 64642857
+ 0.93 0.71 0.86 71714286
+ 0.93 0.71 0.86 78785714
+ 0.93 0.71 0.86 85857143
+ 0.93 0.71 0.86 92928571
+ 0.93 0.71 0.86 100000000
+ 0.93 0.71 0.93 1000000
+ 0.93 0.71 0.93 8071429
+ 0.93 0.71 0.93 15142857
+ 0.93 0.71 0.93 22214286
+ 0.93 0.71 0.93 29285714
+ 0.93 0.71 0.93 36357143
+ 0.93 0.71 0.93 43428571
+ 0.93 0.71 0.93 50500000
+ 0.93 0.71 0.93 57571429
+ 0.93 0.71 0.93 64642857
+ 0.93 0.71 0.93 71714286
+ 0.93 0.71 0.93 78785714
+ 0.93 0.71 0.93 85857143
+ 0.93 0.71 0.93 92928571
+ 0.93 0.71 0.93 100000000
+ 0.93 0.71 1.00 1000000
+ 0.93 0.71 1.00 8071429
+ 0.93 0.71 1.00 15142857
+ 0.93 0.71 1.00 22214286
+ 0.93 0.71 1.00 29285714
+ 0.93 0.71 1.00 36357143
+ 0.93 0.71 1.00 43428571
+ 0.93 0.71 1.00 50500000
+ 0.93 0.71 1.00 57571429
+ 0.93 0.71 1.00 64642857
+ 0.93 0.71 1.00 71714286
+ 0.93 0.71 1.00 78785714
+ 0.93 0.71 1.00 85857143
+ 0.93 0.71 1.00 92928571
+ 0.93 0.71 1.00 100000000
+ 0.93 0.79 0.00 1000000
+ 0.93 0.79 0.00 8071429
+ 0.93 0.79 0.00 15142857
+ 0.93 0.79 0.00 22214286
+ 0.93 0.79 0.00 29285714
+ 0.93 0.79 0.00 36357143
+ 0.93 0.79 0.00 43428571
+ 0.93 0.79 0.00 50500000
+ 0.93 0.79 0.00 57571429
+ 0.93 0.79 0.00 64642857
+ 0.93 0.79 0.00 71714286
+ 0.93 0.79 0.00 78785714
+ 0.93 0.79 0.00 85857143
+ 0.93 0.79 0.00 92928571
+ 0.93 0.79 0.00 100000000
+ 0.93 0.79 0.07 1000000
+ 0.93 0.79 0.07 8071429
+ 0.93 0.79 0.07 15142857
+ 0.93 0.79 0.07 22214286
+ 0.93 0.79 0.07 29285714
+ 0.93 0.79 0.07 36357143
+ 0.93 0.79 0.07 43428571
+ 0.93 0.79 0.07 50500000
+ 0.93 0.79 0.07 57571429
+ 0.93 0.79 0.07 64642857
+ 0.93 0.79 0.07 71714286
+ 0.93 0.79 0.07 78785714
+ 0.93 0.79 0.07 85857143
+ 0.93 0.79 0.07 92928571
+ 0.93 0.79 0.07 100000000
+ 0.93 0.79 0.14 1000000
+ 0.93 0.79 0.14 8071429
+ 0.93 0.79 0.14 15142857
+ 0.93 0.79 0.14 22214286
+ 0.93 0.79 0.14 29285714
+ 0.93 0.79 0.14 36357143
+ 0.93 0.79 0.14 43428571
+ 0.93 0.79 0.14 50500000
+ 0.93 0.79 0.14 57571429
+ 0.93 0.79 0.14 64642857
+ 0.93 0.79 0.14 71714286
+ 0.93 0.79 0.14 78785714
+ 0.93 0.79 0.14 85857143
+ 0.93 0.79 0.14 92928571
+ 0.93 0.79 0.14 100000000
+ 0.93 0.79 0.21 1000000
+ 0.93 0.79 0.21 8071429
+ 0.93 0.79 0.21 15142857
+ 0.93 0.79 0.21 22214286
+ 0.93 0.79 0.21 29285714
+ 0.93 0.79 0.21 36357143
+ 0.93 0.79 0.21 43428571
+ 0.93 0.79 0.21 50500000
+ 0.93 0.79 0.21 57571429
+ 0.93 0.79 0.21 64642857
+ 0.93 0.79 0.21 71714286
+ 0.93 0.79 0.21 78785714
+ 0.93 0.79 0.21 85857143
+ 0.93 0.79 0.21 92928571
+ 0.93 0.79 0.21 100000000
+ 0.93 0.79 0.29 1000000
+ 0.93 0.79 0.29 8071429
+ 0.93 0.79 0.29 15142857
+ 0.93 0.79 0.29 22214286
+ 0.93 0.79 0.29 29285714
+ 0.93 0.79 0.29 36357143
+ 0.93 0.79 0.29 43428571
+ 0.93 0.79 0.29 50500000
+ 0.93 0.79 0.29 57571429
+ 0.93 0.79 0.29 64642857
+ 0.93 0.79 0.29 71714286
+ 0.93 0.79 0.29 78785714
+ 0.93 0.79 0.29 85857143
+ 0.93 0.79 0.29 92928571
+ 0.93 0.79 0.29 100000000
+ 0.93 0.79 0.36 1000000
+ 0.93 0.79 0.36 8071429
+ 0.93 0.79 0.36 15142857
+ 0.93 0.79 0.36 22214286
+ 0.93 0.79 0.36 29285714
+ 0.93 0.79 0.36 36357143
+ 0.93 0.79 0.36 43428571
+ 0.93 0.79 0.36 50500000
+ 0.93 0.79 0.36 57571429
+ 0.93 0.79 0.36 64642857
+ 0.93 0.79 0.36 71714286
+ 0.93 0.79 0.36 78785714
+ 0.93 0.79 0.36 85857143
+ 0.93 0.79 0.36 92928571
+ 0.93 0.79 0.36 100000000
+ 0.93 0.79 0.43 1000000
+ 0.93 0.79 0.43 8071429
+ 0.93 0.79 0.43 15142857
+ 0.93 0.79 0.43 22214286
+ 0.93 0.79 0.43 29285714
+ 0.93 0.79 0.43 36357143
+ 0.93 0.79 0.43 43428571
+ 0.93 0.79 0.43 50500000
+ 0.93 0.79 0.43 57571429
+ 0.93 0.79 0.43 64642857
+ 0.93 0.79 0.43 71714286
+ 0.93 0.79 0.43 78785714
+ 0.93 0.79 0.43 85857143
+ 0.93 0.79 0.43 92928571
+ 0.93 0.79 0.43 100000000
+ 0.93 0.79 0.50 1000000
+ 0.93 0.79 0.50 8071429
+ 0.93 0.79 0.50 15142857
+ 0.93 0.79 0.50 22214286
+ 0.93 0.79 0.50 29285714
+ 0.93 0.79 0.50 36357143
+ 0.93 0.79 0.50 43428571
+ 0.93 0.79 0.50 50500000
+ 0.93 0.79 0.50 57571429
+ 0.93 0.79 0.50 64642857
+ 0.93 0.79 0.50 71714286
+ 0.93 0.79 0.50 78785714
+ 0.93 0.79 0.50 85857143
+ 0.93 0.79 0.50 92928571
+ 0.93 0.79 0.50 100000000
+ 0.93 0.79 0.57 1000000
+ 0.93 0.79 0.57 8071429
+ 0.93 0.79 0.57 15142857
+ 0.93 0.79 0.57 22214286
+ 0.93 0.79 0.57 29285714
+ 0.93 0.79 0.57 36357143
+ 0.93 0.79 0.57 43428571
+ 0.93 0.79 0.57 50500000
+ 0.93 0.79 0.57 57571429
+ 0.93 0.79 0.57 64642857
+ 0.93 0.79 0.57 71714286
+ 0.93 0.79 0.57 78785714
+ 0.93 0.79 0.57 85857143
+ 0.93 0.79 0.57 92928571
+ 0.93 0.79 0.57 100000000
+ 0.93 0.79 0.64 1000000
+ 0.93 0.79 0.64 8071429
+ 0.93 0.79 0.64 15142857
+ 0.93 0.79 0.64 22214286
+ 0.93 0.79 0.64 29285714
+ 0.93 0.79 0.64 36357143
+ 0.93 0.79 0.64 43428571
+ 0.93 0.79 0.64 50500000
+ 0.93 0.79 0.64 57571429
+ 0.93 0.79 0.64 64642857
+ 0.93 0.79 0.64 71714286
+ 0.93 0.79 0.64 78785714
+ 0.93 0.79 0.64 85857143
+ 0.93 0.79 0.64 92928571
+ 0.93 0.79 0.64 100000000
+ 0.93 0.79 0.71 1000000
+ 0.93 0.79 0.71 8071429
+ 0.93 0.79 0.71 15142857
+ 0.93 0.79 0.71 22214286
+ 0.93 0.79 0.71 29285714
+ 0.93 0.79 0.71 36357143
+ 0.93 0.79 0.71 43428571
+ 0.93 0.79 0.71 50500000
+ 0.93 0.79 0.71 57571429
+ 0.93 0.79 0.71 64642857
+ 0.93 0.79 0.71 71714286
+ 0.93 0.79 0.71 78785714
+ 0.93 0.79 0.71 85857143
+ 0.93 0.79 0.71 92928571
+ 0.93 0.79 0.71 100000000
+ 0.93 0.79 0.79 1000000
+ 0.93 0.79 0.79 8071429
+ 0.93 0.79 0.79 15142857
+ 0.93 0.79 0.79 22214286
+ 0.93 0.79 0.79 29285714
+ 0.93 0.79 0.79 36357143
+ 0.93 0.79 0.79 43428571
+ 0.93 0.79 0.79 50500000
+ 0.93 0.79 0.79 57571429
+ 0.93 0.79 0.79 64642857
+ 0.93 0.79 0.79 71714286
+ 0.93 0.79 0.79 78785714
+ 0.93 0.79 0.79 85857143
+ 0.93 0.79 0.79 92928571
+ 0.93 0.79 0.79 100000000
+ 0.93 0.79 0.86 1000000
+ 0.93 0.79 0.86 8071429
+ 0.93 0.79 0.86 15142857
+ 0.93 0.79 0.86 22214286
+ 0.93 0.79 0.86 29285714
+ 0.93 0.79 0.86 36357143
+ 0.93 0.79 0.86 43428571
+ 0.93 0.79 0.86 50500000
+ 0.93 0.79 0.86 57571429
+ 0.93 0.79 0.86 64642857
+ 0.93 0.79 0.86 71714286
+ 0.93 0.79 0.86 78785714
+ 0.93 0.79 0.86 85857143
+ 0.93 0.79 0.86 92928571
+ 0.93 0.79 0.86 100000000
+ 0.93 0.79 0.93 1000000
+ 0.93 0.79 0.93 8071429
+ 0.93 0.79 0.93 15142857
+ 0.93 0.79 0.93 22214286
+ 0.93 0.79 0.93 29285714
+ 0.93 0.79 0.93 36357143
+ 0.93 0.79 0.93 43428571
+ 0.93 0.79 0.93 50500000
+ 0.93 0.79 0.93 57571429
+ 0.93 0.79 0.93 64642857
+ 0.93 0.79 0.93 71714286
+ 0.93 0.79 0.93 78785714
+ 0.93 0.79 0.93 85857143
+ 0.93 0.79 0.93 92928571
+ 0.93 0.79 0.93 100000000
+ 0.93 0.79 1.00 1000000
+ 0.93 0.79 1.00 8071429
+ 0.93 0.79 1.00 15142857
+ 0.93 0.79 1.00 22214286
+ 0.93 0.79 1.00 29285714
+ 0.93 0.79 1.00 36357143
+ 0.93 0.79 1.00 43428571
+ 0.93 0.79 1.00 50500000
+ 0.93 0.79 1.00 57571429
+ 0.93 0.79 1.00 64642857
+ 0.93 0.79 1.00 71714286
+ 0.93 0.79 1.00 78785714
+ 0.93 0.79 1.00 85857143
+ 0.93 0.79 1.00 92928571
+ 0.93 0.79 1.00 100000000
+ 0.93 0.86 0.00 1000000
+ 0.93 0.86 0.00 8071429
+ 0.93 0.86 0.00 15142857
+ 0.93 0.86 0.00 22214286
+ 0.93 0.86 0.00 29285714
+ 0.93 0.86 0.00 36357143
+ 0.93 0.86 0.00 43428571
+ 0.93 0.86 0.00 50500000
+ 0.93 0.86 0.00 57571429
+ 0.93 0.86 0.00 64642857
+ 0.93 0.86 0.00 71714286
+ 0.93 0.86 0.00 78785714
+ 0.93 0.86 0.00 85857143
+ 0.93 0.86 0.00 92928571
+ 0.93 0.86 0.00 100000000
+ 0.93 0.86 0.07 1000000
+ 0.93 0.86 0.07 8071429
+ 0.93 0.86 0.07 15142857
+ 0.93 0.86 0.07 22214286
+ 0.93 0.86 0.07 29285714
+ 0.93 0.86 0.07 36357143
+ 0.93 0.86 0.07 43428571
+ 0.93 0.86 0.07 50500000
+ 0.93 0.86 0.07 57571429
+ 0.93 0.86 0.07 64642857
+ 0.93 0.86 0.07 71714286
+ 0.93 0.86 0.07 78785714
+ 0.93 0.86 0.07 85857143
+ 0.93 0.86 0.07 92928571
+ 0.93 0.86 0.07 100000000
+ 0.93 0.86 0.14 1000000
+ 0.93 0.86 0.14 8071429
+ 0.93 0.86 0.14 15142857
+ 0.93 0.86 0.14 22214286
+ 0.93 0.86 0.14 29285714
+ 0.93 0.86 0.14 36357143
+ 0.93 0.86 0.14 43428571
+ 0.93 0.86 0.14 50500000
+ 0.93 0.86 0.14 57571429
+ 0.93 0.86 0.14 64642857
+ 0.93 0.86 0.14 71714286
+ 0.93 0.86 0.14 78785714
+ 0.93 0.86 0.14 85857143
+ 0.93 0.86 0.14 92928571
+ 0.93 0.86 0.14 100000000
+ 0.93 0.86 0.21 1000000
+ 0.93 0.86 0.21 8071429
+ 0.93 0.86 0.21 15142857
+ 0.93 0.86 0.21 22214286
+ 0.93 0.86 0.21 29285714
+ 0.93 0.86 0.21 36357143
+ 0.93 0.86 0.21 43428571
+ 0.93 0.86 0.21 50500000
+ 0.93 0.86 0.21 57571429
+ 0.93 0.86 0.21 64642857
+ 0.93 0.86 0.21 71714286
+ 0.93 0.86 0.21 78785714
+ 0.93 0.86 0.21 85857143
+ 0.93 0.86 0.21 92928571
+ 0.93 0.86 0.21 100000000
+ 0.93 0.86 0.29 1000000
+ 0.93 0.86 0.29 8071429
+ 0.93 0.86 0.29 15142857
+ 0.93 0.86 0.29 22214286
+ 0.93 0.86 0.29 29285714
+ 0.93 0.86 0.29 36357143
+ 0.93 0.86 0.29 43428571
+ 0.93 0.86 0.29 50500000
+ 0.93 0.86 0.29 57571429
+ 0.93 0.86 0.29 64642857
+ 0.93 0.86 0.29 71714286
+ 0.93 0.86 0.29 78785714
+ 0.93 0.86 0.29 85857143
+ 0.93 0.86 0.29 92928571
+ 0.93 0.86 0.29 100000000
+ 0.93 0.86 0.36 1000000
+ 0.93 0.86 0.36 8071429
+ 0.93 0.86 0.36 15142857
+ 0.93 0.86 0.36 22214286
+ 0.93 0.86 0.36 29285714
+ 0.93 0.86 0.36 36357143
+ 0.93 0.86 0.36 43428571
+ 0.93 0.86 0.36 50500000
+ 0.93 0.86 0.36 57571429
+ 0.93 0.86 0.36 64642857
+ 0.93 0.86 0.36 71714286
+ 0.93 0.86 0.36 78785714
+ 0.93 0.86 0.36 85857143
+ 0.93 0.86 0.36 92928571
+ 0.93 0.86 0.36 100000000
+ 0.93 0.86 0.43 1000000
+ 0.93 0.86 0.43 8071429
+ 0.93 0.86 0.43 15142857
+ 0.93 0.86 0.43 22214286
+ 0.93 0.86 0.43 29285714
+ 0.93 0.86 0.43 36357143
+ 0.93 0.86 0.43 43428571
+ 0.93 0.86 0.43 50500000
+ 0.93 0.86 0.43 57571429
+ 0.93 0.86 0.43 64642857
+ 0.93 0.86 0.43 71714286
+ 0.93 0.86 0.43 78785714
+ 0.93 0.86 0.43 85857143
+ 0.93 0.86 0.43 92928571
+ 0.93 0.86 0.43 100000000
+ 0.93 0.86 0.50 1000000
+ 0.93 0.86 0.50 8071429
+ 0.93 0.86 0.50 15142857
+ 0.93 0.86 0.50 22214286
+ 0.93 0.86 0.50 29285714
+ 0.93 0.86 0.50 36357143
+ 0.93 0.86 0.50 43428571
+ 0.93 0.86 0.50 50500000
+ 0.93 0.86 0.50 57571429
+ 0.93 0.86 0.50 64642857
+ 0.93 0.86 0.50 71714286
+ 0.93 0.86 0.50 78785714
+ 0.93 0.86 0.50 85857143
+ 0.93 0.86 0.50 92928571
+ 0.93 0.86 0.50 100000000
+ 0.93 0.86 0.57 1000000
+ 0.93 0.86 0.57 8071429
+ 0.93 0.86 0.57 15142857
+ 0.93 0.86 0.57 22214286
+ 0.93 0.86 0.57 29285714
+ 0.93 0.86 0.57 36357143
+ 0.93 0.86 0.57 43428571
+ 0.93 0.86 0.57 50500000
+ 0.93 0.86 0.57 57571429
+ 0.93 0.86 0.57 64642857
+ 0.93 0.86 0.57 71714286
+ 0.93 0.86 0.57 78785714
+ 0.93 0.86 0.57 85857143
+ 0.93 0.86 0.57 92928571
+ 0.93 0.86 0.57 100000000
+ 0.93 0.86 0.64 1000000
+ 0.93 0.86 0.64 8071429
+ 0.93 0.86 0.64 15142857
+ 0.93 0.86 0.64 22214286
+ 0.93 0.86 0.64 29285714
+ 0.93 0.86 0.64 36357143
+ 0.93 0.86 0.64 43428571
+ 0.93 0.86 0.64 50500000
+ 0.93 0.86 0.64 57571429
+ 0.93 0.86 0.64 64642857
+ 0.93 0.86 0.64 71714286
+ 0.93 0.86 0.64 78785714
+ 0.93 0.86 0.64 85857143
+ 0.93 0.86 0.64 92928571
+ 0.93 0.86 0.64 100000000
+ 0.93 0.86 0.71 1000000
+ 0.93 0.86 0.71 8071429
+ 0.93 0.86 0.71 15142857
+ 0.93 0.86 0.71 22214286
+ 0.93 0.86 0.71 29285714
+ 0.93 0.86 0.71 36357143
+ 0.93 0.86 0.71 43428571
+ 0.93 0.86 0.71 50500000
+ 0.93 0.86 0.71 57571429
+ 0.93 0.86 0.71 64642857
+ 0.93 0.86 0.71 71714286
+ 0.93 0.86 0.71 78785714
+ 0.93 0.86 0.71 85857143
+ 0.93 0.86 0.71 92928571
+ 0.93 0.86 0.71 100000000
+ 0.93 0.86 0.79 1000000
+ 0.93 0.86 0.79 8071429
+ 0.93 0.86 0.79 15142857
+ 0.93 0.86 0.79 22214286
+ 0.93 0.86 0.79 29285714
+ 0.93 0.86 0.79 36357143
+ 0.93 0.86 0.79 43428571
+ 0.93 0.86 0.79 50500000
+ 0.93 0.86 0.79 57571429
+ 0.93 0.86 0.79 64642857
+ 0.93 0.86 0.79 71714286
+ 0.93 0.86 0.79 78785714
+ 0.93 0.86 0.79 85857143
+ 0.93 0.86 0.79 92928571
+ 0.93 0.86 0.79 100000000
+ 0.93 0.86 0.86 1000000
+ 0.93 0.86 0.86 8071429
+ 0.93 0.86 0.86 15142857
+ 0.93 0.86 0.86 22214286
+ 0.93 0.86 0.86 29285714
+ 0.93 0.86 0.86 36357143
+ 0.93 0.86 0.86 43428571
+ 0.93 0.86 0.86 50500000
+ 0.93 0.86 0.86 57571429
+ 0.93 0.86 0.86 64642857
+ 0.93 0.86 0.86 71714286
+ 0.93 0.86 0.86 78785714
+ 0.93 0.86 0.86 85857143
+ 0.93 0.86 0.86 92928571
+ 0.93 0.86 0.86 100000000
+ 0.93 0.86 0.93 1000000
+ 0.93 0.86 0.93 8071429
+ 0.93 0.86 0.93 15142857
+ 0.93 0.86 0.93 22214286
+ 0.93 0.86 0.93 29285714
+ 0.93 0.86 0.93 36357143
+ 0.93 0.86 0.93 43428571
+ 0.93 0.86 0.93 50500000
+ 0.93 0.86 0.93 57571429
+ 0.93 0.86 0.93 64642857
+ 0.93 0.86 0.93 71714286
+ 0.93 0.86 0.93 78785714
+ 0.93 0.86 0.93 85857143
+ 0.93 0.86 0.93 92928571
+ 0.93 0.86 0.93 100000000
+ 0.93 0.86 1.00 1000000
+ 0.93 0.86 1.00 8071429
+ 0.93 0.86 1.00 15142857
+ 0.93 0.86 1.00 22214286
+ 0.93 0.86 1.00 29285714
+ 0.93 0.86 1.00 36357143
+ 0.93 0.86 1.00 43428571
+ 0.93 0.86 1.00 50500000
+ 0.93 0.86 1.00 57571429
+ 0.93 0.86 1.00 64642857
+ 0.93 0.86 1.00 71714286
+ 0.93 0.86 1.00 78785714
+ 0.93 0.86 1.00 85857143
+ 0.93 0.86 1.00 92928571
+ 0.93 0.86 1.00 100000000
+ 0.93 0.93 0.00 1000000
+ 0.93 0.93 0.00 8071429
+ 0.93 0.93 0.00 15142857
+ 0.93 0.93 0.00 22214286
+ 0.93 0.93 0.00 29285714
+ 0.93 0.93 0.00 36357143
+ 0.93 0.93 0.00 43428571
+ 0.93 0.93 0.00 50500000
+ 0.93 0.93 0.00 57571429
+ 0.93 0.93 0.00 64642857
+ 0.93 0.93 0.00 71714286
+ 0.93 0.93 0.00 78785714
+ 0.93 0.93 0.00 85857143
+ 0.93 0.93 0.00 92928571
+ 0.93 0.93 0.00 100000000
+ 0.93 0.93 0.07 1000000
+ 0.93 0.93 0.07 8071429
+ 0.93 0.93 0.07 15142857
+ 0.93 0.93 0.07 22214286
+ 0.93 0.93 0.07 29285714
+ 0.93 0.93 0.07 36357143
+ 0.93 0.93 0.07 43428571
+ 0.93 0.93 0.07 50500000
+ 0.93 0.93 0.07 57571429
+ 0.93 0.93 0.07 64642857
+ 0.93 0.93 0.07 71714286
+ 0.93 0.93 0.07 78785714
+ 0.93 0.93 0.07 85857143
+ 0.93 0.93 0.07 92928571
+ 0.93 0.93 0.07 100000000
+ 0.93 0.93 0.14 1000000
+ 0.93 0.93 0.14 8071429
+ 0.93 0.93 0.14 15142857
+ 0.93 0.93 0.14 22214286
+ 0.93 0.93 0.14 29285714
+ 0.93 0.93 0.14 36357143
+ 0.93 0.93 0.14 43428571
+ 0.93 0.93 0.14 50500000
+ 0.93 0.93 0.14 57571429
+ 0.93 0.93 0.14 64642857
+ 0.93 0.93 0.14 71714286
+ 0.93 0.93 0.14 78785714
+ 0.93 0.93 0.14 85857143
+ 0.93 0.93 0.14 92928571
+ 0.93 0.93 0.14 100000000
+ 0.93 0.93 0.21 1000000
+ 0.93 0.93 0.21 8071429
+ 0.93 0.93 0.21 15142857
+ 0.93 0.93 0.21 22214286
+ 0.93 0.93 0.21 29285714
+ 0.93 0.93 0.21 36357143
+ 0.93 0.93 0.21 43428571
+ 0.93 0.93 0.21 50500000
+ 0.93 0.93 0.21 57571429
+ 0.93 0.93 0.21 64642857
+ 0.93 0.93 0.21 71714286
+ 0.93 0.93 0.21 78785714
+ 0.93 0.93 0.21 85857143
+ 0.93 0.93 0.21 92928571
+ 0.93 0.93 0.21 100000000
+ 0.93 0.93 0.29 1000000
+ 0.93 0.93 0.29 8071429
+ 0.93 0.93 0.29 15142857
+ 0.93 0.93 0.29 22214286
+ 0.93 0.93 0.29 29285714
+ 0.93 0.93 0.29 36357143
+ 0.93 0.93 0.29 43428571
+ 0.93 0.93 0.29 50500000
+ 0.93 0.93 0.29 57571429
+ 0.93 0.93 0.29 64642857
+ 0.93 0.93 0.29 71714286
+ 0.93 0.93 0.29 78785714
+ 0.93 0.93 0.29 85857143
+ 0.93 0.93 0.29 92928571
+ 0.93 0.93 0.29 100000000
+ 0.93 0.93 0.36 1000000
+ 0.93 0.93 0.36 8071429
+ 0.93 0.93 0.36 15142857
+ 0.93 0.93 0.36 22214286
+ 0.93 0.93 0.36 29285714
+ 0.93 0.93 0.36 36357143
+ 0.93 0.93 0.36 43428571
+ 0.93 0.93 0.36 50500000
+ 0.93 0.93 0.36 57571429
+ 0.93 0.93 0.36 64642857
+ 0.93 0.93 0.36 71714286
+ 0.93 0.93 0.36 78785714
+ 0.93 0.93 0.36 85857143
+ 0.93 0.93 0.36 92928571
+ 0.93 0.93 0.36 100000000
+ 0.93 0.93 0.43 1000000
+ 0.93 0.93 0.43 8071429
+ 0.93 0.93 0.43 15142857
+ 0.93 0.93 0.43 22214286
+ 0.93 0.93 0.43 29285714
+ 0.93 0.93 0.43 36357143
+ 0.93 0.93 0.43 43428571
+ 0.93 0.93 0.43 50500000
+ 0.93 0.93 0.43 57571429
+ 0.93 0.93 0.43 64642857
+ 0.93 0.93 0.43 71714286
+ 0.93 0.93 0.43 78785714
+ 0.93 0.93 0.43 85857143
+ 0.93 0.93 0.43 92928571
+ 0.93 0.93 0.43 100000000
+ 0.93 0.93 0.50 1000000
+ 0.93 0.93 0.50 8071429
+ 0.93 0.93 0.50 15142857
+ 0.93 0.93 0.50 22214286
+ 0.93 0.93 0.50 29285714
+ 0.93 0.93 0.50 36357143
+ 0.93 0.93 0.50 43428571
+ 0.93 0.93 0.50 50500000
+ 0.93 0.93 0.50 57571429
+ 0.93 0.93 0.50 64642857
+ 0.93 0.93 0.50 71714286
+ 0.93 0.93 0.50 78785714
+ 0.93 0.93 0.50 85857143
+ 0.93 0.93 0.50 92928571
+ 0.93 0.93 0.50 100000000
+ 0.93 0.93 0.57 1000000
+ 0.93 0.93 0.57 8071429
+ 0.93 0.93 0.57 15142857
+ 0.93 0.93 0.57 22214286
+ 0.93 0.93 0.57 29285714
+ 0.93 0.93 0.57 36357143
+ 0.93 0.93 0.57 43428571
+ 0.93 0.93 0.57 50500000
+ 0.93 0.93 0.57 57571429
+ 0.93 0.93 0.57 64642857
+ 0.93 0.93 0.57 71714286
+ 0.93 0.93 0.57 78785714
+ 0.93 0.93 0.57 85857143
+ 0.93 0.93 0.57 92928571
+ 0.93 0.93 0.57 100000000
+ 0.93 0.93 0.64 1000000
+ 0.93 0.93 0.64 8071429
+ 0.93 0.93 0.64 15142857
+ 0.93 0.93 0.64 22214286
+ 0.93 0.93 0.64 29285714
+ 0.93 0.93 0.64 36357143
+ 0.93 0.93 0.64 43428571
+ 0.93 0.93 0.64 50500000
+ 0.93 0.93 0.64 57571429
+ 0.93 0.93 0.64 64642857
+ 0.93 0.93 0.64 71714286
+ 0.93 0.93 0.64 78785714
+ 0.93 0.93 0.64 85857143
+ 0.93 0.93 0.64 92928571
+ 0.93 0.93 0.64 100000000
+ 0.93 0.93 0.71 1000000
+ 0.93 0.93 0.71 8071429
+ 0.93 0.93 0.71 15142857
+ 0.93 0.93 0.71 22214286
+ 0.93 0.93 0.71 29285714
+ 0.93 0.93 0.71 36357143
+ 0.93 0.93 0.71 43428571
+ 0.93 0.93 0.71 50500000
+ 0.93 0.93 0.71 57571429
+ 0.93 0.93 0.71 64642857
+ 0.93 0.93 0.71 71714286
+ 0.93 0.93 0.71 78785714
+ 0.93 0.93 0.71 85857143
+ 0.93 0.93 0.71 92928571
+ 0.93 0.93 0.71 100000000
+ 0.93 0.93 0.79 1000000
+ 0.93 0.93 0.79 8071429
+ 0.93 0.93 0.79 15142857
+ 0.93 0.93 0.79 22214286
+ 0.93 0.93 0.79 29285714
+ 0.93 0.93 0.79 36357143
+ 0.93 0.93 0.79 43428571
+ 0.93 0.93 0.79 50500000
+ 0.93 0.93 0.79 57571429
+ 0.93 0.93 0.79 64642857
+ 0.93 0.93 0.79 71714286
+ 0.93 0.93 0.79 78785714
+ 0.93 0.93 0.79 85857143
+ 0.93 0.93 0.79 92928571
+ 0.93 0.93 0.79 100000000
+ 0.93 0.93 0.86 1000000
+ 0.93 0.93 0.86 8071429
+ 0.93 0.93 0.86 15142857
+ 0.93 0.93 0.86 22214286
+ 0.93 0.93 0.86 29285714
+ 0.93 0.93 0.86 36357143
+ 0.93 0.93 0.86 43428571
+ 0.93 0.93 0.86 50500000
+ 0.93 0.93 0.86 57571429
+ 0.93 0.93 0.86 64642857
+ 0.93 0.93 0.86 71714286
+ 0.93 0.93 0.86 78785714
+ 0.93 0.93 0.86 85857143
+ 0.93 0.93 0.86 92928571
+ 0.93 0.93 0.86 100000000
+ 0.93 0.93 0.93 1000000
+ 0.93 0.93 0.93 8071429
+ 0.93 0.93 0.93 15142857
+ 0.93 0.93 0.93 22214286
+ 0.93 0.93 0.93 29285714
+ 0.93 0.93 0.93 36357143
+ 0.93 0.93 0.93 43428571
+ 0.93 0.93 0.93 50500000
+ 0.93 0.93 0.93 57571429
+ 0.93 0.93 0.93 64642857
+ 0.93 0.93 0.93 71714286
+ 0.93 0.93 0.93 78785714
+ 0.93 0.93 0.93 85857143
+ 0.93 0.93 0.93 92928571
+ 0.93 0.93 0.93 100000000
+ 0.93 0.93 1.00 1000000
+ 0.93 0.93 1.00 8071429
+ 0.93 0.93 1.00 15142857
+ 0.93 0.93 1.00 22214286
+ 0.93 0.93 1.00 29285714
+ 0.93 0.93 1.00 36357143
+ 0.93 0.93 1.00 43428571
+ 0.93 0.93 1.00 50500000
+ 0.93 0.93 1.00 57571429
+ 0.93 0.93 1.00 64642857
+ 0.93 0.93 1.00 71714286
+ 0.93 0.93 1.00 78785714
+ 0.93 0.93 1.00 85857143
+ 0.93 0.93 1.00 92928571
+ 0.93 0.93 1.00 100000000
+ 0.93 1.00 0.00 1000000
+ 0.93 1.00 0.00 8071429
+ 0.93 1.00 0.00 15142857
+ 0.93 1.00 0.00 22214286
+ 0.93 1.00 0.00 29285714
+ 0.93 1.00 0.00 36357143
+ 0.93 1.00 0.00 43428571
+ 0.93 1.00 0.00 50500000
+ 0.93 1.00 0.00 57571429
+ 0.93 1.00 0.00 64642857
+ 0.93 1.00 0.00 71714286
+ 0.93 1.00 0.00 78785714
+ 0.93 1.00 0.00 85857143
+ 0.93 1.00 0.00 92928571
+ 0.93 1.00 0.00 100000000
+ 0.93 1.00 0.07 1000000
+ 0.93 1.00 0.07 8071429
+ 0.93 1.00 0.07 15142857
+ 0.93 1.00 0.07 22214286
+ 0.93 1.00 0.07 29285714
+ 0.93 1.00 0.07 36357143
+ 0.93 1.00 0.07 43428571
+ 0.93 1.00 0.07 50500000
+ 0.93 1.00 0.07 57571429
+ 0.93 1.00 0.07 64642857
+ 0.93 1.00 0.07 71714286
+ 0.93 1.00 0.07 78785714
+ 0.93 1.00 0.07 85857143
+ 0.93 1.00 0.07 92928571
+ 0.93 1.00 0.07 100000000
+ 0.93 1.00 0.14 1000000
+ 0.93 1.00 0.14 8071429
+ 0.93 1.00 0.14 15142857
+ 0.93 1.00 0.14 22214286
+ 0.93 1.00 0.14 29285714
+ 0.93 1.00 0.14 36357143
+ 0.93 1.00 0.14 43428571
+ 0.93 1.00 0.14 50500000
+ 0.93 1.00 0.14 57571429
+ 0.93 1.00 0.14 64642857
+ 0.93 1.00 0.14 71714286
+ 0.93 1.00 0.14 78785714
+ 0.93 1.00 0.14 85857143
+ 0.93 1.00 0.14 92928571
+ 0.93 1.00 0.14 100000000
+ 0.93 1.00 0.21 1000000
+ 0.93 1.00 0.21 8071429
+ 0.93 1.00 0.21 15142857
+ 0.93 1.00 0.21 22214286
+ 0.93 1.00 0.21 29285714
+ 0.93 1.00 0.21 36357143
+ 0.93 1.00 0.21 43428571
+ 0.93 1.00 0.21 50500000
+ 0.93 1.00 0.21 57571429
+ 0.93 1.00 0.21 64642857
+ 0.93 1.00 0.21 71714286
+ 0.93 1.00 0.21 78785714
+ 0.93 1.00 0.21 85857143
+ 0.93 1.00 0.21 92928571
+ 0.93 1.00 0.21 100000000
+ 0.93 1.00 0.29 1000000
+ 0.93 1.00 0.29 8071429
+ 0.93 1.00 0.29 15142857
+ 0.93 1.00 0.29 22214286
+ 0.93 1.00 0.29 29285714
+ 0.93 1.00 0.29 36357143
+ 0.93 1.00 0.29 43428571
+ 0.93 1.00 0.29 50500000
+ 0.93 1.00 0.29 57571429
+ 0.93 1.00 0.29 64642857
+ 0.93 1.00 0.29 71714286
+ 0.93 1.00 0.29 78785714
+ 0.93 1.00 0.29 85857143
+ 0.93 1.00 0.29 92928571
+ 0.93 1.00 0.29 100000000
+ 0.93 1.00 0.36 1000000
+ 0.93 1.00 0.36 8071429
+ 0.93 1.00 0.36 15142857
+ 0.93 1.00 0.36 22214286
+ 0.93 1.00 0.36 29285714
+ 0.93 1.00 0.36 36357143
+ 0.93 1.00 0.36 43428571
+ 0.93 1.00 0.36 50500000
+ 0.93 1.00 0.36 57571429
+ 0.93 1.00 0.36 64642857
+ 0.93 1.00 0.36 71714286
+ 0.93 1.00 0.36 78785714
+ 0.93 1.00 0.36 85857143
+ 0.93 1.00 0.36 92928571
+ 0.93 1.00 0.36 100000000
+ 0.93 1.00 0.43 1000000
+ 0.93 1.00 0.43 8071429
+ 0.93 1.00 0.43 15142857
+ 0.93 1.00 0.43 22214286
+ 0.93 1.00 0.43 29285714
+ 0.93 1.00 0.43 36357143
+ 0.93 1.00 0.43 43428571
+ 0.93 1.00 0.43 50500000
+ 0.93 1.00 0.43 57571429
+ 0.93 1.00 0.43 64642857
+ 0.93 1.00 0.43 71714286
+ 0.93 1.00 0.43 78785714
+ 0.93 1.00 0.43 85857143
+ 0.93 1.00 0.43 92928571
+ 0.93 1.00 0.43 100000000
+ 0.93 1.00 0.50 1000000
+ 0.93 1.00 0.50 8071429
+ 0.93 1.00 0.50 15142857
+ 0.93 1.00 0.50 22214286
+ 0.93 1.00 0.50 29285714
+ 0.93 1.00 0.50 36357143
+ 0.93 1.00 0.50 43428571
+ 0.93 1.00 0.50 50500000
+ 0.93 1.00 0.50 57571429
+ 0.93 1.00 0.50 64642857
+ 0.93 1.00 0.50 71714286
+ 0.93 1.00 0.50 78785714
+ 0.93 1.00 0.50 85857143
+ 0.93 1.00 0.50 92928571
+ 0.93 1.00 0.50 100000000
+ 0.93 1.00 0.57 1000000
+ 0.93 1.00 0.57 8071429
+ 0.93 1.00 0.57 15142857
+ 0.93 1.00 0.57 22214286
+ 0.93 1.00 0.57 29285714
+ 0.93 1.00 0.57 36357143
+ 0.93 1.00 0.57 43428571
+ 0.93 1.00 0.57 50500000
+ 0.93 1.00 0.57 57571429
+ 0.93 1.00 0.57 64642857
+ 0.93 1.00 0.57 71714286
+ 0.93 1.00 0.57 78785714
+ 0.93 1.00 0.57 85857143
+ 0.93 1.00 0.57 92928571
+ 0.93 1.00 0.57 100000000
+ 0.93 1.00 0.64 1000000
+ 0.93 1.00 0.64 8071429
+ 0.93 1.00 0.64 15142857
+ 0.93 1.00 0.64 22214286
+ 0.93 1.00 0.64 29285714
+ 0.93 1.00 0.64 36357143
+ 0.93 1.00 0.64 43428571
+ 0.93 1.00 0.64 50500000
+ 0.93 1.00 0.64 57571429
+ 0.93 1.00 0.64 64642857
+ 0.93 1.00 0.64 71714286
+ 0.93 1.00 0.64 78785714
+ 0.93 1.00 0.64 85857143
+ 0.93 1.00 0.64 92928571
+ 0.93 1.00 0.64 100000000
+ 0.93 1.00 0.71 1000000
+ 0.93 1.00 0.71 8071429
+ 0.93 1.00 0.71 15142857
+ 0.93 1.00 0.71 22214286
+ 0.93 1.00 0.71 29285714
+ 0.93 1.00 0.71 36357143
+ 0.93 1.00 0.71 43428571
+ 0.93 1.00 0.71 50500000
+ 0.93 1.00 0.71 57571429
+ 0.93 1.00 0.71 64642857
+ 0.93 1.00 0.71 71714286
+ 0.93 1.00 0.71 78785714
+ 0.93 1.00 0.71 85857143
+ 0.93 1.00 0.71 92928571
+ 0.93 1.00 0.71 100000000
+ 0.93 1.00 0.79 1000000
+ 0.93 1.00 0.79 8071429
+ 0.93 1.00 0.79 15142857
+ 0.93 1.00 0.79 22214286
+ 0.93 1.00 0.79 29285714
+ 0.93 1.00 0.79 36357143
+ 0.93 1.00 0.79 43428571
+ 0.93 1.00 0.79 50500000
+ 0.93 1.00 0.79 57571429
+ 0.93 1.00 0.79 64642857
+ 0.93 1.00 0.79 71714286
+ 0.93 1.00 0.79 78785714
+ 0.93 1.00 0.79 85857143
+ 0.93 1.00 0.79 92928571
+ 0.93 1.00 0.79 100000000
+ 0.93 1.00 0.86 1000000
+ 0.93 1.00 0.86 8071429
+ 0.93 1.00 0.86 15142857
+ 0.93 1.00 0.86 22214286
+ 0.93 1.00 0.86 29285714
+ 0.93 1.00 0.86 36357143
+ 0.93 1.00 0.86 43428571
+ 0.93 1.00 0.86 50500000
+ 0.93 1.00 0.86 57571429
+ 0.93 1.00 0.86 64642857
+ 0.93 1.00 0.86 71714286
+ 0.93 1.00 0.86 78785714
+ 0.93 1.00 0.86 85857143
+ 0.93 1.00 0.86 92928571
+ 0.93 1.00 0.86 100000000
+ 0.93 1.00 0.93 1000000
+ 0.93 1.00 0.93 8071429
+ 0.93 1.00 0.93 15142857
+ 0.93 1.00 0.93 22214286
+ 0.93 1.00 0.93 29285714
+ 0.93 1.00 0.93 36357143
+ 0.93 1.00 0.93 43428571
+ 0.93 1.00 0.93 50500000
+ 0.93 1.00 0.93 57571429
+ 0.93 1.00 0.93 64642857
+ 0.93 1.00 0.93 71714286
+ 0.93 1.00 0.93 78785714
+ 0.93 1.00 0.93 85857143
+ 0.93 1.00 0.93 92928571
+ 0.93 1.00 0.93 100000000
+ 0.93 1.00 1.00 1000000
+ 0.93 1.00 1.00 8071429
+ 0.93 1.00 1.00 15142857
+ 0.93 1.00 1.00 22214286
+ 0.93 1.00 1.00 29285714
+ 0.93 1.00 1.00 36357143
+ 0.93 1.00 1.00 43428571
+ 0.93 1.00 1.00 50500000
+ 0.93 1.00 1.00 57571429
+ 0.93 1.00 1.00 64642857
+ 0.93 1.00 1.00 71714286
+ 0.93 1.00 1.00 78785714
+ 0.93 1.00 1.00 85857143
+ 0.93 1.00 1.00 92928571
+ 0.93 1.00 1.00 100000000
+ 1.00 0.00 0.00 1000000
+ 1.00 0.00 0.00 8071429
+ 1.00 0.00 0.00 15142857
+ 1.00 0.00 0.00 22214286
+ 1.00 0.00 0.00 29285714
+ 1.00 0.00 0.00 36357143
+ 1.00 0.00 0.00 43428571
+ 1.00 0.00 0.00 50500000
+ 1.00 0.00 0.00 57571429
+ 1.00 0.00 0.00 64642857
+ 1.00 0.00 0.00 71714286
+ 1.00 0.00 0.00 78785714
+ 1.00 0.00 0.00 85857143
+ 1.00 0.00 0.00 92928571
+ 1.00 0.00 0.00 100000000
+ 1.00 0.00 0.07 1000000
+ 1.00 0.00 0.07 8071429
+ 1.00 0.00 0.07 15142857
+ 1.00 0.00 0.07 22214286
+ 1.00 0.00 0.07 29285714
+ 1.00 0.00 0.07 36357143
+ 1.00 0.00 0.07 43428571
+ 1.00 0.00 0.07 50500000
+ 1.00 0.00 0.07 57571429
+ 1.00 0.00 0.07 64642857
+ 1.00 0.00 0.07 71714286
+ 1.00 0.00 0.07 78785714
+ 1.00 0.00 0.07 85857143
+ 1.00 0.00 0.07 92928571
+ 1.00 0.00 0.07 100000000
+ 1.00 0.00 0.14 1000000
+ 1.00 0.00 0.14 8071429
+ 1.00 0.00 0.14 15142857
+ 1.00 0.00 0.14 22214286
+ 1.00 0.00 0.14 29285714
+ 1.00 0.00 0.14 36357143
+ 1.00 0.00 0.14 43428571
+ 1.00 0.00 0.14 50500000
+ 1.00 0.00 0.14 57571429
+ 1.00 0.00 0.14 64642857
+ 1.00 0.00 0.14 71714286
+ 1.00 0.00 0.14 78785714
+ 1.00 0.00 0.14 85857143
+ 1.00 0.00 0.14 92928571
+ 1.00 0.00 0.14 100000000
+ 1.00 0.00 0.21 1000000
+ 1.00 0.00 0.21 8071429
+ 1.00 0.00 0.21 15142857
+ 1.00 0.00 0.21 22214286
+ 1.00 0.00 0.21 29285714
+ 1.00 0.00 0.21 36357143
+ 1.00 0.00 0.21 43428571
+ 1.00 0.00 0.21 50500000
+ 1.00 0.00 0.21 57571429
+ 1.00 0.00 0.21 64642857
+ 1.00 0.00 0.21 71714286
+ 1.00 0.00 0.21 78785714
+ 1.00 0.00 0.21 85857143
+ 1.00 0.00 0.21 92928571
+ 1.00 0.00 0.21 100000000
+ 1.00 0.00 0.29 1000000
+ 1.00 0.00 0.29 8071429
+ 1.00 0.00 0.29 15142857
+ 1.00 0.00 0.29 22214286
+ 1.00 0.00 0.29 29285714
+ 1.00 0.00 0.29 36357143
+ 1.00 0.00 0.29 43428571
+ 1.00 0.00 0.29 50500000
+ 1.00 0.00 0.29 57571429
+ 1.00 0.00 0.29 64642857
+ 1.00 0.00 0.29 71714286
+ 1.00 0.00 0.29 78785714
+ 1.00 0.00 0.29 85857143
+ 1.00 0.00 0.29 92928571
+ 1.00 0.00 0.29 100000000
+ 1.00 0.00 0.36 1000000
+ 1.00 0.00 0.36 8071429
+ 1.00 0.00 0.36 15142857
+ 1.00 0.00 0.36 22214286
+ 1.00 0.00 0.36 29285714
+ 1.00 0.00 0.36 36357143
+ 1.00 0.00 0.36 43428571
+ 1.00 0.00 0.36 50500000
+ 1.00 0.00 0.36 57571429
+ 1.00 0.00 0.36 64642857
+ 1.00 0.00 0.36 71714286
+ 1.00 0.00 0.36 78785714
+ 1.00 0.00 0.36 85857143
+ 1.00 0.00 0.36 92928571
+ 1.00 0.00 0.36 100000000
+ 1.00 0.00 0.43 1000000
+ 1.00 0.00 0.43 8071429
+ 1.00 0.00 0.43 15142857
+ 1.00 0.00 0.43 22214286
+ 1.00 0.00 0.43 29285714
+ 1.00 0.00 0.43 36357143
+ 1.00 0.00 0.43 43428571
+ 1.00 0.00 0.43 50500000
+ 1.00 0.00 0.43 57571429
+ 1.00 0.00 0.43 64642857
+ 1.00 0.00 0.43 71714286
+ 1.00 0.00 0.43 78785714
+ 1.00 0.00 0.43 85857143
+ 1.00 0.00 0.43 92928571
+ 1.00 0.00 0.43 100000000
+ 1.00 0.00 0.50 1000000
+ 1.00 0.00 0.50 8071429
+ 1.00 0.00 0.50 15142857
+ 1.00 0.00 0.50 22214286
+ 1.00 0.00 0.50 29285714
+ 1.00 0.00 0.50 36357143
+ 1.00 0.00 0.50 43428571
+ 1.00 0.00 0.50 50500000
+ 1.00 0.00 0.50 57571429
+ 1.00 0.00 0.50 64642857
+ 1.00 0.00 0.50 71714286
+ 1.00 0.00 0.50 78785714
+ 1.00 0.00 0.50 85857143
+ 1.00 0.00 0.50 92928571
+ 1.00 0.00 0.50 100000000
+ 1.00 0.00 0.57 1000000
+ 1.00 0.00 0.57 8071429
+ 1.00 0.00 0.57 15142857
+ 1.00 0.00 0.57 22214286
+ 1.00 0.00 0.57 29285714
+ 1.00 0.00 0.57 36357143
+ 1.00 0.00 0.57 43428571
+ 1.00 0.00 0.57 50500000
+ 1.00 0.00 0.57 57571429
+ 1.00 0.00 0.57 64642857
+ 1.00 0.00 0.57 71714286
+ 1.00 0.00 0.57 78785714
+ 1.00 0.00 0.57 85857143
+ 1.00 0.00 0.57 92928571
+ 1.00 0.00 0.57 100000000
+ 1.00 0.00 0.64 1000000
+ 1.00 0.00 0.64 8071429
+ 1.00 0.00 0.64 15142857
+ 1.00 0.00 0.64 22214286
+ 1.00 0.00 0.64 29285714
+ 1.00 0.00 0.64 36357143
+ 1.00 0.00 0.64 43428571
+ 1.00 0.00 0.64 50500000
+ 1.00 0.00 0.64 57571429
+ 1.00 0.00 0.64 64642857
+ 1.00 0.00 0.64 71714286
+ 1.00 0.00 0.64 78785714
+ 1.00 0.00 0.64 85857143
+ 1.00 0.00 0.64 92928571
+ 1.00 0.00 0.64 100000000
+ 1.00 0.00 0.71 1000000
+ 1.00 0.00 0.71 8071429
+ 1.00 0.00 0.71 15142857
+ 1.00 0.00 0.71 22214286
+ 1.00 0.00 0.71 29285714
+ 1.00 0.00 0.71 36357143
+ 1.00 0.00 0.71 43428571
+ 1.00 0.00 0.71 50500000
+ 1.00 0.00 0.71 57571429
+ 1.00 0.00 0.71 64642857
+ 1.00 0.00 0.71 71714286
+ 1.00 0.00 0.71 78785714
+ 1.00 0.00 0.71 85857143
+ 1.00 0.00 0.71 92928571
+ 1.00 0.00 0.71 100000000
+ 1.00 0.00 0.79 1000000
+ 1.00 0.00 0.79 8071429
+ 1.00 0.00 0.79 15142857
+ 1.00 0.00 0.79 22214286
+ 1.00 0.00 0.79 29285714
+ 1.00 0.00 0.79 36357143
+ 1.00 0.00 0.79 43428571
+ 1.00 0.00 0.79 50500000
+ 1.00 0.00 0.79 57571429
+ 1.00 0.00 0.79 64642857
+ 1.00 0.00 0.79 71714286
+ 1.00 0.00 0.79 78785714
+ 1.00 0.00 0.79 85857143
+ 1.00 0.00 0.79 92928571
+ 1.00 0.00 0.79 100000000
+ 1.00 0.00 0.86 1000000
+ 1.00 0.00 0.86 8071429
+ 1.00 0.00 0.86 15142857
+ 1.00 0.00 0.86 22214286
+ 1.00 0.00 0.86 29285714
+ 1.00 0.00 0.86 36357143
+ 1.00 0.00 0.86 43428571
+ 1.00 0.00 0.86 50500000
+ 1.00 0.00 0.86 57571429
+ 1.00 0.00 0.86 64642857
+ 1.00 0.00 0.86 71714286
+ 1.00 0.00 0.86 78785714
+ 1.00 0.00 0.86 85857143
+ 1.00 0.00 0.86 92928571
+ 1.00 0.00 0.86 100000000
+ 1.00 0.00 0.93 1000000
+ 1.00 0.00 0.93 8071429
+ 1.00 0.00 0.93 15142857
+ 1.00 0.00 0.93 22214286
+ 1.00 0.00 0.93 29285714
+ 1.00 0.00 0.93 36357143
+ 1.00 0.00 0.93 43428571
+ 1.00 0.00 0.93 50500000
+ 1.00 0.00 0.93 57571429
+ 1.00 0.00 0.93 64642857
+ 1.00 0.00 0.93 71714286
+ 1.00 0.00 0.93 78785714
+ 1.00 0.00 0.93 85857143
+ 1.00 0.00 0.93 92928571
+ 1.00 0.00 0.93 100000000
+ 1.00 0.00 1.00 1000000
+ 1.00 0.00 1.00 8071429
+ 1.00 0.00 1.00 15142857
+ 1.00 0.00 1.00 22214286
+ 1.00 0.00 1.00 29285714
+ 1.00 0.00 1.00 36357143
+ 1.00 0.00 1.00 43428571
+ 1.00 0.00 1.00 50500000
+ 1.00 0.00 1.00 57571429
+ 1.00 0.00 1.00 64642857
+ 1.00 0.00 1.00 71714286
+ 1.00 0.00 1.00 78785714
+ 1.00 0.00 1.00 85857143
+ 1.00 0.00 1.00 92928571
+ 1.00 0.00 1.00 100000000
+ 1.00 0.07 0.00 1000000
+ 1.00 0.07 0.00 8071429
+ 1.00 0.07 0.00 15142857
+ 1.00 0.07 0.00 22214286
+ 1.00 0.07 0.00 29285714
+ 1.00 0.07 0.00 36357143
+ 1.00 0.07 0.00 43428571
+ 1.00 0.07 0.00 50500000
+ 1.00 0.07 0.00 57571429
+ 1.00 0.07 0.00 64642857
+ 1.00 0.07 0.00 71714286
+ 1.00 0.07 0.00 78785714
+ 1.00 0.07 0.00 85857143
+ 1.00 0.07 0.00 92928571
+ 1.00 0.07 0.00 100000000
+ 1.00 0.07 0.07 1000000
+ 1.00 0.07 0.07 8071429
+ 1.00 0.07 0.07 15142857
+ 1.00 0.07 0.07 22214286
+ 1.00 0.07 0.07 29285714
+ 1.00 0.07 0.07 36357143
+ 1.00 0.07 0.07 43428571
+ 1.00 0.07 0.07 50500000
+ 1.00 0.07 0.07 57571429
+ 1.00 0.07 0.07 64642857
+ 1.00 0.07 0.07 71714286
+ 1.00 0.07 0.07 78785714
+ 1.00 0.07 0.07 85857143
+ 1.00 0.07 0.07 92928571
+ 1.00 0.07 0.07 100000000
+ 1.00 0.07 0.14 1000000
+ 1.00 0.07 0.14 8071429
+ 1.00 0.07 0.14 15142857
+ 1.00 0.07 0.14 22214286
+ 1.00 0.07 0.14 29285714
+ 1.00 0.07 0.14 36357143
+ 1.00 0.07 0.14 43428571
+ 1.00 0.07 0.14 50500000
+ 1.00 0.07 0.14 57571429
+ 1.00 0.07 0.14 64642857
+ 1.00 0.07 0.14 71714286
+ 1.00 0.07 0.14 78785714
+ 1.00 0.07 0.14 85857143
+ 1.00 0.07 0.14 92928571
+ 1.00 0.07 0.14 100000000
+ 1.00 0.07 0.21 1000000
+ 1.00 0.07 0.21 8071429
+ 1.00 0.07 0.21 15142857
+ 1.00 0.07 0.21 22214286
+ 1.00 0.07 0.21 29285714
+ 1.00 0.07 0.21 36357143
+ 1.00 0.07 0.21 43428571
+ 1.00 0.07 0.21 50500000
+ 1.00 0.07 0.21 57571429
+ 1.00 0.07 0.21 64642857
+ 1.00 0.07 0.21 71714286
+ 1.00 0.07 0.21 78785714
+ 1.00 0.07 0.21 85857143
+ 1.00 0.07 0.21 92928571
+ 1.00 0.07 0.21 100000000
+ 1.00 0.07 0.29 1000000
+ 1.00 0.07 0.29 8071429
+ 1.00 0.07 0.29 15142857
+ 1.00 0.07 0.29 22214286
+ 1.00 0.07 0.29 29285714
+ 1.00 0.07 0.29 36357143
+ 1.00 0.07 0.29 43428571
+ 1.00 0.07 0.29 50500000
+ 1.00 0.07 0.29 57571429
+ 1.00 0.07 0.29 64642857
+ 1.00 0.07 0.29 71714286
+ 1.00 0.07 0.29 78785714
+ 1.00 0.07 0.29 85857143
+ 1.00 0.07 0.29 92928571
+ 1.00 0.07 0.29 100000000
+ 1.00 0.07 0.36 1000000
+ 1.00 0.07 0.36 8071429
+ 1.00 0.07 0.36 15142857
+ 1.00 0.07 0.36 22214286
+ 1.00 0.07 0.36 29285714
+ 1.00 0.07 0.36 36357143
+ 1.00 0.07 0.36 43428571
+ 1.00 0.07 0.36 50500000
+ 1.00 0.07 0.36 57571429
+ 1.00 0.07 0.36 64642857
+ 1.00 0.07 0.36 71714286
+ 1.00 0.07 0.36 78785714
+ 1.00 0.07 0.36 85857143
+ 1.00 0.07 0.36 92928571
+ 1.00 0.07 0.36 100000000
+ 1.00 0.07 0.43 1000000
+ 1.00 0.07 0.43 8071429
+ 1.00 0.07 0.43 15142857
+ 1.00 0.07 0.43 22214286
+ 1.00 0.07 0.43 29285714
+ 1.00 0.07 0.43 36357143
+ 1.00 0.07 0.43 43428571
+ 1.00 0.07 0.43 50500000
+ 1.00 0.07 0.43 57571429
+ 1.00 0.07 0.43 64642857
+ 1.00 0.07 0.43 71714286
+ 1.00 0.07 0.43 78785714
+ 1.00 0.07 0.43 85857143
+ 1.00 0.07 0.43 92928571
+ 1.00 0.07 0.43 100000000
+ 1.00 0.07 0.50 1000000
+ 1.00 0.07 0.50 8071429
+ 1.00 0.07 0.50 15142857
+ 1.00 0.07 0.50 22214286
+ 1.00 0.07 0.50 29285714
+ 1.00 0.07 0.50 36357143
+ 1.00 0.07 0.50 43428571
+ 1.00 0.07 0.50 50500000
+ 1.00 0.07 0.50 57571429
+ 1.00 0.07 0.50 64642857
+ 1.00 0.07 0.50 71714286
+ 1.00 0.07 0.50 78785714
+ 1.00 0.07 0.50 85857143
+ 1.00 0.07 0.50 92928571
+ 1.00 0.07 0.50 100000000
+ 1.00 0.07 0.57 1000000
+ 1.00 0.07 0.57 8071429
+ 1.00 0.07 0.57 15142857
+ 1.00 0.07 0.57 22214286
+ 1.00 0.07 0.57 29285714
+ 1.00 0.07 0.57 36357143
+ 1.00 0.07 0.57 43428571
+ 1.00 0.07 0.57 50500000
+ 1.00 0.07 0.57 57571429
+ 1.00 0.07 0.57 64642857
+ 1.00 0.07 0.57 71714286
+ 1.00 0.07 0.57 78785714
+ 1.00 0.07 0.57 85857143
+ 1.00 0.07 0.57 92928571
+ 1.00 0.07 0.57 100000000
+ 1.00 0.07 0.64 1000000
+ 1.00 0.07 0.64 8071429
+ 1.00 0.07 0.64 15142857
+ 1.00 0.07 0.64 22214286
+ 1.00 0.07 0.64 29285714
+ 1.00 0.07 0.64 36357143
+ 1.00 0.07 0.64 43428571
+ 1.00 0.07 0.64 50500000
+ 1.00 0.07 0.64 57571429
+ 1.00 0.07 0.64 64642857
+ 1.00 0.07 0.64 71714286
+ 1.00 0.07 0.64 78785714
+ 1.00 0.07 0.64 85857143
+ 1.00 0.07 0.64 92928571
+ 1.00 0.07 0.64 100000000
+ 1.00 0.07 0.71 1000000
+ 1.00 0.07 0.71 8071429
+ 1.00 0.07 0.71 15142857
+ 1.00 0.07 0.71 22214286
+ 1.00 0.07 0.71 29285714
+ 1.00 0.07 0.71 36357143
+ 1.00 0.07 0.71 43428571
+ 1.00 0.07 0.71 50500000
+ 1.00 0.07 0.71 57571429
+ 1.00 0.07 0.71 64642857
+ 1.00 0.07 0.71 71714286
+ 1.00 0.07 0.71 78785714
+ 1.00 0.07 0.71 85857143
+ 1.00 0.07 0.71 92928571
+ 1.00 0.07 0.71 100000000
+ 1.00 0.07 0.79 1000000
+ 1.00 0.07 0.79 8071429
+ 1.00 0.07 0.79 15142857
+ 1.00 0.07 0.79 22214286
+ 1.00 0.07 0.79 29285714
+ 1.00 0.07 0.79 36357143
+ 1.00 0.07 0.79 43428571
+ 1.00 0.07 0.79 50500000
+ 1.00 0.07 0.79 57571429
+ 1.00 0.07 0.79 64642857
+ 1.00 0.07 0.79 71714286
+ 1.00 0.07 0.79 78785714
+ 1.00 0.07 0.79 85857143
+ 1.00 0.07 0.79 92928571
+ 1.00 0.07 0.79 100000000
+ 1.00 0.07 0.86 1000000
+ 1.00 0.07 0.86 8071429
+ 1.00 0.07 0.86 15142857
+ 1.00 0.07 0.86 22214286
+ 1.00 0.07 0.86 29285714
+ 1.00 0.07 0.86 36357143
+ 1.00 0.07 0.86 43428571
+ 1.00 0.07 0.86 50500000
+ 1.00 0.07 0.86 57571429
+ 1.00 0.07 0.86 64642857
+ 1.00 0.07 0.86 71714286
+ 1.00 0.07 0.86 78785714
+ 1.00 0.07 0.86 85857143
+ 1.00 0.07 0.86 92928571
+ 1.00 0.07 0.86 100000000
+ 1.00 0.07 0.93 1000000
+ 1.00 0.07 0.93 8071429
+ 1.00 0.07 0.93 15142857
+ 1.00 0.07 0.93 22214286
+ 1.00 0.07 0.93 29285714
+ 1.00 0.07 0.93 36357143
+ 1.00 0.07 0.93 43428571
+ 1.00 0.07 0.93 50500000
+ 1.00 0.07 0.93 57571429
+ 1.00 0.07 0.93 64642857
+ 1.00 0.07 0.93 71714286
+ 1.00 0.07 0.93 78785714
+ 1.00 0.07 0.93 85857143
+ 1.00 0.07 0.93 92928571
+ 1.00 0.07 0.93 100000000
+ 1.00 0.07 1.00 1000000
+ 1.00 0.07 1.00 8071429
+ 1.00 0.07 1.00 15142857
+ 1.00 0.07 1.00 22214286
+ 1.00 0.07 1.00 29285714
+ 1.00 0.07 1.00 36357143
+ 1.00 0.07 1.00 43428571
+ 1.00 0.07 1.00 50500000
+ 1.00 0.07 1.00 57571429
+ 1.00 0.07 1.00 64642857
+ 1.00 0.07 1.00 71714286
+ 1.00 0.07 1.00 78785714
+ 1.00 0.07 1.00 85857143
+ 1.00 0.07 1.00 92928571
+ 1.00 0.07 1.00 100000000
+ 1.00 0.14 0.00 1000000
+ 1.00 0.14 0.00 8071429
+ 1.00 0.14 0.00 15142857
+ 1.00 0.14 0.00 22214286
+ 1.00 0.14 0.00 29285714
+ 1.00 0.14 0.00 36357143
+ 1.00 0.14 0.00 43428571
+ 1.00 0.14 0.00 50500000
+ 1.00 0.14 0.00 57571429
+ 1.00 0.14 0.00 64642857
+ 1.00 0.14 0.00 71714286
+ 1.00 0.14 0.00 78785714
+ 1.00 0.14 0.00 85857143
+ 1.00 0.14 0.00 92928571
+ 1.00 0.14 0.00 100000000
+ 1.00 0.14 0.07 1000000
+ 1.00 0.14 0.07 8071429
+ 1.00 0.14 0.07 15142857
+ 1.00 0.14 0.07 22214286
+ 1.00 0.14 0.07 29285714
+ 1.00 0.14 0.07 36357143
+ 1.00 0.14 0.07 43428571
+ 1.00 0.14 0.07 50500000
+ 1.00 0.14 0.07 57571429
+ 1.00 0.14 0.07 64642857
+ 1.00 0.14 0.07 71714286
+ 1.00 0.14 0.07 78785714
+ 1.00 0.14 0.07 85857143
+ 1.00 0.14 0.07 92928571
+ 1.00 0.14 0.07 100000000
+ 1.00 0.14 0.14 1000000
+ 1.00 0.14 0.14 8071429
+ 1.00 0.14 0.14 15142857
+ 1.00 0.14 0.14 22214286
+ 1.00 0.14 0.14 29285714
+ 1.00 0.14 0.14 36357143
+ 1.00 0.14 0.14 43428571
+ 1.00 0.14 0.14 50500000
+ 1.00 0.14 0.14 57571429
+ 1.00 0.14 0.14 64642857
+ 1.00 0.14 0.14 71714286
+ 1.00 0.14 0.14 78785714
+ 1.00 0.14 0.14 85857143
+ 1.00 0.14 0.14 92928571
+ 1.00 0.14 0.14 100000000
+ 1.00 0.14 0.21 1000000
+ 1.00 0.14 0.21 8071429
+ 1.00 0.14 0.21 15142857
+ 1.00 0.14 0.21 22214286
+ 1.00 0.14 0.21 29285714
+ 1.00 0.14 0.21 36357143
+ 1.00 0.14 0.21 43428571
+ 1.00 0.14 0.21 50500000
+ 1.00 0.14 0.21 57571429
+ 1.00 0.14 0.21 64642857
+ 1.00 0.14 0.21 71714286
+ 1.00 0.14 0.21 78785714
+ 1.00 0.14 0.21 85857143
+ 1.00 0.14 0.21 92928571
+ 1.00 0.14 0.21 100000000
+ 1.00 0.14 0.29 1000000
+ 1.00 0.14 0.29 8071429
+ 1.00 0.14 0.29 15142857
+ 1.00 0.14 0.29 22214286
+ 1.00 0.14 0.29 29285714
+ 1.00 0.14 0.29 36357143
+ 1.00 0.14 0.29 43428571
+ 1.00 0.14 0.29 50500000
+ 1.00 0.14 0.29 57571429
+ 1.00 0.14 0.29 64642857
+ 1.00 0.14 0.29 71714286
+ 1.00 0.14 0.29 78785714
+ 1.00 0.14 0.29 85857143
+ 1.00 0.14 0.29 92928571
+ 1.00 0.14 0.29 100000000
+ 1.00 0.14 0.36 1000000
+ 1.00 0.14 0.36 8071429
+ 1.00 0.14 0.36 15142857
+ 1.00 0.14 0.36 22214286
+ 1.00 0.14 0.36 29285714
+ 1.00 0.14 0.36 36357143
+ 1.00 0.14 0.36 43428571
+ 1.00 0.14 0.36 50500000
+ 1.00 0.14 0.36 57571429
+ 1.00 0.14 0.36 64642857
+ 1.00 0.14 0.36 71714286
+ 1.00 0.14 0.36 78785714
+ 1.00 0.14 0.36 85857143
+ 1.00 0.14 0.36 92928571
+ 1.00 0.14 0.36 100000000
+ 1.00 0.14 0.43 1000000
+ 1.00 0.14 0.43 8071429
+ 1.00 0.14 0.43 15142857
+ 1.00 0.14 0.43 22214286
+ 1.00 0.14 0.43 29285714
+ 1.00 0.14 0.43 36357143
+ 1.00 0.14 0.43 43428571
+ 1.00 0.14 0.43 50500000
+ 1.00 0.14 0.43 57571429
+ 1.00 0.14 0.43 64642857
+ 1.00 0.14 0.43 71714286
+ 1.00 0.14 0.43 78785714
+ 1.00 0.14 0.43 85857143
+ 1.00 0.14 0.43 92928571
+ 1.00 0.14 0.43 100000000
+ 1.00 0.14 0.50 1000000
+ 1.00 0.14 0.50 8071429
+ 1.00 0.14 0.50 15142857
+ 1.00 0.14 0.50 22214286
+ 1.00 0.14 0.50 29285714
+ 1.00 0.14 0.50 36357143
+ 1.00 0.14 0.50 43428571
+ 1.00 0.14 0.50 50500000
+ 1.00 0.14 0.50 57571429
+ 1.00 0.14 0.50 64642857
+ 1.00 0.14 0.50 71714286
+ 1.00 0.14 0.50 78785714
+ 1.00 0.14 0.50 85857143
+ 1.00 0.14 0.50 92928571
+ 1.00 0.14 0.50 100000000
+ 1.00 0.14 0.57 1000000
+ 1.00 0.14 0.57 8071429
+ 1.00 0.14 0.57 15142857
+ 1.00 0.14 0.57 22214286
+ 1.00 0.14 0.57 29285714
+ 1.00 0.14 0.57 36357143
+ 1.00 0.14 0.57 43428571
+ 1.00 0.14 0.57 50500000
+ 1.00 0.14 0.57 57571429
+ 1.00 0.14 0.57 64642857
+ 1.00 0.14 0.57 71714286
+ 1.00 0.14 0.57 78785714
+ 1.00 0.14 0.57 85857143
+ 1.00 0.14 0.57 92928571
+ 1.00 0.14 0.57 100000000
+ 1.00 0.14 0.64 1000000
+ 1.00 0.14 0.64 8071429
+ 1.00 0.14 0.64 15142857
+ 1.00 0.14 0.64 22214286
+ 1.00 0.14 0.64 29285714
+ 1.00 0.14 0.64 36357143
+ 1.00 0.14 0.64 43428571
+ 1.00 0.14 0.64 50500000
+ 1.00 0.14 0.64 57571429
+ 1.00 0.14 0.64 64642857
+ 1.00 0.14 0.64 71714286
+ 1.00 0.14 0.64 78785714
+ 1.00 0.14 0.64 85857143
+ 1.00 0.14 0.64 92928571
+ 1.00 0.14 0.64 100000000
+ 1.00 0.14 0.71 1000000
+ 1.00 0.14 0.71 8071429
+ 1.00 0.14 0.71 15142857
+ 1.00 0.14 0.71 22214286
+ 1.00 0.14 0.71 29285714
+ 1.00 0.14 0.71 36357143
+ 1.00 0.14 0.71 43428571
+ 1.00 0.14 0.71 50500000
+ 1.00 0.14 0.71 57571429
+ 1.00 0.14 0.71 64642857
+ 1.00 0.14 0.71 71714286
+ 1.00 0.14 0.71 78785714
+ 1.00 0.14 0.71 85857143
+ 1.00 0.14 0.71 92928571
+ 1.00 0.14 0.71 100000000
+ 1.00 0.14 0.79 1000000
+ 1.00 0.14 0.79 8071429
+ 1.00 0.14 0.79 15142857
+ 1.00 0.14 0.79 22214286
+ 1.00 0.14 0.79 29285714
+ 1.00 0.14 0.79 36357143
+ 1.00 0.14 0.79 43428571
+ 1.00 0.14 0.79 50500000
+ 1.00 0.14 0.79 57571429
+ 1.00 0.14 0.79 64642857
+ 1.00 0.14 0.79 71714286
+ 1.00 0.14 0.79 78785714
+ 1.00 0.14 0.79 85857143
+ 1.00 0.14 0.79 92928571
+ 1.00 0.14 0.79 100000000
+ 1.00 0.14 0.86 1000000
+ 1.00 0.14 0.86 8071429
+ 1.00 0.14 0.86 15142857
+ 1.00 0.14 0.86 22214286
+ 1.00 0.14 0.86 29285714
+ 1.00 0.14 0.86 36357143
+ 1.00 0.14 0.86 43428571
+ 1.00 0.14 0.86 50500000
+ 1.00 0.14 0.86 57571429
+ 1.00 0.14 0.86 64642857
+ 1.00 0.14 0.86 71714286
+ 1.00 0.14 0.86 78785714
+ 1.00 0.14 0.86 85857143
+ 1.00 0.14 0.86 92928571
+ 1.00 0.14 0.86 100000000
+ 1.00 0.14 0.93 1000000
+ 1.00 0.14 0.93 8071429
+ 1.00 0.14 0.93 15142857
+ 1.00 0.14 0.93 22214286
+ 1.00 0.14 0.93 29285714
+ 1.00 0.14 0.93 36357143
+ 1.00 0.14 0.93 43428571
+ 1.00 0.14 0.93 50500000
+ 1.00 0.14 0.93 57571429
+ 1.00 0.14 0.93 64642857
+ 1.00 0.14 0.93 71714286
+ 1.00 0.14 0.93 78785714
+ 1.00 0.14 0.93 85857143
+ 1.00 0.14 0.93 92928571
+ 1.00 0.14 0.93 100000000
+ 1.00 0.14 1.00 1000000
+ 1.00 0.14 1.00 8071429
+ 1.00 0.14 1.00 15142857
+ 1.00 0.14 1.00 22214286
+ 1.00 0.14 1.00 29285714
+ 1.00 0.14 1.00 36357143
+ 1.00 0.14 1.00 43428571
+ 1.00 0.14 1.00 50500000
+ 1.00 0.14 1.00 57571429
+ 1.00 0.14 1.00 64642857
+ 1.00 0.14 1.00 71714286
+ 1.00 0.14 1.00 78785714
+ 1.00 0.14 1.00 85857143
+ 1.00 0.14 1.00 92928571
+ 1.00 0.14 1.00 100000000
+ 1.00 0.21 0.00 1000000
+ 1.00 0.21 0.00 8071429
+ 1.00 0.21 0.00 15142857
+ 1.00 0.21 0.00 22214286
+ 1.00 0.21 0.00 29285714
+ 1.00 0.21 0.00 36357143
+ 1.00 0.21 0.00 43428571
+ 1.00 0.21 0.00 50500000
+ 1.00 0.21 0.00 57571429
+ 1.00 0.21 0.00 64642857
+ 1.00 0.21 0.00 71714286
+ 1.00 0.21 0.00 78785714
+ 1.00 0.21 0.00 85857143
+ 1.00 0.21 0.00 92928571
+ 1.00 0.21 0.00 100000000
+ 1.00 0.21 0.07 1000000
+ 1.00 0.21 0.07 8071429
+ 1.00 0.21 0.07 15142857
+ 1.00 0.21 0.07 22214286
+ 1.00 0.21 0.07 29285714
+ 1.00 0.21 0.07 36357143
+ 1.00 0.21 0.07 43428571
+ 1.00 0.21 0.07 50500000
+ 1.00 0.21 0.07 57571429
+ 1.00 0.21 0.07 64642857
+ 1.00 0.21 0.07 71714286
+ 1.00 0.21 0.07 78785714
+ 1.00 0.21 0.07 85857143
+ 1.00 0.21 0.07 92928571
+ 1.00 0.21 0.07 100000000
+ 1.00 0.21 0.14 1000000
+ 1.00 0.21 0.14 8071429
+ 1.00 0.21 0.14 15142857
+ 1.00 0.21 0.14 22214286
+ 1.00 0.21 0.14 29285714
+ 1.00 0.21 0.14 36357143
+ 1.00 0.21 0.14 43428571
+ 1.00 0.21 0.14 50500000
+ 1.00 0.21 0.14 57571429
+ 1.00 0.21 0.14 64642857
+ 1.00 0.21 0.14 71714286
+ 1.00 0.21 0.14 78785714
+ 1.00 0.21 0.14 85857143
+ 1.00 0.21 0.14 92928571
+ 1.00 0.21 0.14 100000000
+ 1.00 0.21 0.21 1000000
+ 1.00 0.21 0.21 8071429
+ 1.00 0.21 0.21 15142857
+ 1.00 0.21 0.21 22214286
+ 1.00 0.21 0.21 29285714
+ 1.00 0.21 0.21 36357143
+ 1.00 0.21 0.21 43428571
+ 1.00 0.21 0.21 50500000
+ 1.00 0.21 0.21 57571429
+ 1.00 0.21 0.21 64642857
+ 1.00 0.21 0.21 71714286
+ 1.00 0.21 0.21 78785714
+ 1.00 0.21 0.21 85857143
+ 1.00 0.21 0.21 92928571
+ 1.00 0.21 0.21 100000000
+ 1.00 0.21 0.29 1000000
+ 1.00 0.21 0.29 8071429
+ 1.00 0.21 0.29 15142857
+ 1.00 0.21 0.29 22214286
+ 1.00 0.21 0.29 29285714
+ 1.00 0.21 0.29 36357143
+ 1.00 0.21 0.29 43428571
+ 1.00 0.21 0.29 50500000
+ 1.00 0.21 0.29 57571429
+ 1.00 0.21 0.29 64642857
+ 1.00 0.21 0.29 71714286
+ 1.00 0.21 0.29 78785714
+ 1.00 0.21 0.29 85857143
+ 1.00 0.21 0.29 92928571
+ 1.00 0.21 0.29 100000000
+ 1.00 0.21 0.36 1000000
+ 1.00 0.21 0.36 8071429
+ 1.00 0.21 0.36 15142857
+ 1.00 0.21 0.36 22214286
+ 1.00 0.21 0.36 29285714
+ 1.00 0.21 0.36 36357143
+ 1.00 0.21 0.36 43428571
+ 1.00 0.21 0.36 50500000
+ 1.00 0.21 0.36 57571429
+ 1.00 0.21 0.36 64642857
+ 1.00 0.21 0.36 71714286
+ 1.00 0.21 0.36 78785714
+ 1.00 0.21 0.36 85857143
+ 1.00 0.21 0.36 92928571
+ 1.00 0.21 0.36 100000000
+ 1.00 0.21 0.43 1000000
+ 1.00 0.21 0.43 8071429
+ 1.00 0.21 0.43 15142857
+ 1.00 0.21 0.43 22214286
+ 1.00 0.21 0.43 29285714
+ 1.00 0.21 0.43 36357143
+ 1.00 0.21 0.43 43428571
+ 1.00 0.21 0.43 50500000
+ 1.00 0.21 0.43 57571429
+ 1.00 0.21 0.43 64642857
+ 1.00 0.21 0.43 71714286
+ 1.00 0.21 0.43 78785714
+ 1.00 0.21 0.43 85857143
+ 1.00 0.21 0.43 92928571
+ 1.00 0.21 0.43 100000000
+ 1.00 0.21 0.50 1000000
+ 1.00 0.21 0.50 8071429
+ 1.00 0.21 0.50 15142857
+ 1.00 0.21 0.50 22214286
+ 1.00 0.21 0.50 29285714
+ 1.00 0.21 0.50 36357143
+ 1.00 0.21 0.50 43428571
+ 1.00 0.21 0.50 50500000
+ 1.00 0.21 0.50 57571429
+ 1.00 0.21 0.50 64642857
+ 1.00 0.21 0.50 71714286
+ 1.00 0.21 0.50 78785714
+ 1.00 0.21 0.50 85857143
+ 1.00 0.21 0.50 92928571
+ 1.00 0.21 0.50 100000000
+ 1.00 0.21 0.57 1000000
+ 1.00 0.21 0.57 8071429
+ 1.00 0.21 0.57 15142857
+ 1.00 0.21 0.57 22214286
+ 1.00 0.21 0.57 29285714
+ 1.00 0.21 0.57 36357143
+ 1.00 0.21 0.57 43428571
+ 1.00 0.21 0.57 50500000
+ 1.00 0.21 0.57 57571429
+ 1.00 0.21 0.57 64642857
+ 1.00 0.21 0.57 71714286
+ 1.00 0.21 0.57 78785714
+ 1.00 0.21 0.57 85857143
+ 1.00 0.21 0.57 92928571
+ 1.00 0.21 0.57 100000000
+ 1.00 0.21 0.64 1000000
+ 1.00 0.21 0.64 8071429
+ 1.00 0.21 0.64 15142857
+ 1.00 0.21 0.64 22214286
+ 1.00 0.21 0.64 29285714
+ 1.00 0.21 0.64 36357143
+ 1.00 0.21 0.64 43428571
+ 1.00 0.21 0.64 50500000
+ 1.00 0.21 0.64 57571429
+ 1.00 0.21 0.64 64642857
+ 1.00 0.21 0.64 71714286
+ 1.00 0.21 0.64 78785714
+ 1.00 0.21 0.64 85857143
+ 1.00 0.21 0.64 92928571
+ 1.00 0.21 0.64 100000000
+ 1.00 0.21 0.71 1000000
+ 1.00 0.21 0.71 8071429
+ 1.00 0.21 0.71 15142857
+ 1.00 0.21 0.71 22214286
+ 1.00 0.21 0.71 29285714
+ 1.00 0.21 0.71 36357143
+ 1.00 0.21 0.71 43428571
+ 1.00 0.21 0.71 50500000
+ 1.00 0.21 0.71 57571429
+ 1.00 0.21 0.71 64642857
+ 1.00 0.21 0.71 71714286
+ 1.00 0.21 0.71 78785714
+ 1.00 0.21 0.71 85857143
+ 1.00 0.21 0.71 92928571
+ 1.00 0.21 0.71 100000000
+ 1.00 0.21 0.79 1000000
+ 1.00 0.21 0.79 8071429
+ 1.00 0.21 0.79 15142857
+ 1.00 0.21 0.79 22214286
+ 1.00 0.21 0.79 29285714
+ 1.00 0.21 0.79 36357143
+ 1.00 0.21 0.79 43428571
+ 1.00 0.21 0.79 50500000
+ 1.00 0.21 0.79 57571429
+ 1.00 0.21 0.79 64642857
+ 1.00 0.21 0.79 71714286
+ 1.00 0.21 0.79 78785714
+ 1.00 0.21 0.79 85857143
+ 1.00 0.21 0.79 92928571
+ 1.00 0.21 0.79 100000000
+ 1.00 0.21 0.86 1000000
+ 1.00 0.21 0.86 8071429
+ 1.00 0.21 0.86 15142857
+ 1.00 0.21 0.86 22214286
+ 1.00 0.21 0.86 29285714
+ 1.00 0.21 0.86 36357143
+ 1.00 0.21 0.86 43428571
+ 1.00 0.21 0.86 50500000
+ 1.00 0.21 0.86 57571429
+ 1.00 0.21 0.86 64642857
+ 1.00 0.21 0.86 71714286
+ 1.00 0.21 0.86 78785714
+ 1.00 0.21 0.86 85857143
+ 1.00 0.21 0.86 92928571
+ 1.00 0.21 0.86 100000000
+ 1.00 0.21 0.93 1000000
+ 1.00 0.21 0.93 8071429
+ 1.00 0.21 0.93 15142857
+ 1.00 0.21 0.93 22214286
+ 1.00 0.21 0.93 29285714
+ 1.00 0.21 0.93 36357143
+ 1.00 0.21 0.93 43428571
+ 1.00 0.21 0.93 50500000
+ 1.00 0.21 0.93 57571429
+ 1.00 0.21 0.93 64642857
+ 1.00 0.21 0.93 71714286
+ 1.00 0.21 0.93 78785714
+ 1.00 0.21 0.93 85857143
+ 1.00 0.21 0.93 92928571
+ 1.00 0.21 0.93 100000000
+ 1.00 0.21 1.00 1000000
+ 1.00 0.21 1.00 8071429
+ 1.00 0.21 1.00 15142857
+ 1.00 0.21 1.00 22214286
+ 1.00 0.21 1.00 29285714
+ 1.00 0.21 1.00 36357143
+ 1.00 0.21 1.00 43428571
+ 1.00 0.21 1.00 50500000
+ 1.00 0.21 1.00 57571429
+ 1.00 0.21 1.00 64642857
+ 1.00 0.21 1.00 71714286
+ 1.00 0.21 1.00 78785714
+ 1.00 0.21 1.00 85857143
+ 1.00 0.21 1.00 92928571
+ 1.00 0.21 1.00 100000000
+ 1.00 0.29 0.00 1000000
+ 1.00 0.29 0.00 8071429
+ 1.00 0.29 0.00 15142857
+ 1.00 0.29 0.00 22214286
+ 1.00 0.29 0.00 29285714
+ 1.00 0.29 0.00 36357143
+ 1.00 0.29 0.00 43428571
+ 1.00 0.29 0.00 50500000
+ 1.00 0.29 0.00 57571429
+ 1.00 0.29 0.00 64642857
+ 1.00 0.29 0.00 71714286
+ 1.00 0.29 0.00 78785714
+ 1.00 0.29 0.00 85857143
+ 1.00 0.29 0.00 92928571
+ 1.00 0.29 0.00 100000000
+ 1.00 0.29 0.07 1000000
+ 1.00 0.29 0.07 8071429
+ 1.00 0.29 0.07 15142857
+ 1.00 0.29 0.07 22214286
+ 1.00 0.29 0.07 29285714
+ 1.00 0.29 0.07 36357143
+ 1.00 0.29 0.07 43428571
+ 1.00 0.29 0.07 50500000
+ 1.00 0.29 0.07 57571429
+ 1.00 0.29 0.07 64642857
+ 1.00 0.29 0.07 71714286
+ 1.00 0.29 0.07 78785714
+ 1.00 0.29 0.07 85857143
+ 1.00 0.29 0.07 92928571
+ 1.00 0.29 0.07 100000000
+ 1.00 0.29 0.14 1000000
+ 1.00 0.29 0.14 8071429
+ 1.00 0.29 0.14 15142857
+ 1.00 0.29 0.14 22214286
+ 1.00 0.29 0.14 29285714
+ 1.00 0.29 0.14 36357143
+ 1.00 0.29 0.14 43428571
+ 1.00 0.29 0.14 50500000
+ 1.00 0.29 0.14 57571429
+ 1.00 0.29 0.14 64642857
+ 1.00 0.29 0.14 71714286
+ 1.00 0.29 0.14 78785714
+ 1.00 0.29 0.14 85857143
+ 1.00 0.29 0.14 92928571
+ 1.00 0.29 0.14 100000000
+ 1.00 0.29 0.21 1000000
+ 1.00 0.29 0.21 8071429
+ 1.00 0.29 0.21 15142857
+ 1.00 0.29 0.21 22214286
+ 1.00 0.29 0.21 29285714
+ 1.00 0.29 0.21 36357143
+ 1.00 0.29 0.21 43428571
+ 1.00 0.29 0.21 50500000
+ 1.00 0.29 0.21 57571429
+ 1.00 0.29 0.21 64642857
+ 1.00 0.29 0.21 71714286
+ 1.00 0.29 0.21 78785714
+ 1.00 0.29 0.21 85857143
+ 1.00 0.29 0.21 92928571
+ 1.00 0.29 0.21 100000000
+ 1.00 0.29 0.29 1000000
+ 1.00 0.29 0.29 8071429
+ 1.00 0.29 0.29 15142857
+ 1.00 0.29 0.29 22214286
+ 1.00 0.29 0.29 29285714
+ 1.00 0.29 0.29 36357143
+ 1.00 0.29 0.29 43428571
+ 1.00 0.29 0.29 50500000
+ 1.00 0.29 0.29 57571429
+ 1.00 0.29 0.29 64642857
+ 1.00 0.29 0.29 71714286
+ 1.00 0.29 0.29 78785714
+ 1.00 0.29 0.29 85857143
+ 1.00 0.29 0.29 92928571
+ 1.00 0.29 0.29 100000000
+ 1.00 0.29 0.36 1000000
+ 1.00 0.29 0.36 8071429
+ 1.00 0.29 0.36 15142857
+ 1.00 0.29 0.36 22214286
+ 1.00 0.29 0.36 29285714
+ 1.00 0.29 0.36 36357143
+ 1.00 0.29 0.36 43428571
+ 1.00 0.29 0.36 50500000
+ 1.00 0.29 0.36 57571429
+ 1.00 0.29 0.36 64642857
+ 1.00 0.29 0.36 71714286
+ 1.00 0.29 0.36 78785714
+ 1.00 0.29 0.36 85857143
+ 1.00 0.29 0.36 92928571
+ 1.00 0.29 0.36 100000000
+ 1.00 0.29 0.43 1000000
+ 1.00 0.29 0.43 8071429
+ 1.00 0.29 0.43 15142857
+ 1.00 0.29 0.43 22214286
+ 1.00 0.29 0.43 29285714
+ 1.00 0.29 0.43 36357143
+ 1.00 0.29 0.43 43428571
+ 1.00 0.29 0.43 50500000
+ 1.00 0.29 0.43 57571429
+ 1.00 0.29 0.43 64642857
+ 1.00 0.29 0.43 71714286
+ 1.00 0.29 0.43 78785714
+ 1.00 0.29 0.43 85857143
+ 1.00 0.29 0.43 92928571
+ 1.00 0.29 0.43 100000000
+ 1.00 0.29 0.50 1000000
+ 1.00 0.29 0.50 8071429
+ 1.00 0.29 0.50 15142857
+ 1.00 0.29 0.50 22214286
+ 1.00 0.29 0.50 29285714
+ 1.00 0.29 0.50 36357143
+ 1.00 0.29 0.50 43428571
+ 1.00 0.29 0.50 50500000
+ 1.00 0.29 0.50 57571429
+ 1.00 0.29 0.50 64642857
+ 1.00 0.29 0.50 71714286
+ 1.00 0.29 0.50 78785714
+ 1.00 0.29 0.50 85857143
+ 1.00 0.29 0.50 92928571
+ 1.00 0.29 0.50 100000000
+ 1.00 0.29 0.57 1000000
+ 1.00 0.29 0.57 8071429
+ 1.00 0.29 0.57 15142857
+ 1.00 0.29 0.57 22214286
+ 1.00 0.29 0.57 29285714
+ 1.00 0.29 0.57 36357143
+ 1.00 0.29 0.57 43428571
+ 1.00 0.29 0.57 50500000
+ 1.00 0.29 0.57 57571429
+ 1.00 0.29 0.57 64642857
+ 1.00 0.29 0.57 71714286
+ 1.00 0.29 0.57 78785714
+ 1.00 0.29 0.57 85857143
+ 1.00 0.29 0.57 92928571
+ 1.00 0.29 0.57 100000000
+ 1.00 0.29 0.64 1000000
+ 1.00 0.29 0.64 8071429
+ 1.00 0.29 0.64 15142857
+ 1.00 0.29 0.64 22214286
+ 1.00 0.29 0.64 29285714
+ 1.00 0.29 0.64 36357143
+ 1.00 0.29 0.64 43428571
+ 1.00 0.29 0.64 50500000
+ 1.00 0.29 0.64 57571429
+ 1.00 0.29 0.64 64642857
+ 1.00 0.29 0.64 71714286
+ 1.00 0.29 0.64 78785714
+ 1.00 0.29 0.64 85857143
+ 1.00 0.29 0.64 92928571
+ 1.00 0.29 0.64 100000000
+ 1.00 0.29 0.71 1000000
+ 1.00 0.29 0.71 8071429
+ 1.00 0.29 0.71 15142857
+ 1.00 0.29 0.71 22214286
+ 1.00 0.29 0.71 29285714
+ 1.00 0.29 0.71 36357143
+ 1.00 0.29 0.71 43428571
+ 1.00 0.29 0.71 50500000
+ 1.00 0.29 0.71 57571429
+ 1.00 0.29 0.71 64642857
+ 1.00 0.29 0.71 71714286
+ 1.00 0.29 0.71 78785714
+ 1.00 0.29 0.71 85857143
+ 1.00 0.29 0.71 92928571
+ 1.00 0.29 0.71 100000000
+ 1.00 0.29 0.79 1000000
+ 1.00 0.29 0.79 8071429
+ 1.00 0.29 0.79 15142857
+ 1.00 0.29 0.79 22214286
+ 1.00 0.29 0.79 29285714
+ 1.00 0.29 0.79 36357143
+ 1.00 0.29 0.79 43428571
+ 1.00 0.29 0.79 50500000
+ 1.00 0.29 0.79 57571429
+ 1.00 0.29 0.79 64642857
+ 1.00 0.29 0.79 71714286
+ 1.00 0.29 0.79 78785714
+ 1.00 0.29 0.79 85857143
+ 1.00 0.29 0.79 92928571
+ 1.00 0.29 0.79 100000000
+ 1.00 0.29 0.86 1000000
+ 1.00 0.29 0.86 8071429
+ 1.00 0.29 0.86 15142857
+ 1.00 0.29 0.86 22214286
+ 1.00 0.29 0.86 29285714
+ 1.00 0.29 0.86 36357143
+ 1.00 0.29 0.86 43428571
+ 1.00 0.29 0.86 50500000
+ 1.00 0.29 0.86 57571429
+ 1.00 0.29 0.86 64642857
+ 1.00 0.29 0.86 71714286
+ 1.00 0.29 0.86 78785714
+ 1.00 0.29 0.86 85857143
+ 1.00 0.29 0.86 92928571
+ 1.00 0.29 0.86 100000000
+ 1.00 0.29 0.93 1000000
+ 1.00 0.29 0.93 8071429
+ 1.00 0.29 0.93 15142857
+ 1.00 0.29 0.93 22214286
+ 1.00 0.29 0.93 29285714
+ 1.00 0.29 0.93 36357143
+ 1.00 0.29 0.93 43428571
+ 1.00 0.29 0.93 50500000
+ 1.00 0.29 0.93 57571429
+ 1.00 0.29 0.93 64642857
+ 1.00 0.29 0.93 71714286
+ 1.00 0.29 0.93 78785714
+ 1.00 0.29 0.93 85857143
+ 1.00 0.29 0.93 92928571
+ 1.00 0.29 0.93 100000000
+ 1.00 0.29 1.00 1000000
+ 1.00 0.29 1.00 8071429
+ 1.00 0.29 1.00 15142857
+ 1.00 0.29 1.00 22214286
+ 1.00 0.29 1.00 29285714
+ 1.00 0.29 1.00 36357143
+ 1.00 0.29 1.00 43428571
+ 1.00 0.29 1.00 50500000
+ 1.00 0.29 1.00 57571429
+ 1.00 0.29 1.00 64642857
+ 1.00 0.29 1.00 71714286
+ 1.00 0.29 1.00 78785714
+ 1.00 0.29 1.00 85857143
+ 1.00 0.29 1.00 92928571
+ 1.00 0.29 1.00 100000000
+ 1.00 0.36 0.00 1000000
+ 1.00 0.36 0.00 8071429
+ 1.00 0.36 0.00 15142857
+ 1.00 0.36 0.00 22214286
+ 1.00 0.36 0.00 29285714
+ 1.00 0.36 0.00 36357143
+ 1.00 0.36 0.00 43428571
+ 1.00 0.36 0.00 50500000
+ 1.00 0.36 0.00 57571429
+ 1.00 0.36 0.00 64642857
+ 1.00 0.36 0.00 71714286
+ 1.00 0.36 0.00 78785714
+ 1.00 0.36 0.00 85857143
+ 1.00 0.36 0.00 92928571
+ 1.00 0.36 0.00 100000000
+ 1.00 0.36 0.07 1000000
+ 1.00 0.36 0.07 8071429
+ 1.00 0.36 0.07 15142857
+ 1.00 0.36 0.07 22214286
+ 1.00 0.36 0.07 29285714
+ 1.00 0.36 0.07 36357143
+ 1.00 0.36 0.07 43428571
+ 1.00 0.36 0.07 50500000
+ 1.00 0.36 0.07 57571429
+ 1.00 0.36 0.07 64642857
+ 1.00 0.36 0.07 71714286
+ 1.00 0.36 0.07 78785714
+ 1.00 0.36 0.07 85857143
+ 1.00 0.36 0.07 92928571
+ 1.00 0.36 0.07 100000000
+ 1.00 0.36 0.14 1000000
+ 1.00 0.36 0.14 8071429
+ 1.00 0.36 0.14 15142857
+ 1.00 0.36 0.14 22214286
+ 1.00 0.36 0.14 29285714
+ 1.00 0.36 0.14 36357143
+ 1.00 0.36 0.14 43428571
+ 1.00 0.36 0.14 50500000
+ 1.00 0.36 0.14 57571429
+ 1.00 0.36 0.14 64642857
+ 1.00 0.36 0.14 71714286
+ 1.00 0.36 0.14 78785714
+ 1.00 0.36 0.14 85857143
+ 1.00 0.36 0.14 92928571
+ 1.00 0.36 0.14 100000000
+ 1.00 0.36 0.21 1000000
+ 1.00 0.36 0.21 8071429
+ 1.00 0.36 0.21 15142857
+ 1.00 0.36 0.21 22214286
+ 1.00 0.36 0.21 29285714
+ 1.00 0.36 0.21 36357143
+ 1.00 0.36 0.21 43428571
+ 1.00 0.36 0.21 50500000
+ 1.00 0.36 0.21 57571429
+ 1.00 0.36 0.21 64642857
+ 1.00 0.36 0.21 71714286
+ 1.00 0.36 0.21 78785714
+ 1.00 0.36 0.21 85857143
+ 1.00 0.36 0.21 92928571
+ 1.00 0.36 0.21 100000000
+ 1.00 0.36 0.29 1000000
+ 1.00 0.36 0.29 8071429
+ 1.00 0.36 0.29 15142857
+ 1.00 0.36 0.29 22214286
+ 1.00 0.36 0.29 29285714
+ 1.00 0.36 0.29 36357143
+ 1.00 0.36 0.29 43428571
+ 1.00 0.36 0.29 50500000
+ 1.00 0.36 0.29 57571429
+ 1.00 0.36 0.29 64642857
+ 1.00 0.36 0.29 71714286
+ 1.00 0.36 0.29 78785714
+ 1.00 0.36 0.29 85857143
+ 1.00 0.36 0.29 92928571
+ 1.00 0.36 0.29 100000000
+ 1.00 0.36 0.36 1000000
+ 1.00 0.36 0.36 8071429
+ 1.00 0.36 0.36 15142857
+ 1.00 0.36 0.36 22214286
+ 1.00 0.36 0.36 29285714
+ 1.00 0.36 0.36 36357143
+ 1.00 0.36 0.36 43428571
+ 1.00 0.36 0.36 50500000
+ 1.00 0.36 0.36 57571429
+ 1.00 0.36 0.36 64642857
+ 1.00 0.36 0.36 71714286
+ 1.00 0.36 0.36 78785714
+ 1.00 0.36 0.36 85857143
+ 1.00 0.36 0.36 92928571
+ 1.00 0.36 0.36 100000000
+ 1.00 0.36 0.43 1000000
+ 1.00 0.36 0.43 8071429
+ 1.00 0.36 0.43 15142857
+ 1.00 0.36 0.43 22214286
+ 1.00 0.36 0.43 29285714
+ 1.00 0.36 0.43 36357143
+ 1.00 0.36 0.43 43428571
+ 1.00 0.36 0.43 50500000
+ 1.00 0.36 0.43 57571429
+ 1.00 0.36 0.43 64642857
+ 1.00 0.36 0.43 71714286
+ 1.00 0.36 0.43 78785714
+ 1.00 0.36 0.43 85857143
+ 1.00 0.36 0.43 92928571
+ 1.00 0.36 0.43 100000000
+ 1.00 0.36 0.50 1000000
+ 1.00 0.36 0.50 8071429
+ 1.00 0.36 0.50 15142857
+ 1.00 0.36 0.50 22214286
+ 1.00 0.36 0.50 29285714
+ 1.00 0.36 0.50 36357143
+ 1.00 0.36 0.50 43428571
+ 1.00 0.36 0.50 50500000
+ 1.00 0.36 0.50 57571429
+ 1.00 0.36 0.50 64642857
+ 1.00 0.36 0.50 71714286
+ 1.00 0.36 0.50 78785714
+ 1.00 0.36 0.50 85857143
+ 1.00 0.36 0.50 92928571
+ 1.00 0.36 0.50 100000000
+ 1.00 0.36 0.57 1000000
+ 1.00 0.36 0.57 8071429
+ 1.00 0.36 0.57 15142857
+ 1.00 0.36 0.57 22214286
+ 1.00 0.36 0.57 29285714
+ 1.00 0.36 0.57 36357143
+ 1.00 0.36 0.57 43428571
+ 1.00 0.36 0.57 50500000
+ 1.00 0.36 0.57 57571429
+ 1.00 0.36 0.57 64642857
+ 1.00 0.36 0.57 71714286
+ 1.00 0.36 0.57 78785714
+ 1.00 0.36 0.57 85857143
+ 1.00 0.36 0.57 92928571
+ 1.00 0.36 0.57 100000000
+ 1.00 0.36 0.64 1000000
+ 1.00 0.36 0.64 8071429
+ 1.00 0.36 0.64 15142857
+ 1.00 0.36 0.64 22214286
+ 1.00 0.36 0.64 29285714
+ 1.00 0.36 0.64 36357143
+ 1.00 0.36 0.64 43428571
+ 1.00 0.36 0.64 50500000
+ 1.00 0.36 0.64 57571429
+ 1.00 0.36 0.64 64642857
+ 1.00 0.36 0.64 71714286
+ 1.00 0.36 0.64 78785714
+ 1.00 0.36 0.64 85857143
+ 1.00 0.36 0.64 92928571
+ 1.00 0.36 0.64 100000000
+ 1.00 0.36 0.71 1000000
+ 1.00 0.36 0.71 8071429
+ 1.00 0.36 0.71 15142857
+ 1.00 0.36 0.71 22214286
+ 1.00 0.36 0.71 29285714
+ 1.00 0.36 0.71 36357143
+ 1.00 0.36 0.71 43428571
+ 1.00 0.36 0.71 50500000
+ 1.00 0.36 0.71 57571429
+ 1.00 0.36 0.71 64642857
+ 1.00 0.36 0.71 71714286
+ 1.00 0.36 0.71 78785714
+ 1.00 0.36 0.71 85857143
+ 1.00 0.36 0.71 92928571
+ 1.00 0.36 0.71 100000000
+ 1.00 0.36 0.79 1000000
+ 1.00 0.36 0.79 8071429
+ 1.00 0.36 0.79 15142857
+ 1.00 0.36 0.79 22214286
+ 1.00 0.36 0.79 29285714
+ 1.00 0.36 0.79 36357143
+ 1.00 0.36 0.79 43428571
+ 1.00 0.36 0.79 50500000
+ 1.00 0.36 0.79 57571429
+ 1.00 0.36 0.79 64642857
+ 1.00 0.36 0.79 71714286
+ 1.00 0.36 0.79 78785714
+ 1.00 0.36 0.79 85857143
+ 1.00 0.36 0.79 92928571
+ 1.00 0.36 0.79 100000000
+ 1.00 0.36 0.86 1000000
+ 1.00 0.36 0.86 8071429
+ 1.00 0.36 0.86 15142857
+ 1.00 0.36 0.86 22214286
+ 1.00 0.36 0.86 29285714
+ 1.00 0.36 0.86 36357143
+ 1.00 0.36 0.86 43428571
+ 1.00 0.36 0.86 50500000
+ 1.00 0.36 0.86 57571429
+ 1.00 0.36 0.86 64642857
+ 1.00 0.36 0.86 71714286
+ 1.00 0.36 0.86 78785714
+ 1.00 0.36 0.86 85857143
+ 1.00 0.36 0.86 92928571
+ 1.00 0.36 0.86 100000000
+ 1.00 0.36 0.93 1000000
+ 1.00 0.36 0.93 8071429
+ 1.00 0.36 0.93 15142857
+ 1.00 0.36 0.93 22214286
+ 1.00 0.36 0.93 29285714
+ 1.00 0.36 0.93 36357143
+ 1.00 0.36 0.93 43428571
+ 1.00 0.36 0.93 50500000
+ 1.00 0.36 0.93 57571429
+ 1.00 0.36 0.93 64642857
+ 1.00 0.36 0.93 71714286
+ 1.00 0.36 0.93 78785714
+ 1.00 0.36 0.93 85857143
+ 1.00 0.36 0.93 92928571
+ 1.00 0.36 0.93 100000000
+ 1.00 0.36 1.00 1000000
+ 1.00 0.36 1.00 8071429
+ 1.00 0.36 1.00 15142857
+ 1.00 0.36 1.00 22214286
+ 1.00 0.36 1.00 29285714
+ 1.00 0.36 1.00 36357143
+ 1.00 0.36 1.00 43428571
+ 1.00 0.36 1.00 50500000
+ 1.00 0.36 1.00 57571429
+ 1.00 0.36 1.00 64642857
+ 1.00 0.36 1.00 71714286
+ 1.00 0.36 1.00 78785714
+ 1.00 0.36 1.00 85857143
+ 1.00 0.36 1.00 92928571
+ 1.00 0.36 1.00 100000000
+ 1.00 0.43 0.00 1000000
+ 1.00 0.43 0.00 8071429
+ 1.00 0.43 0.00 15142857
+ 1.00 0.43 0.00 22214286
+ 1.00 0.43 0.00 29285714
+ 1.00 0.43 0.00 36357143
+ 1.00 0.43 0.00 43428571
+ 1.00 0.43 0.00 50500000
+ 1.00 0.43 0.00 57571429
+ 1.00 0.43 0.00 64642857
+ 1.00 0.43 0.00 71714286
+ 1.00 0.43 0.00 78785714
+ 1.00 0.43 0.00 85857143
+ 1.00 0.43 0.00 92928571
+ 1.00 0.43 0.00 100000000
+ 1.00 0.43 0.07 1000000
+ 1.00 0.43 0.07 8071429
+ 1.00 0.43 0.07 15142857
+ 1.00 0.43 0.07 22214286
+ 1.00 0.43 0.07 29285714
+ 1.00 0.43 0.07 36357143
+ 1.00 0.43 0.07 43428571
+ 1.00 0.43 0.07 50500000
+ 1.00 0.43 0.07 57571429
+ 1.00 0.43 0.07 64642857
+ 1.00 0.43 0.07 71714286
+ 1.00 0.43 0.07 78785714
+ 1.00 0.43 0.07 85857143
+ 1.00 0.43 0.07 92928571
+ 1.00 0.43 0.07 100000000
+ 1.00 0.43 0.14 1000000
+ 1.00 0.43 0.14 8071429
+ 1.00 0.43 0.14 15142857
+ 1.00 0.43 0.14 22214286
+ 1.00 0.43 0.14 29285714
+ 1.00 0.43 0.14 36357143
+ 1.00 0.43 0.14 43428571
+ 1.00 0.43 0.14 50500000
+ 1.00 0.43 0.14 57571429
+ 1.00 0.43 0.14 64642857
+ 1.00 0.43 0.14 71714286
+ 1.00 0.43 0.14 78785714
+ 1.00 0.43 0.14 85857143
+ 1.00 0.43 0.14 92928571
+ 1.00 0.43 0.14 100000000
+ 1.00 0.43 0.21 1000000
+ 1.00 0.43 0.21 8071429
+ 1.00 0.43 0.21 15142857
+ 1.00 0.43 0.21 22214286
+ 1.00 0.43 0.21 29285714
+ 1.00 0.43 0.21 36357143
+ 1.00 0.43 0.21 43428571
+ 1.00 0.43 0.21 50500000
+ 1.00 0.43 0.21 57571429
+ 1.00 0.43 0.21 64642857
+ 1.00 0.43 0.21 71714286
+ 1.00 0.43 0.21 78785714
+ 1.00 0.43 0.21 85857143
+ 1.00 0.43 0.21 92928571
+ 1.00 0.43 0.21 100000000
+ 1.00 0.43 0.29 1000000
+ 1.00 0.43 0.29 8071429
+ 1.00 0.43 0.29 15142857
+ 1.00 0.43 0.29 22214286
+ 1.00 0.43 0.29 29285714
+ 1.00 0.43 0.29 36357143
+ 1.00 0.43 0.29 43428571
+ 1.00 0.43 0.29 50500000
+ 1.00 0.43 0.29 57571429
+ 1.00 0.43 0.29 64642857
+ 1.00 0.43 0.29 71714286
+ 1.00 0.43 0.29 78785714
+ 1.00 0.43 0.29 85857143
+ 1.00 0.43 0.29 92928571
+ 1.00 0.43 0.29 100000000
+ 1.00 0.43 0.36 1000000
+ 1.00 0.43 0.36 8071429
+ 1.00 0.43 0.36 15142857
+ 1.00 0.43 0.36 22214286
+ 1.00 0.43 0.36 29285714
+ 1.00 0.43 0.36 36357143
+ 1.00 0.43 0.36 43428571
+ 1.00 0.43 0.36 50500000
+ 1.00 0.43 0.36 57571429
+ 1.00 0.43 0.36 64642857
+ 1.00 0.43 0.36 71714286
+ 1.00 0.43 0.36 78785714
+ 1.00 0.43 0.36 85857143
+ 1.00 0.43 0.36 92928571
+ 1.00 0.43 0.36 100000000
+ 1.00 0.43 0.43 1000000
+ 1.00 0.43 0.43 8071429
+ 1.00 0.43 0.43 15142857
+ 1.00 0.43 0.43 22214286
+ 1.00 0.43 0.43 29285714
+ 1.00 0.43 0.43 36357143
+ 1.00 0.43 0.43 43428571
+ 1.00 0.43 0.43 50500000
+ 1.00 0.43 0.43 57571429
+ 1.00 0.43 0.43 64642857
+ 1.00 0.43 0.43 71714286
+ 1.00 0.43 0.43 78785714
+ 1.00 0.43 0.43 85857143
+ 1.00 0.43 0.43 92928571
+ 1.00 0.43 0.43 100000000
+ 1.00 0.43 0.50 1000000
+ 1.00 0.43 0.50 8071429
+ 1.00 0.43 0.50 15142857
+ 1.00 0.43 0.50 22214286
+ 1.00 0.43 0.50 29285714
+ 1.00 0.43 0.50 36357143
+ 1.00 0.43 0.50 43428571
+ 1.00 0.43 0.50 50500000
+ 1.00 0.43 0.50 57571429
+ 1.00 0.43 0.50 64642857
+ 1.00 0.43 0.50 71714286
+ 1.00 0.43 0.50 78785714
+ 1.00 0.43 0.50 85857143
+ 1.00 0.43 0.50 92928571
+ 1.00 0.43 0.50 100000000
+ 1.00 0.43 0.57 1000000
+ 1.00 0.43 0.57 8071429
+ 1.00 0.43 0.57 15142857
+ 1.00 0.43 0.57 22214286
+ 1.00 0.43 0.57 29285714
+ 1.00 0.43 0.57 36357143
+ 1.00 0.43 0.57 43428571
+ 1.00 0.43 0.57 50500000
+ 1.00 0.43 0.57 57571429
+ 1.00 0.43 0.57 64642857
+ 1.00 0.43 0.57 71714286
+ 1.00 0.43 0.57 78785714
+ 1.00 0.43 0.57 85857143
+ 1.00 0.43 0.57 92928571
+ 1.00 0.43 0.57 100000000
+ 1.00 0.43 0.64 1000000
+ 1.00 0.43 0.64 8071429
+ 1.00 0.43 0.64 15142857
+ 1.00 0.43 0.64 22214286
+ 1.00 0.43 0.64 29285714
+ 1.00 0.43 0.64 36357143
+ 1.00 0.43 0.64 43428571
+ 1.00 0.43 0.64 50500000
+ 1.00 0.43 0.64 57571429
+ 1.00 0.43 0.64 64642857
+ 1.00 0.43 0.64 71714286
+ 1.00 0.43 0.64 78785714
+ 1.00 0.43 0.64 85857143
+ 1.00 0.43 0.64 92928571
+ 1.00 0.43 0.64 100000000
+ 1.00 0.43 0.71 1000000
+ 1.00 0.43 0.71 8071429
+ 1.00 0.43 0.71 15142857
+ 1.00 0.43 0.71 22214286
+ 1.00 0.43 0.71 29285714
+ 1.00 0.43 0.71 36357143
+ 1.00 0.43 0.71 43428571
+ 1.00 0.43 0.71 50500000
+ 1.00 0.43 0.71 57571429
+ 1.00 0.43 0.71 64642857
+ 1.00 0.43 0.71 71714286
+ 1.00 0.43 0.71 78785714
+ 1.00 0.43 0.71 85857143
+ 1.00 0.43 0.71 92928571
+ 1.00 0.43 0.71 100000000
+ 1.00 0.43 0.79 1000000
+ 1.00 0.43 0.79 8071429
+ 1.00 0.43 0.79 15142857
+ 1.00 0.43 0.79 22214286
+ 1.00 0.43 0.79 29285714
+ 1.00 0.43 0.79 36357143
+ 1.00 0.43 0.79 43428571
+ 1.00 0.43 0.79 50500000
+ 1.00 0.43 0.79 57571429
+ 1.00 0.43 0.79 64642857
+ 1.00 0.43 0.79 71714286
+ 1.00 0.43 0.79 78785714
+ 1.00 0.43 0.79 85857143
+ 1.00 0.43 0.79 92928571
+ 1.00 0.43 0.79 100000000
+ 1.00 0.43 0.86 1000000
+ 1.00 0.43 0.86 8071429
+ 1.00 0.43 0.86 15142857
+ 1.00 0.43 0.86 22214286
+ 1.00 0.43 0.86 29285714
+ 1.00 0.43 0.86 36357143
+ 1.00 0.43 0.86 43428571
+ 1.00 0.43 0.86 50500000
+ 1.00 0.43 0.86 57571429
+ 1.00 0.43 0.86 64642857
+ 1.00 0.43 0.86 71714286
+ 1.00 0.43 0.86 78785714
+ 1.00 0.43 0.86 85857143
+ 1.00 0.43 0.86 92928571
+ 1.00 0.43 0.86 100000000
+ 1.00 0.43 0.93 1000000
+ 1.00 0.43 0.93 8071429
+ 1.00 0.43 0.93 15142857
+ 1.00 0.43 0.93 22214286
+ 1.00 0.43 0.93 29285714
+ 1.00 0.43 0.93 36357143
+ 1.00 0.43 0.93 43428571
+ 1.00 0.43 0.93 50500000
+ 1.00 0.43 0.93 57571429
+ 1.00 0.43 0.93 64642857
+ 1.00 0.43 0.93 71714286
+ 1.00 0.43 0.93 78785714
+ 1.00 0.43 0.93 85857143
+ 1.00 0.43 0.93 92928571
+ 1.00 0.43 0.93 100000000
+ 1.00 0.43 1.00 1000000
+ 1.00 0.43 1.00 8071429
+ 1.00 0.43 1.00 15142857
+ 1.00 0.43 1.00 22214286
+ 1.00 0.43 1.00 29285714
+ 1.00 0.43 1.00 36357143
+ 1.00 0.43 1.00 43428571
+ 1.00 0.43 1.00 50500000
+ 1.00 0.43 1.00 57571429
+ 1.00 0.43 1.00 64642857
+ 1.00 0.43 1.00 71714286
+ 1.00 0.43 1.00 78785714
+ 1.00 0.43 1.00 85857143
+ 1.00 0.43 1.00 92928571
+ 1.00 0.43 1.00 100000000
+ 1.00 0.50 0.00 1000000
+ 1.00 0.50 0.00 8071429
+ 1.00 0.50 0.00 15142857
+ 1.00 0.50 0.00 22214286
+ 1.00 0.50 0.00 29285714
+ 1.00 0.50 0.00 36357143
+ 1.00 0.50 0.00 43428571
+ 1.00 0.50 0.00 50500000
+ 1.00 0.50 0.00 57571429
+ 1.00 0.50 0.00 64642857
+ 1.00 0.50 0.00 71714286
+ 1.00 0.50 0.00 78785714
+ 1.00 0.50 0.00 85857143
+ 1.00 0.50 0.00 92928571
+ 1.00 0.50 0.00 100000000
+ 1.00 0.50 0.07 1000000
+ 1.00 0.50 0.07 8071429
+ 1.00 0.50 0.07 15142857
+ 1.00 0.50 0.07 22214286
+ 1.00 0.50 0.07 29285714
+ 1.00 0.50 0.07 36357143
+ 1.00 0.50 0.07 43428571
+ 1.00 0.50 0.07 50500000
+ 1.00 0.50 0.07 57571429
+ 1.00 0.50 0.07 64642857
+ 1.00 0.50 0.07 71714286
+ 1.00 0.50 0.07 78785714
+ 1.00 0.50 0.07 85857143
+ 1.00 0.50 0.07 92928571
+ 1.00 0.50 0.07 100000000
+ 1.00 0.50 0.14 1000000
+ 1.00 0.50 0.14 8071429
+ 1.00 0.50 0.14 15142857
+ 1.00 0.50 0.14 22214286
+ 1.00 0.50 0.14 29285714
+ 1.00 0.50 0.14 36357143
+ 1.00 0.50 0.14 43428571
+ 1.00 0.50 0.14 50500000
+ 1.00 0.50 0.14 57571429
+ 1.00 0.50 0.14 64642857
+ 1.00 0.50 0.14 71714286
+ 1.00 0.50 0.14 78785714
+ 1.00 0.50 0.14 85857143
+ 1.00 0.50 0.14 92928571
+ 1.00 0.50 0.14 100000000
+ 1.00 0.50 0.21 1000000
+ 1.00 0.50 0.21 8071429
+ 1.00 0.50 0.21 15142857
+ 1.00 0.50 0.21 22214286
+ 1.00 0.50 0.21 29285714
+ 1.00 0.50 0.21 36357143
+ 1.00 0.50 0.21 43428571
+ 1.00 0.50 0.21 50500000
+ 1.00 0.50 0.21 57571429
+ 1.00 0.50 0.21 64642857
+ 1.00 0.50 0.21 71714286
+ 1.00 0.50 0.21 78785714
+ 1.00 0.50 0.21 85857143
+ 1.00 0.50 0.21 92928571
+ 1.00 0.50 0.21 100000000
+ 1.00 0.50 0.29 1000000
+ 1.00 0.50 0.29 8071429
+ 1.00 0.50 0.29 15142857
+ 1.00 0.50 0.29 22214286
+ 1.00 0.50 0.29 29285714
+ 1.00 0.50 0.29 36357143
+ 1.00 0.50 0.29 43428571
+ 1.00 0.50 0.29 50500000
+ 1.00 0.50 0.29 57571429
+ 1.00 0.50 0.29 64642857
+ 1.00 0.50 0.29 71714286
+ 1.00 0.50 0.29 78785714
+ 1.00 0.50 0.29 85857143
+ 1.00 0.50 0.29 92928571
+ 1.00 0.50 0.29 100000000
+ 1.00 0.50 0.36 1000000
+ 1.00 0.50 0.36 8071429
+ 1.00 0.50 0.36 15142857
+ 1.00 0.50 0.36 22214286
+ 1.00 0.50 0.36 29285714
+ 1.00 0.50 0.36 36357143
+ 1.00 0.50 0.36 43428571
+ 1.00 0.50 0.36 50500000
+ 1.00 0.50 0.36 57571429
+ 1.00 0.50 0.36 64642857
+ 1.00 0.50 0.36 71714286
+ 1.00 0.50 0.36 78785714
+ 1.00 0.50 0.36 85857143
+ 1.00 0.50 0.36 92928571
+ 1.00 0.50 0.36 100000000
+ 1.00 0.50 0.43 1000000
+ 1.00 0.50 0.43 8071429
+ 1.00 0.50 0.43 15142857
+ 1.00 0.50 0.43 22214286
+ 1.00 0.50 0.43 29285714
+ 1.00 0.50 0.43 36357143
+ 1.00 0.50 0.43 43428571
+ 1.00 0.50 0.43 50500000
+ 1.00 0.50 0.43 57571429
+ 1.00 0.50 0.43 64642857
+ 1.00 0.50 0.43 71714286
+ 1.00 0.50 0.43 78785714
+ 1.00 0.50 0.43 85857143
+ 1.00 0.50 0.43 92928571
+ 1.00 0.50 0.43 100000000
+ 1.00 0.50 0.50 1000000
+ 1.00 0.50 0.50 8071429
+ 1.00 0.50 0.50 15142857
+ 1.00 0.50 0.50 22214286
+ 1.00 0.50 0.50 29285714
+ 1.00 0.50 0.50 36357143
+ 1.00 0.50 0.50 43428571
+ 1.00 0.50 0.50 50500000
+ 1.00 0.50 0.50 57571429
+ 1.00 0.50 0.50 64642857
+ 1.00 0.50 0.50 71714286
+ 1.00 0.50 0.50 78785714
+ 1.00 0.50 0.50 85857143
+ 1.00 0.50 0.50 92928571
+ 1.00 0.50 0.50 100000000
+ 1.00 0.50 0.57 1000000
+ 1.00 0.50 0.57 8071429
+ 1.00 0.50 0.57 15142857
+ 1.00 0.50 0.57 22214286
+ 1.00 0.50 0.57 29285714
+ 1.00 0.50 0.57 36357143
+ 1.00 0.50 0.57 43428571
+ 1.00 0.50 0.57 50500000
+ 1.00 0.50 0.57 57571429
+ 1.00 0.50 0.57 64642857
+ 1.00 0.50 0.57 71714286
+ 1.00 0.50 0.57 78785714
+ 1.00 0.50 0.57 85857143
+ 1.00 0.50 0.57 92928571
+ 1.00 0.50 0.57 100000000
+ 1.00 0.50 0.64 1000000
+ 1.00 0.50 0.64 8071429
+ 1.00 0.50 0.64 15142857
+ 1.00 0.50 0.64 22214286
+ 1.00 0.50 0.64 29285714
+ 1.00 0.50 0.64 36357143
+ 1.00 0.50 0.64 43428571
+ 1.00 0.50 0.64 50500000
+ 1.00 0.50 0.64 57571429
+ 1.00 0.50 0.64 64642857
+ 1.00 0.50 0.64 71714286
+ 1.00 0.50 0.64 78785714
+ 1.00 0.50 0.64 85857143
+ 1.00 0.50 0.64 92928571
+ 1.00 0.50 0.64 100000000
+ 1.00 0.50 0.71 1000000
+ 1.00 0.50 0.71 8071429
+ 1.00 0.50 0.71 15142857
+ 1.00 0.50 0.71 22214286
+ 1.00 0.50 0.71 29285714
+ 1.00 0.50 0.71 36357143
+ 1.00 0.50 0.71 43428571
+ 1.00 0.50 0.71 50500000
+ 1.00 0.50 0.71 57571429
+ 1.00 0.50 0.71 64642857
+ 1.00 0.50 0.71 71714286
+ 1.00 0.50 0.71 78785714
+ 1.00 0.50 0.71 85857143
+ 1.00 0.50 0.71 92928571
+ 1.00 0.50 0.71 100000000
+ 1.00 0.50 0.79 1000000
+ 1.00 0.50 0.79 8071429
+ 1.00 0.50 0.79 15142857
+ 1.00 0.50 0.79 22214286
+ 1.00 0.50 0.79 29285714
+ 1.00 0.50 0.79 36357143
+ 1.00 0.50 0.79 43428571
+ 1.00 0.50 0.79 50500000
+ 1.00 0.50 0.79 57571429
+ 1.00 0.50 0.79 64642857
+ 1.00 0.50 0.79 71714286
+ 1.00 0.50 0.79 78785714
+ 1.00 0.50 0.79 85857143
+ 1.00 0.50 0.79 92928571
+ 1.00 0.50 0.79 100000000
+ 1.00 0.50 0.86 1000000
+ 1.00 0.50 0.86 8071429
+ 1.00 0.50 0.86 15142857
+ 1.00 0.50 0.86 22214286
+ 1.00 0.50 0.86 29285714
+ 1.00 0.50 0.86 36357143
+ 1.00 0.50 0.86 43428571
+ 1.00 0.50 0.86 50500000
+ 1.00 0.50 0.86 57571429
+ 1.00 0.50 0.86 64642857
+ 1.00 0.50 0.86 71714286
+ 1.00 0.50 0.86 78785714
+ 1.00 0.50 0.86 85857143
+ 1.00 0.50 0.86 92928571
+ 1.00 0.50 0.86 100000000
+ 1.00 0.50 0.93 1000000
+ 1.00 0.50 0.93 8071429
+ 1.00 0.50 0.93 15142857
+ 1.00 0.50 0.93 22214286
+ 1.00 0.50 0.93 29285714
+ 1.00 0.50 0.93 36357143
+ 1.00 0.50 0.93 43428571
+ 1.00 0.50 0.93 50500000
+ 1.00 0.50 0.93 57571429
+ 1.00 0.50 0.93 64642857
+ 1.00 0.50 0.93 71714286
+ 1.00 0.50 0.93 78785714
+ 1.00 0.50 0.93 85857143
+ 1.00 0.50 0.93 92928571
+ 1.00 0.50 0.93 100000000
+ 1.00 0.50 1.00 1000000
+ 1.00 0.50 1.00 8071429
+ 1.00 0.50 1.00 15142857
+ 1.00 0.50 1.00 22214286
+ 1.00 0.50 1.00 29285714
+ 1.00 0.50 1.00 36357143
+ 1.00 0.50 1.00 43428571
+ 1.00 0.50 1.00 50500000
+ 1.00 0.50 1.00 57571429
+ 1.00 0.50 1.00 64642857
+ 1.00 0.50 1.00 71714286
+ 1.00 0.50 1.00 78785714
+ 1.00 0.50 1.00 85857143
+ 1.00 0.50 1.00 92928571
+ 1.00 0.50 1.00 100000000
+ 1.00 0.57 0.00 1000000
+ 1.00 0.57 0.00 8071429
+ 1.00 0.57 0.00 15142857
+ 1.00 0.57 0.00 22214286
+ 1.00 0.57 0.00 29285714
+ 1.00 0.57 0.00 36357143
+ 1.00 0.57 0.00 43428571
+ 1.00 0.57 0.00 50500000
+ 1.00 0.57 0.00 57571429
+ 1.00 0.57 0.00 64642857
+ 1.00 0.57 0.00 71714286
+ 1.00 0.57 0.00 78785714
+ 1.00 0.57 0.00 85857143
+ 1.00 0.57 0.00 92928571
+ 1.00 0.57 0.00 100000000
+ 1.00 0.57 0.07 1000000
+ 1.00 0.57 0.07 8071429
+ 1.00 0.57 0.07 15142857
+ 1.00 0.57 0.07 22214286
+ 1.00 0.57 0.07 29285714
+ 1.00 0.57 0.07 36357143
+ 1.00 0.57 0.07 43428571
+ 1.00 0.57 0.07 50500000
+ 1.00 0.57 0.07 57571429
+ 1.00 0.57 0.07 64642857
+ 1.00 0.57 0.07 71714286
+ 1.00 0.57 0.07 78785714
+ 1.00 0.57 0.07 85857143
+ 1.00 0.57 0.07 92928571
+ 1.00 0.57 0.07 100000000
+ 1.00 0.57 0.14 1000000
+ 1.00 0.57 0.14 8071429
+ 1.00 0.57 0.14 15142857
+ 1.00 0.57 0.14 22214286
+ 1.00 0.57 0.14 29285714
+ 1.00 0.57 0.14 36357143
+ 1.00 0.57 0.14 43428571
+ 1.00 0.57 0.14 50500000
+ 1.00 0.57 0.14 57571429
+ 1.00 0.57 0.14 64642857
+ 1.00 0.57 0.14 71714286
+ 1.00 0.57 0.14 78785714
+ 1.00 0.57 0.14 85857143
+ 1.00 0.57 0.14 92928571
+ 1.00 0.57 0.14 100000000
+ 1.00 0.57 0.21 1000000
+ 1.00 0.57 0.21 8071429
+ 1.00 0.57 0.21 15142857
+ 1.00 0.57 0.21 22214286
+ 1.00 0.57 0.21 29285714
+ 1.00 0.57 0.21 36357143
+ 1.00 0.57 0.21 43428571
+ 1.00 0.57 0.21 50500000
+ 1.00 0.57 0.21 57571429
+ 1.00 0.57 0.21 64642857
+ 1.00 0.57 0.21 71714286
+ 1.00 0.57 0.21 78785714
+ 1.00 0.57 0.21 85857143
+ 1.00 0.57 0.21 92928571
+ 1.00 0.57 0.21 100000000
+ 1.00 0.57 0.29 1000000
+ 1.00 0.57 0.29 8071429
+ 1.00 0.57 0.29 15142857
+ 1.00 0.57 0.29 22214286
+ 1.00 0.57 0.29 29285714
+ 1.00 0.57 0.29 36357143
+ 1.00 0.57 0.29 43428571
+ 1.00 0.57 0.29 50500000
+ 1.00 0.57 0.29 57571429
+ 1.00 0.57 0.29 64642857
+ 1.00 0.57 0.29 71714286
+ 1.00 0.57 0.29 78785714
+ 1.00 0.57 0.29 85857143
+ 1.00 0.57 0.29 92928571
+ 1.00 0.57 0.29 100000000
+ 1.00 0.57 0.36 1000000
+ 1.00 0.57 0.36 8071429
+ 1.00 0.57 0.36 15142857
+ 1.00 0.57 0.36 22214286
+ 1.00 0.57 0.36 29285714
+ 1.00 0.57 0.36 36357143
+ 1.00 0.57 0.36 43428571
+ 1.00 0.57 0.36 50500000
+ 1.00 0.57 0.36 57571429
+ 1.00 0.57 0.36 64642857
+ 1.00 0.57 0.36 71714286
+ 1.00 0.57 0.36 78785714
+ 1.00 0.57 0.36 85857143
+ 1.00 0.57 0.36 92928571
+ 1.00 0.57 0.36 100000000
+ 1.00 0.57 0.43 1000000
+ 1.00 0.57 0.43 8071429
+ 1.00 0.57 0.43 15142857
+ 1.00 0.57 0.43 22214286
+ 1.00 0.57 0.43 29285714
+ 1.00 0.57 0.43 36357143
+ 1.00 0.57 0.43 43428571
+ 1.00 0.57 0.43 50500000
+ 1.00 0.57 0.43 57571429
+ 1.00 0.57 0.43 64642857
+ 1.00 0.57 0.43 71714286
+ 1.00 0.57 0.43 78785714
+ 1.00 0.57 0.43 85857143
+ 1.00 0.57 0.43 92928571
+ 1.00 0.57 0.43 100000000
+ 1.00 0.57 0.50 1000000
+ 1.00 0.57 0.50 8071429
+ 1.00 0.57 0.50 15142857
+ 1.00 0.57 0.50 22214286
+ 1.00 0.57 0.50 29285714
+ 1.00 0.57 0.50 36357143
+ 1.00 0.57 0.50 43428571
+ 1.00 0.57 0.50 50500000
+ 1.00 0.57 0.50 57571429
+ 1.00 0.57 0.50 64642857
+ 1.00 0.57 0.50 71714286
+ 1.00 0.57 0.50 78785714
+ 1.00 0.57 0.50 85857143
+ 1.00 0.57 0.50 92928571
+ 1.00 0.57 0.50 100000000
+ 1.00 0.57 0.57 1000000
+ 1.00 0.57 0.57 8071429
+ 1.00 0.57 0.57 15142857
+ 1.00 0.57 0.57 22214286
+ 1.00 0.57 0.57 29285714
+ 1.00 0.57 0.57 36357143
+ 1.00 0.57 0.57 43428571
+ 1.00 0.57 0.57 50500000
+ 1.00 0.57 0.57 57571429
+ 1.00 0.57 0.57 64642857
+ 1.00 0.57 0.57 71714286
+ 1.00 0.57 0.57 78785714
+ 1.00 0.57 0.57 85857143
+ 1.00 0.57 0.57 92928571
+ 1.00 0.57 0.57 100000000
+ 1.00 0.57 0.64 1000000
+ 1.00 0.57 0.64 8071429
+ 1.00 0.57 0.64 15142857
+ 1.00 0.57 0.64 22214286
+ 1.00 0.57 0.64 29285714
+ 1.00 0.57 0.64 36357143
+ 1.00 0.57 0.64 43428571
+ 1.00 0.57 0.64 50500000
+ 1.00 0.57 0.64 57571429
+ 1.00 0.57 0.64 64642857
+ 1.00 0.57 0.64 71714286
+ 1.00 0.57 0.64 78785714
+ 1.00 0.57 0.64 85857143
+ 1.00 0.57 0.64 92928571
+ 1.00 0.57 0.64 100000000
+ 1.00 0.57 0.71 1000000
+ 1.00 0.57 0.71 8071429
+ 1.00 0.57 0.71 15142857
+ 1.00 0.57 0.71 22214286
+ 1.00 0.57 0.71 29285714
+ 1.00 0.57 0.71 36357143
+ 1.00 0.57 0.71 43428571
+ 1.00 0.57 0.71 50500000
+ 1.00 0.57 0.71 57571429
+ 1.00 0.57 0.71 64642857
+ 1.00 0.57 0.71 71714286
+ 1.00 0.57 0.71 78785714
+ 1.00 0.57 0.71 85857143
+ 1.00 0.57 0.71 92928571
+ 1.00 0.57 0.71 100000000
+ 1.00 0.57 0.79 1000000
+ 1.00 0.57 0.79 8071429
+ 1.00 0.57 0.79 15142857
+ 1.00 0.57 0.79 22214286
+ 1.00 0.57 0.79 29285714
+ 1.00 0.57 0.79 36357143
+ 1.00 0.57 0.79 43428571
+ 1.00 0.57 0.79 50500000
+ 1.00 0.57 0.79 57571429
+ 1.00 0.57 0.79 64642857
+ 1.00 0.57 0.79 71714286
+ 1.00 0.57 0.79 78785714
+ 1.00 0.57 0.79 85857143
+ 1.00 0.57 0.79 92928571
+ 1.00 0.57 0.79 100000000
+ 1.00 0.57 0.86 1000000
+ 1.00 0.57 0.86 8071429
+ 1.00 0.57 0.86 15142857
+ 1.00 0.57 0.86 22214286
+ 1.00 0.57 0.86 29285714
+ 1.00 0.57 0.86 36357143
+ 1.00 0.57 0.86 43428571
+ 1.00 0.57 0.86 50500000
+ 1.00 0.57 0.86 57571429
+ 1.00 0.57 0.86 64642857
+ 1.00 0.57 0.86 71714286
+ 1.00 0.57 0.86 78785714
+ 1.00 0.57 0.86 85857143
+ 1.00 0.57 0.86 92928571
+ 1.00 0.57 0.86 100000000
+ 1.00 0.57 0.93 1000000
+ 1.00 0.57 0.93 8071429
+ 1.00 0.57 0.93 15142857
+ 1.00 0.57 0.93 22214286
+ 1.00 0.57 0.93 29285714
+ 1.00 0.57 0.93 36357143
+ 1.00 0.57 0.93 43428571
+ 1.00 0.57 0.93 50500000
+ 1.00 0.57 0.93 57571429
+ 1.00 0.57 0.93 64642857
+ 1.00 0.57 0.93 71714286
+ 1.00 0.57 0.93 78785714
+ 1.00 0.57 0.93 85857143
+ 1.00 0.57 0.93 92928571
+ 1.00 0.57 0.93 100000000
+ 1.00 0.57 1.00 1000000
+ 1.00 0.57 1.00 8071429
+ 1.00 0.57 1.00 15142857
+ 1.00 0.57 1.00 22214286
+ 1.00 0.57 1.00 29285714
+ 1.00 0.57 1.00 36357143
+ 1.00 0.57 1.00 43428571
+ 1.00 0.57 1.00 50500000
+ 1.00 0.57 1.00 57571429
+ 1.00 0.57 1.00 64642857
+ 1.00 0.57 1.00 71714286
+ 1.00 0.57 1.00 78785714
+ 1.00 0.57 1.00 85857143
+ 1.00 0.57 1.00 92928571
+ 1.00 0.57 1.00 100000000
+ 1.00 0.64 0.00 1000000
+ 1.00 0.64 0.00 8071429
+ 1.00 0.64 0.00 15142857
+ 1.00 0.64 0.00 22214286
+ 1.00 0.64 0.00 29285714
+ 1.00 0.64 0.00 36357143
+ 1.00 0.64 0.00 43428571
+ 1.00 0.64 0.00 50500000
+ 1.00 0.64 0.00 57571429
+ 1.00 0.64 0.00 64642857
+ 1.00 0.64 0.00 71714286
+ 1.00 0.64 0.00 78785714
+ 1.00 0.64 0.00 85857143
+ 1.00 0.64 0.00 92928571
+ 1.00 0.64 0.00 100000000
+ 1.00 0.64 0.07 1000000
+ 1.00 0.64 0.07 8071429
+ 1.00 0.64 0.07 15142857
+ 1.00 0.64 0.07 22214286
+ 1.00 0.64 0.07 29285714
+ 1.00 0.64 0.07 36357143
+ 1.00 0.64 0.07 43428571
+ 1.00 0.64 0.07 50500000
+ 1.00 0.64 0.07 57571429
+ 1.00 0.64 0.07 64642857
+ 1.00 0.64 0.07 71714286
+ 1.00 0.64 0.07 78785714
+ 1.00 0.64 0.07 85857143
+ 1.00 0.64 0.07 92928571
+ 1.00 0.64 0.07 100000000
+ 1.00 0.64 0.14 1000000
+ 1.00 0.64 0.14 8071429
+ 1.00 0.64 0.14 15142857
+ 1.00 0.64 0.14 22214286
+ 1.00 0.64 0.14 29285714
+ 1.00 0.64 0.14 36357143
+ 1.00 0.64 0.14 43428571
+ 1.00 0.64 0.14 50500000
+ 1.00 0.64 0.14 57571429
+ 1.00 0.64 0.14 64642857
+ 1.00 0.64 0.14 71714286
+ 1.00 0.64 0.14 78785714
+ 1.00 0.64 0.14 85857143
+ 1.00 0.64 0.14 92928571
+ 1.00 0.64 0.14 100000000
+ 1.00 0.64 0.21 1000000
+ 1.00 0.64 0.21 8071429
+ 1.00 0.64 0.21 15142857
+ 1.00 0.64 0.21 22214286
+ 1.00 0.64 0.21 29285714
+ 1.00 0.64 0.21 36357143
+ 1.00 0.64 0.21 43428571
+ 1.00 0.64 0.21 50500000
+ 1.00 0.64 0.21 57571429
+ 1.00 0.64 0.21 64642857
+ 1.00 0.64 0.21 71714286
+ 1.00 0.64 0.21 78785714
+ 1.00 0.64 0.21 85857143
+ 1.00 0.64 0.21 92928571
+ 1.00 0.64 0.21 100000000
+ 1.00 0.64 0.29 1000000
+ 1.00 0.64 0.29 8071429
+ 1.00 0.64 0.29 15142857
+ 1.00 0.64 0.29 22214286
+ 1.00 0.64 0.29 29285714
+ 1.00 0.64 0.29 36357143
+ 1.00 0.64 0.29 43428571
+ 1.00 0.64 0.29 50500000
+ 1.00 0.64 0.29 57571429
+ 1.00 0.64 0.29 64642857
+ 1.00 0.64 0.29 71714286
+ 1.00 0.64 0.29 78785714
+ 1.00 0.64 0.29 85857143
+ 1.00 0.64 0.29 92928571
+ 1.00 0.64 0.29 100000000
+ 1.00 0.64 0.36 1000000
+ 1.00 0.64 0.36 8071429
+ 1.00 0.64 0.36 15142857
+ 1.00 0.64 0.36 22214286
+ 1.00 0.64 0.36 29285714
+ 1.00 0.64 0.36 36357143
+ 1.00 0.64 0.36 43428571
+ 1.00 0.64 0.36 50500000
+ 1.00 0.64 0.36 57571429
+ 1.00 0.64 0.36 64642857
+ 1.00 0.64 0.36 71714286
+ 1.00 0.64 0.36 78785714
+ 1.00 0.64 0.36 85857143
+ 1.00 0.64 0.36 92928571
+ 1.00 0.64 0.36 100000000
+ 1.00 0.64 0.43 1000000
+ 1.00 0.64 0.43 8071429
+ 1.00 0.64 0.43 15142857
+ 1.00 0.64 0.43 22214286
+ 1.00 0.64 0.43 29285714
+ 1.00 0.64 0.43 36357143
+ 1.00 0.64 0.43 43428571
+ 1.00 0.64 0.43 50500000
+ 1.00 0.64 0.43 57571429
+ 1.00 0.64 0.43 64642857
+ 1.00 0.64 0.43 71714286
+ 1.00 0.64 0.43 78785714
+ 1.00 0.64 0.43 85857143
+ 1.00 0.64 0.43 92928571
+ 1.00 0.64 0.43 100000000
+ 1.00 0.64 0.50 1000000
+ 1.00 0.64 0.50 8071429
+ 1.00 0.64 0.50 15142857
+ 1.00 0.64 0.50 22214286
+ 1.00 0.64 0.50 29285714
+ 1.00 0.64 0.50 36357143
+ 1.00 0.64 0.50 43428571
+ 1.00 0.64 0.50 50500000
+ 1.00 0.64 0.50 57571429
+ 1.00 0.64 0.50 64642857
+ 1.00 0.64 0.50 71714286
+ 1.00 0.64 0.50 78785714
+ 1.00 0.64 0.50 85857143
+ 1.00 0.64 0.50 92928571
+ 1.00 0.64 0.50 100000000
+ 1.00 0.64 0.57 1000000
+ 1.00 0.64 0.57 8071429
+ 1.00 0.64 0.57 15142857
+ 1.00 0.64 0.57 22214286
+ 1.00 0.64 0.57 29285714
+ 1.00 0.64 0.57 36357143
+ 1.00 0.64 0.57 43428571
+ 1.00 0.64 0.57 50500000
+ 1.00 0.64 0.57 57571429
+ 1.00 0.64 0.57 64642857
+ 1.00 0.64 0.57 71714286
+ 1.00 0.64 0.57 78785714
+ 1.00 0.64 0.57 85857143
+ 1.00 0.64 0.57 92928571
+ 1.00 0.64 0.57 100000000
+ 1.00 0.64 0.64 1000000
+ 1.00 0.64 0.64 8071429
+ 1.00 0.64 0.64 15142857
+ 1.00 0.64 0.64 22214286
+ 1.00 0.64 0.64 29285714
+ 1.00 0.64 0.64 36357143
+ 1.00 0.64 0.64 43428571
+ 1.00 0.64 0.64 50500000
+ 1.00 0.64 0.64 57571429
+ 1.00 0.64 0.64 64642857
+ 1.00 0.64 0.64 71714286
+ 1.00 0.64 0.64 78785714
+ 1.00 0.64 0.64 85857143
+ 1.00 0.64 0.64 92928571
+ 1.00 0.64 0.64 100000000
+ 1.00 0.64 0.71 1000000
+ 1.00 0.64 0.71 8071429
+ 1.00 0.64 0.71 15142857
+ 1.00 0.64 0.71 22214286
+ 1.00 0.64 0.71 29285714
+ 1.00 0.64 0.71 36357143
+ 1.00 0.64 0.71 43428571
+ 1.00 0.64 0.71 50500000
+ 1.00 0.64 0.71 57571429
+ 1.00 0.64 0.71 64642857
+ 1.00 0.64 0.71 71714286
+ 1.00 0.64 0.71 78785714
+ 1.00 0.64 0.71 85857143
+ 1.00 0.64 0.71 92928571
+ 1.00 0.64 0.71 100000000
+ 1.00 0.64 0.79 1000000
+ 1.00 0.64 0.79 8071429
+ 1.00 0.64 0.79 15142857
+ 1.00 0.64 0.79 22214286
+ 1.00 0.64 0.79 29285714
+ 1.00 0.64 0.79 36357143
+ 1.00 0.64 0.79 43428571
+ 1.00 0.64 0.79 50500000
+ 1.00 0.64 0.79 57571429
+ 1.00 0.64 0.79 64642857
+ 1.00 0.64 0.79 71714286
+ 1.00 0.64 0.79 78785714
+ 1.00 0.64 0.79 85857143
+ 1.00 0.64 0.79 92928571
+ 1.00 0.64 0.79 100000000
+ 1.00 0.64 0.86 1000000
+ 1.00 0.64 0.86 8071429
+ 1.00 0.64 0.86 15142857
+ 1.00 0.64 0.86 22214286
+ 1.00 0.64 0.86 29285714
+ 1.00 0.64 0.86 36357143
+ 1.00 0.64 0.86 43428571
+ 1.00 0.64 0.86 50500000
+ 1.00 0.64 0.86 57571429
+ 1.00 0.64 0.86 64642857
+ 1.00 0.64 0.86 71714286
+ 1.00 0.64 0.86 78785714
+ 1.00 0.64 0.86 85857143
+ 1.00 0.64 0.86 92928571
+ 1.00 0.64 0.86 100000000
+ 1.00 0.64 0.93 1000000
+ 1.00 0.64 0.93 8071429
+ 1.00 0.64 0.93 15142857
+ 1.00 0.64 0.93 22214286
+ 1.00 0.64 0.93 29285714
+ 1.00 0.64 0.93 36357143
+ 1.00 0.64 0.93 43428571
+ 1.00 0.64 0.93 50500000
+ 1.00 0.64 0.93 57571429
+ 1.00 0.64 0.93 64642857
+ 1.00 0.64 0.93 71714286
+ 1.00 0.64 0.93 78785714
+ 1.00 0.64 0.93 85857143
+ 1.00 0.64 0.93 92928571
+ 1.00 0.64 0.93 100000000
+ 1.00 0.64 1.00 1000000
+ 1.00 0.64 1.00 8071429
+ 1.00 0.64 1.00 15142857
+ 1.00 0.64 1.00 22214286
+ 1.00 0.64 1.00 29285714
+ 1.00 0.64 1.00 36357143
+ 1.00 0.64 1.00 43428571
+ 1.00 0.64 1.00 50500000
+ 1.00 0.64 1.00 57571429
+ 1.00 0.64 1.00 64642857
+ 1.00 0.64 1.00 71714286
+ 1.00 0.64 1.00 78785714
+ 1.00 0.64 1.00 85857143
+ 1.00 0.64 1.00 92928571
+ 1.00 0.64 1.00 100000000
+ 1.00 0.71 0.00 1000000
+ 1.00 0.71 0.00 8071429
+ 1.00 0.71 0.00 15142857
+ 1.00 0.71 0.00 22214286
+ 1.00 0.71 0.00 29285714
+ 1.00 0.71 0.00 36357143
+ 1.00 0.71 0.00 43428571
+ 1.00 0.71 0.00 50500000
+ 1.00 0.71 0.00 57571429
+ 1.00 0.71 0.00 64642857
+ 1.00 0.71 0.00 71714286
+ 1.00 0.71 0.00 78785714
+ 1.00 0.71 0.00 85857143
+ 1.00 0.71 0.00 92928571
+ 1.00 0.71 0.00 100000000
+ 1.00 0.71 0.07 1000000
+ 1.00 0.71 0.07 8071429
+ 1.00 0.71 0.07 15142857
+ 1.00 0.71 0.07 22214286
+ 1.00 0.71 0.07 29285714
+ 1.00 0.71 0.07 36357143
+ 1.00 0.71 0.07 43428571
+ 1.00 0.71 0.07 50500000
+ 1.00 0.71 0.07 57571429
+ 1.00 0.71 0.07 64642857
+ 1.00 0.71 0.07 71714286
+ 1.00 0.71 0.07 78785714
+ 1.00 0.71 0.07 85857143
+ 1.00 0.71 0.07 92928571
+ 1.00 0.71 0.07 100000000
+ 1.00 0.71 0.14 1000000
+ 1.00 0.71 0.14 8071429
+ 1.00 0.71 0.14 15142857
+ 1.00 0.71 0.14 22214286
+ 1.00 0.71 0.14 29285714
+ 1.00 0.71 0.14 36357143
+ 1.00 0.71 0.14 43428571
+ 1.00 0.71 0.14 50500000
+ 1.00 0.71 0.14 57571429
+ 1.00 0.71 0.14 64642857
+ 1.00 0.71 0.14 71714286
+ 1.00 0.71 0.14 78785714
+ 1.00 0.71 0.14 85857143
+ 1.00 0.71 0.14 92928571
+ 1.00 0.71 0.14 100000000
+ 1.00 0.71 0.21 1000000
+ 1.00 0.71 0.21 8071429
+ 1.00 0.71 0.21 15142857
+ 1.00 0.71 0.21 22214286
+ 1.00 0.71 0.21 29285714
+ 1.00 0.71 0.21 36357143
+ 1.00 0.71 0.21 43428571
+ 1.00 0.71 0.21 50500000
+ 1.00 0.71 0.21 57571429
+ 1.00 0.71 0.21 64642857
+ 1.00 0.71 0.21 71714286
+ 1.00 0.71 0.21 78785714
+ 1.00 0.71 0.21 85857143
+ 1.00 0.71 0.21 92928571
+ 1.00 0.71 0.21 100000000
+ 1.00 0.71 0.29 1000000
+ 1.00 0.71 0.29 8071429
+ 1.00 0.71 0.29 15142857
+ 1.00 0.71 0.29 22214286
+ 1.00 0.71 0.29 29285714
+ 1.00 0.71 0.29 36357143
+ 1.00 0.71 0.29 43428571
+ 1.00 0.71 0.29 50500000
+ 1.00 0.71 0.29 57571429
+ 1.00 0.71 0.29 64642857
+ 1.00 0.71 0.29 71714286
+ 1.00 0.71 0.29 78785714
+ 1.00 0.71 0.29 85857143
+ 1.00 0.71 0.29 92928571
+ 1.00 0.71 0.29 100000000
+ 1.00 0.71 0.36 1000000
+ 1.00 0.71 0.36 8071429
+ 1.00 0.71 0.36 15142857
+ 1.00 0.71 0.36 22214286
+ 1.00 0.71 0.36 29285714
+ 1.00 0.71 0.36 36357143
+ 1.00 0.71 0.36 43428571
+ 1.00 0.71 0.36 50500000
+ 1.00 0.71 0.36 57571429
+ 1.00 0.71 0.36 64642857
+ 1.00 0.71 0.36 71714286
+ 1.00 0.71 0.36 78785714
+ 1.00 0.71 0.36 85857143
+ 1.00 0.71 0.36 92928571
+ 1.00 0.71 0.36 100000000
+ 1.00 0.71 0.43 1000000
+ 1.00 0.71 0.43 8071429
+ 1.00 0.71 0.43 15142857
+ 1.00 0.71 0.43 22214286
+ 1.00 0.71 0.43 29285714
+ 1.00 0.71 0.43 36357143
+ 1.00 0.71 0.43 43428571
+ 1.00 0.71 0.43 50500000
+ 1.00 0.71 0.43 57571429
+ 1.00 0.71 0.43 64642857
+ 1.00 0.71 0.43 71714286
+ 1.00 0.71 0.43 78785714
+ 1.00 0.71 0.43 85857143
+ 1.00 0.71 0.43 92928571
+ 1.00 0.71 0.43 100000000
+ 1.00 0.71 0.50 1000000
+ 1.00 0.71 0.50 8071429
+ 1.00 0.71 0.50 15142857
+ 1.00 0.71 0.50 22214286
+ 1.00 0.71 0.50 29285714
+ 1.00 0.71 0.50 36357143
+ 1.00 0.71 0.50 43428571
+ 1.00 0.71 0.50 50500000
+ 1.00 0.71 0.50 57571429
+ 1.00 0.71 0.50 64642857
+ 1.00 0.71 0.50 71714286
+ 1.00 0.71 0.50 78785714
+ 1.00 0.71 0.50 85857143
+ 1.00 0.71 0.50 92928571
+ 1.00 0.71 0.50 100000000
+ 1.00 0.71 0.57 1000000
+ 1.00 0.71 0.57 8071429
+ 1.00 0.71 0.57 15142857
+ 1.00 0.71 0.57 22214286
+ 1.00 0.71 0.57 29285714
+ 1.00 0.71 0.57 36357143
+ 1.00 0.71 0.57 43428571
+ 1.00 0.71 0.57 50500000
+ 1.00 0.71 0.57 57571429
+ 1.00 0.71 0.57 64642857
+ 1.00 0.71 0.57 71714286
+ 1.00 0.71 0.57 78785714
+ 1.00 0.71 0.57 85857143
+ 1.00 0.71 0.57 92928571
+ 1.00 0.71 0.57 100000000
+ 1.00 0.71 0.64 1000000
+ 1.00 0.71 0.64 8071429
+ 1.00 0.71 0.64 15142857
+ 1.00 0.71 0.64 22214286
+ 1.00 0.71 0.64 29285714
+ 1.00 0.71 0.64 36357143
+ 1.00 0.71 0.64 43428571
+ 1.00 0.71 0.64 50500000
+ 1.00 0.71 0.64 57571429
+ 1.00 0.71 0.64 64642857
+ 1.00 0.71 0.64 71714286
+ 1.00 0.71 0.64 78785714
+ 1.00 0.71 0.64 85857143
+ 1.00 0.71 0.64 92928571
+ 1.00 0.71 0.64 100000000
+ 1.00 0.71 0.71 1000000
+ 1.00 0.71 0.71 8071429
+ 1.00 0.71 0.71 15142857
+ 1.00 0.71 0.71 22214286
+ 1.00 0.71 0.71 29285714
+ 1.00 0.71 0.71 36357143
+ 1.00 0.71 0.71 43428571
+ 1.00 0.71 0.71 50500000
+ 1.00 0.71 0.71 57571429
+ 1.00 0.71 0.71 64642857
+ 1.00 0.71 0.71 71714286
+ 1.00 0.71 0.71 78785714
+ 1.00 0.71 0.71 85857143
+ 1.00 0.71 0.71 92928571
+ 1.00 0.71 0.71 100000000
+ 1.00 0.71 0.79 1000000
+ 1.00 0.71 0.79 8071429
+ 1.00 0.71 0.79 15142857
+ 1.00 0.71 0.79 22214286
+ 1.00 0.71 0.79 29285714
+ 1.00 0.71 0.79 36357143
+ 1.00 0.71 0.79 43428571
+ 1.00 0.71 0.79 50500000
+ 1.00 0.71 0.79 57571429
+ 1.00 0.71 0.79 64642857
+ 1.00 0.71 0.79 71714286
+ 1.00 0.71 0.79 78785714
+ 1.00 0.71 0.79 85857143
+ 1.00 0.71 0.79 92928571
+ 1.00 0.71 0.79 100000000
+ 1.00 0.71 0.86 1000000
+ 1.00 0.71 0.86 8071429
+ 1.00 0.71 0.86 15142857
+ 1.00 0.71 0.86 22214286
+ 1.00 0.71 0.86 29285714
+ 1.00 0.71 0.86 36357143
+ 1.00 0.71 0.86 43428571
+ 1.00 0.71 0.86 50500000
+ 1.00 0.71 0.86 57571429
+ 1.00 0.71 0.86 64642857
+ 1.00 0.71 0.86 71714286
+ 1.00 0.71 0.86 78785714
+ 1.00 0.71 0.86 85857143
+ 1.00 0.71 0.86 92928571
+ 1.00 0.71 0.86 100000000
+ 1.00 0.71 0.93 1000000
+ 1.00 0.71 0.93 8071429
+ 1.00 0.71 0.93 15142857
+ 1.00 0.71 0.93 22214286
+ 1.00 0.71 0.93 29285714
+ 1.00 0.71 0.93 36357143
+ 1.00 0.71 0.93 43428571
+ 1.00 0.71 0.93 50500000
+ 1.00 0.71 0.93 57571429
+ 1.00 0.71 0.93 64642857
+ 1.00 0.71 0.93 71714286
+ 1.00 0.71 0.93 78785714
+ 1.00 0.71 0.93 85857143
+ 1.00 0.71 0.93 92928571
+ 1.00 0.71 0.93 100000000
+ 1.00 0.71 1.00 1000000
+ 1.00 0.71 1.00 8071429
+ 1.00 0.71 1.00 15142857
+ 1.00 0.71 1.00 22214286
+ 1.00 0.71 1.00 29285714
+ 1.00 0.71 1.00 36357143
+ 1.00 0.71 1.00 43428571
+ 1.00 0.71 1.00 50500000
+ 1.00 0.71 1.00 57571429
+ 1.00 0.71 1.00 64642857
+ 1.00 0.71 1.00 71714286
+ 1.00 0.71 1.00 78785714
+ 1.00 0.71 1.00 85857143
+ 1.00 0.71 1.00 92928571
+ 1.00 0.71 1.00 100000000
+ 1.00 0.79 0.00 1000000
+ 1.00 0.79 0.00 8071429
+ 1.00 0.79 0.00 15142857
+ 1.00 0.79 0.00 22214286
+ 1.00 0.79 0.00 29285714
+ 1.00 0.79 0.00 36357143
+ 1.00 0.79 0.00 43428571
+ 1.00 0.79 0.00 50500000
+ 1.00 0.79 0.00 57571429
+ 1.00 0.79 0.00 64642857
+ 1.00 0.79 0.00 71714286
+ 1.00 0.79 0.00 78785714
+ 1.00 0.79 0.00 85857143
+ 1.00 0.79 0.00 92928571
+ 1.00 0.79 0.00 100000000
+ 1.00 0.79 0.07 1000000
+ 1.00 0.79 0.07 8071429
+ 1.00 0.79 0.07 15142857
+ 1.00 0.79 0.07 22214286
+ 1.00 0.79 0.07 29285714
+ 1.00 0.79 0.07 36357143
+ 1.00 0.79 0.07 43428571
+ 1.00 0.79 0.07 50500000
+ 1.00 0.79 0.07 57571429
+ 1.00 0.79 0.07 64642857
+ 1.00 0.79 0.07 71714286
+ 1.00 0.79 0.07 78785714
+ 1.00 0.79 0.07 85857143
+ 1.00 0.79 0.07 92928571
+ 1.00 0.79 0.07 100000000
+ 1.00 0.79 0.14 1000000
+ 1.00 0.79 0.14 8071429
+ 1.00 0.79 0.14 15142857
+ 1.00 0.79 0.14 22214286
+ 1.00 0.79 0.14 29285714
+ 1.00 0.79 0.14 36357143
+ 1.00 0.79 0.14 43428571
+ 1.00 0.79 0.14 50500000
+ 1.00 0.79 0.14 57571429
+ 1.00 0.79 0.14 64642857
+ 1.00 0.79 0.14 71714286
+ 1.00 0.79 0.14 78785714
+ 1.00 0.79 0.14 85857143
+ 1.00 0.79 0.14 92928571
+ 1.00 0.79 0.14 100000000
+ 1.00 0.79 0.21 1000000
+ 1.00 0.79 0.21 8071429
+ 1.00 0.79 0.21 15142857
+ 1.00 0.79 0.21 22214286
+ 1.00 0.79 0.21 29285714
+ 1.00 0.79 0.21 36357143
+ 1.00 0.79 0.21 43428571
+ 1.00 0.79 0.21 50500000
+ 1.00 0.79 0.21 57571429
+ 1.00 0.79 0.21 64642857
+ 1.00 0.79 0.21 71714286
+ 1.00 0.79 0.21 78785714
+ 1.00 0.79 0.21 85857143
+ 1.00 0.79 0.21 92928571
+ 1.00 0.79 0.21 100000000
+ 1.00 0.79 0.29 1000000
+ 1.00 0.79 0.29 8071429
+ 1.00 0.79 0.29 15142857
+ 1.00 0.79 0.29 22214286
+ 1.00 0.79 0.29 29285714
+ 1.00 0.79 0.29 36357143
+ 1.00 0.79 0.29 43428571
+ 1.00 0.79 0.29 50500000
+ 1.00 0.79 0.29 57571429
+ 1.00 0.79 0.29 64642857
+ 1.00 0.79 0.29 71714286
+ 1.00 0.79 0.29 78785714
+ 1.00 0.79 0.29 85857143
+ 1.00 0.79 0.29 92928571
+ 1.00 0.79 0.29 100000000
+ 1.00 0.79 0.36 1000000
+ 1.00 0.79 0.36 8071429
+ 1.00 0.79 0.36 15142857
+ 1.00 0.79 0.36 22214286
+ 1.00 0.79 0.36 29285714
+ 1.00 0.79 0.36 36357143
+ 1.00 0.79 0.36 43428571
+ 1.00 0.79 0.36 50500000
+ 1.00 0.79 0.36 57571429
+ 1.00 0.79 0.36 64642857
+ 1.00 0.79 0.36 71714286
+ 1.00 0.79 0.36 78785714
+ 1.00 0.79 0.36 85857143
+ 1.00 0.79 0.36 92928571
+ 1.00 0.79 0.36 100000000
+ 1.00 0.79 0.43 1000000
+ 1.00 0.79 0.43 8071429
+ 1.00 0.79 0.43 15142857
+ 1.00 0.79 0.43 22214286
+ 1.00 0.79 0.43 29285714
+ 1.00 0.79 0.43 36357143
+ 1.00 0.79 0.43 43428571
+ 1.00 0.79 0.43 50500000
+ 1.00 0.79 0.43 57571429
+ 1.00 0.79 0.43 64642857
+ 1.00 0.79 0.43 71714286
+ 1.00 0.79 0.43 78785714
+ 1.00 0.79 0.43 85857143
+ 1.00 0.79 0.43 92928571
+ 1.00 0.79 0.43 100000000
+ 1.00 0.79 0.50 1000000
+ 1.00 0.79 0.50 8071429
+ 1.00 0.79 0.50 15142857
+ 1.00 0.79 0.50 22214286
+ 1.00 0.79 0.50 29285714
+ 1.00 0.79 0.50 36357143
+ 1.00 0.79 0.50 43428571
+ 1.00 0.79 0.50 50500000
+ 1.00 0.79 0.50 57571429
+ 1.00 0.79 0.50 64642857
+ 1.00 0.79 0.50 71714286
+ 1.00 0.79 0.50 78785714
+ 1.00 0.79 0.50 85857143
+ 1.00 0.79 0.50 92928571
+ 1.00 0.79 0.50 100000000
+ 1.00 0.79 0.57 1000000
+ 1.00 0.79 0.57 8071429
+ 1.00 0.79 0.57 15142857
+ 1.00 0.79 0.57 22214286
+ 1.00 0.79 0.57 29285714
+ 1.00 0.79 0.57 36357143
+ 1.00 0.79 0.57 43428571
+ 1.00 0.79 0.57 50500000
+ 1.00 0.79 0.57 57571429
+ 1.00 0.79 0.57 64642857
+ 1.00 0.79 0.57 71714286
+ 1.00 0.79 0.57 78785714
+ 1.00 0.79 0.57 85857143
+ 1.00 0.79 0.57 92928571
+ 1.00 0.79 0.57 100000000
+ 1.00 0.79 0.64 1000000
+ 1.00 0.79 0.64 8071429
+ 1.00 0.79 0.64 15142857
+ 1.00 0.79 0.64 22214286
+ 1.00 0.79 0.64 29285714
+ 1.00 0.79 0.64 36357143
+ 1.00 0.79 0.64 43428571
+ 1.00 0.79 0.64 50500000
+ 1.00 0.79 0.64 57571429
+ 1.00 0.79 0.64 64642857
+ 1.00 0.79 0.64 71714286
+ 1.00 0.79 0.64 78785714
+ 1.00 0.79 0.64 85857143
+ 1.00 0.79 0.64 92928571
+ 1.00 0.79 0.64 100000000
+ 1.00 0.79 0.71 1000000
+ 1.00 0.79 0.71 8071429
+ 1.00 0.79 0.71 15142857
+ 1.00 0.79 0.71 22214286
+ 1.00 0.79 0.71 29285714
+ 1.00 0.79 0.71 36357143
+ 1.00 0.79 0.71 43428571
+ 1.00 0.79 0.71 50500000
+ 1.00 0.79 0.71 57571429
+ 1.00 0.79 0.71 64642857
+ 1.00 0.79 0.71 71714286
+ 1.00 0.79 0.71 78785714
+ 1.00 0.79 0.71 85857143
+ 1.00 0.79 0.71 92928571
+ 1.00 0.79 0.71 100000000
+ 1.00 0.79 0.79 1000000
+ 1.00 0.79 0.79 8071429
+ 1.00 0.79 0.79 15142857
+ 1.00 0.79 0.79 22214286
+ 1.00 0.79 0.79 29285714
+ 1.00 0.79 0.79 36357143
+ 1.00 0.79 0.79 43428571
+ 1.00 0.79 0.79 50500000
+ 1.00 0.79 0.79 57571429
+ 1.00 0.79 0.79 64642857
+ 1.00 0.79 0.79 71714286
+ 1.00 0.79 0.79 78785714
+ 1.00 0.79 0.79 85857143
+ 1.00 0.79 0.79 92928571
+ 1.00 0.79 0.79 100000000
+ 1.00 0.79 0.86 1000000
+ 1.00 0.79 0.86 8071429
+ 1.00 0.79 0.86 15142857
+ 1.00 0.79 0.86 22214286
+ 1.00 0.79 0.86 29285714
+ 1.00 0.79 0.86 36357143
+ 1.00 0.79 0.86 43428571
+ 1.00 0.79 0.86 50500000
+ 1.00 0.79 0.86 57571429
+ 1.00 0.79 0.86 64642857
+ 1.00 0.79 0.86 71714286
+ 1.00 0.79 0.86 78785714
+ 1.00 0.79 0.86 85857143
+ 1.00 0.79 0.86 92928571
+ 1.00 0.79 0.86 100000000
+ 1.00 0.79 0.93 1000000
+ 1.00 0.79 0.93 8071429
+ 1.00 0.79 0.93 15142857
+ 1.00 0.79 0.93 22214286
+ 1.00 0.79 0.93 29285714
+ 1.00 0.79 0.93 36357143
+ 1.00 0.79 0.93 43428571
+ 1.00 0.79 0.93 50500000
+ 1.00 0.79 0.93 57571429
+ 1.00 0.79 0.93 64642857
+ 1.00 0.79 0.93 71714286
+ 1.00 0.79 0.93 78785714
+ 1.00 0.79 0.93 85857143
+ 1.00 0.79 0.93 92928571
+ 1.00 0.79 0.93 100000000
+ 1.00 0.79 1.00 1000000
+ 1.00 0.79 1.00 8071429
+ 1.00 0.79 1.00 15142857
+ 1.00 0.79 1.00 22214286
+ 1.00 0.79 1.00 29285714
+ 1.00 0.79 1.00 36357143
+ 1.00 0.79 1.00 43428571
+ 1.00 0.79 1.00 50500000
+ 1.00 0.79 1.00 57571429
+ 1.00 0.79 1.00 64642857
+ 1.00 0.79 1.00 71714286
+ 1.00 0.79 1.00 78785714
+ 1.00 0.79 1.00 85857143
+ 1.00 0.79 1.00 92928571
+ 1.00 0.79 1.00 100000000
+ 1.00 0.86 0.00 1000000
+ 1.00 0.86 0.00 8071429
+ 1.00 0.86 0.00 15142857
+ 1.00 0.86 0.00 22214286
+ 1.00 0.86 0.00 29285714
+ 1.00 0.86 0.00 36357143
+ 1.00 0.86 0.00 43428571
+ 1.00 0.86 0.00 50500000
+ 1.00 0.86 0.00 57571429
+ 1.00 0.86 0.00 64642857
+ 1.00 0.86 0.00 71714286
+ 1.00 0.86 0.00 78785714
+ 1.00 0.86 0.00 85857143
+ 1.00 0.86 0.00 92928571
+ 1.00 0.86 0.00 100000000
+ 1.00 0.86 0.07 1000000
+ 1.00 0.86 0.07 8071429
+ 1.00 0.86 0.07 15142857
+ 1.00 0.86 0.07 22214286
+ 1.00 0.86 0.07 29285714
+ 1.00 0.86 0.07 36357143
+ 1.00 0.86 0.07 43428571
+ 1.00 0.86 0.07 50500000
+ 1.00 0.86 0.07 57571429
+ 1.00 0.86 0.07 64642857
+ 1.00 0.86 0.07 71714286
+ 1.00 0.86 0.07 78785714
+ 1.00 0.86 0.07 85857143
+ 1.00 0.86 0.07 92928571
+ 1.00 0.86 0.07 100000000
+ 1.00 0.86 0.14 1000000
+ 1.00 0.86 0.14 8071429
+ 1.00 0.86 0.14 15142857
+ 1.00 0.86 0.14 22214286
+ 1.00 0.86 0.14 29285714
+ 1.00 0.86 0.14 36357143
+ 1.00 0.86 0.14 43428571
+ 1.00 0.86 0.14 50500000
+ 1.00 0.86 0.14 57571429
+ 1.00 0.86 0.14 64642857
+ 1.00 0.86 0.14 71714286
+ 1.00 0.86 0.14 78785714
+ 1.00 0.86 0.14 85857143
+ 1.00 0.86 0.14 92928571
+ 1.00 0.86 0.14 100000000
+ 1.00 0.86 0.21 1000000
+ 1.00 0.86 0.21 8071429
+ 1.00 0.86 0.21 15142857
+ 1.00 0.86 0.21 22214286
+ 1.00 0.86 0.21 29285714
+ 1.00 0.86 0.21 36357143
+ 1.00 0.86 0.21 43428571
+ 1.00 0.86 0.21 50500000
+ 1.00 0.86 0.21 57571429
+ 1.00 0.86 0.21 64642857
+ 1.00 0.86 0.21 71714286
+ 1.00 0.86 0.21 78785714
+ 1.00 0.86 0.21 85857143
+ 1.00 0.86 0.21 92928571
+ 1.00 0.86 0.21 100000000
+ 1.00 0.86 0.29 1000000
+ 1.00 0.86 0.29 8071429
+ 1.00 0.86 0.29 15142857
+ 1.00 0.86 0.29 22214286
+ 1.00 0.86 0.29 29285714
+ 1.00 0.86 0.29 36357143
+ 1.00 0.86 0.29 43428571
+ 1.00 0.86 0.29 50500000
+ 1.00 0.86 0.29 57571429
+ 1.00 0.86 0.29 64642857
+ 1.00 0.86 0.29 71714286
+ 1.00 0.86 0.29 78785714
+ 1.00 0.86 0.29 85857143
+ 1.00 0.86 0.29 92928571
+ 1.00 0.86 0.29 100000000
+ 1.00 0.86 0.36 1000000
+ 1.00 0.86 0.36 8071429
+ 1.00 0.86 0.36 15142857
+ 1.00 0.86 0.36 22214286
+ 1.00 0.86 0.36 29285714
+ 1.00 0.86 0.36 36357143
+ 1.00 0.86 0.36 43428571
+ 1.00 0.86 0.36 50500000
+ 1.00 0.86 0.36 57571429
+ 1.00 0.86 0.36 64642857
+ 1.00 0.86 0.36 71714286
+ 1.00 0.86 0.36 78785714
+ 1.00 0.86 0.36 85857143
+ 1.00 0.86 0.36 92928571
+ 1.00 0.86 0.36 100000000
+ 1.00 0.86 0.43 1000000
+ 1.00 0.86 0.43 8071429
+ 1.00 0.86 0.43 15142857
+ 1.00 0.86 0.43 22214286
+ 1.00 0.86 0.43 29285714
+ 1.00 0.86 0.43 36357143
+ 1.00 0.86 0.43 43428571
+ 1.00 0.86 0.43 50500000
+ 1.00 0.86 0.43 57571429
+ 1.00 0.86 0.43 64642857
+ 1.00 0.86 0.43 71714286
+ 1.00 0.86 0.43 78785714
+ 1.00 0.86 0.43 85857143
+ 1.00 0.86 0.43 92928571
+ 1.00 0.86 0.43 100000000
+ 1.00 0.86 0.50 1000000
+ 1.00 0.86 0.50 8071429
+ 1.00 0.86 0.50 15142857
+ 1.00 0.86 0.50 22214286
+ 1.00 0.86 0.50 29285714
+ 1.00 0.86 0.50 36357143
+ 1.00 0.86 0.50 43428571
+ 1.00 0.86 0.50 50500000
+ 1.00 0.86 0.50 57571429
+ 1.00 0.86 0.50 64642857
+ 1.00 0.86 0.50 71714286
+ 1.00 0.86 0.50 78785714
+ 1.00 0.86 0.50 85857143
+ 1.00 0.86 0.50 92928571
+ 1.00 0.86 0.50 100000000
+ 1.00 0.86 0.57 1000000
+ 1.00 0.86 0.57 8071429
+ 1.00 0.86 0.57 15142857
+ 1.00 0.86 0.57 22214286
+ 1.00 0.86 0.57 29285714
+ 1.00 0.86 0.57 36357143
+ 1.00 0.86 0.57 43428571
+ 1.00 0.86 0.57 50500000
+ 1.00 0.86 0.57 57571429
+ 1.00 0.86 0.57 64642857
+ 1.00 0.86 0.57 71714286
+ 1.00 0.86 0.57 78785714
+ 1.00 0.86 0.57 85857143
+ 1.00 0.86 0.57 92928571
+ 1.00 0.86 0.57 100000000
+ 1.00 0.86 0.64 1000000
+ 1.00 0.86 0.64 8071429
+ 1.00 0.86 0.64 15142857
+ 1.00 0.86 0.64 22214286
+ 1.00 0.86 0.64 29285714
+ 1.00 0.86 0.64 36357143
+ 1.00 0.86 0.64 43428571
+ 1.00 0.86 0.64 50500000
+ 1.00 0.86 0.64 57571429
+ 1.00 0.86 0.64 64642857
+ 1.00 0.86 0.64 71714286
+ 1.00 0.86 0.64 78785714
+ 1.00 0.86 0.64 85857143
+ 1.00 0.86 0.64 92928571
+ 1.00 0.86 0.64 100000000
+ 1.00 0.86 0.71 1000000
+ 1.00 0.86 0.71 8071429
+ 1.00 0.86 0.71 15142857
+ 1.00 0.86 0.71 22214286
+ 1.00 0.86 0.71 29285714
+ 1.00 0.86 0.71 36357143
+ 1.00 0.86 0.71 43428571
+ 1.00 0.86 0.71 50500000
+ 1.00 0.86 0.71 57571429
+ 1.00 0.86 0.71 64642857
+ 1.00 0.86 0.71 71714286
+ 1.00 0.86 0.71 78785714
+ 1.00 0.86 0.71 85857143
+ 1.00 0.86 0.71 92928571
+ 1.00 0.86 0.71 100000000
+ 1.00 0.86 0.79 1000000
+ 1.00 0.86 0.79 8071429
+ 1.00 0.86 0.79 15142857
+ 1.00 0.86 0.79 22214286
+ 1.00 0.86 0.79 29285714
+ 1.00 0.86 0.79 36357143
+ 1.00 0.86 0.79 43428571
+ 1.00 0.86 0.79 50500000
+ 1.00 0.86 0.79 57571429
+ 1.00 0.86 0.79 64642857
+ 1.00 0.86 0.79 71714286
+ 1.00 0.86 0.79 78785714
+ 1.00 0.86 0.79 85857143
+ 1.00 0.86 0.79 92928571
+ 1.00 0.86 0.79 100000000
+ 1.00 0.86 0.86 1000000
+ 1.00 0.86 0.86 8071429
+ 1.00 0.86 0.86 15142857
+ 1.00 0.86 0.86 22214286
+ 1.00 0.86 0.86 29285714
+ 1.00 0.86 0.86 36357143
+ 1.00 0.86 0.86 43428571
+ 1.00 0.86 0.86 50500000
+ 1.00 0.86 0.86 57571429
+ 1.00 0.86 0.86 64642857
+ 1.00 0.86 0.86 71714286
+ 1.00 0.86 0.86 78785714
+ 1.00 0.86 0.86 85857143
+ 1.00 0.86 0.86 92928571
+ 1.00 0.86 0.86 100000000
+ 1.00 0.86 0.93 1000000
+ 1.00 0.86 0.93 8071429
+ 1.00 0.86 0.93 15142857
+ 1.00 0.86 0.93 22214286
+ 1.00 0.86 0.93 29285714
+ 1.00 0.86 0.93 36357143
+ 1.00 0.86 0.93 43428571
+ 1.00 0.86 0.93 50500000
+ 1.00 0.86 0.93 57571429
+ 1.00 0.86 0.93 64642857
+ 1.00 0.86 0.93 71714286
+ 1.00 0.86 0.93 78785714
+ 1.00 0.86 0.93 85857143
+ 1.00 0.86 0.93 92928571
+ 1.00 0.86 0.93 100000000
+ 1.00 0.86 1.00 1000000
+ 1.00 0.86 1.00 8071429
+ 1.00 0.86 1.00 15142857
+ 1.00 0.86 1.00 22214286
+ 1.00 0.86 1.00 29285714
+ 1.00 0.86 1.00 36357143
+ 1.00 0.86 1.00 43428571
+ 1.00 0.86 1.00 50500000
+ 1.00 0.86 1.00 57571429
+ 1.00 0.86 1.00 64642857
+ 1.00 0.86 1.00 71714286
+ 1.00 0.86 1.00 78785714
+ 1.00 0.86 1.00 85857143
+ 1.00 0.86 1.00 92928571
+ 1.00 0.86 1.00 100000000
+ 1.00 0.93 0.00 1000000
+ 1.00 0.93 0.00 8071429
+ 1.00 0.93 0.00 15142857
+ 1.00 0.93 0.00 22214286
+ 1.00 0.93 0.00 29285714
+ 1.00 0.93 0.00 36357143
+ 1.00 0.93 0.00 43428571
+ 1.00 0.93 0.00 50500000
+ 1.00 0.93 0.00 57571429
+ 1.00 0.93 0.00 64642857
+ 1.00 0.93 0.00 71714286
+ 1.00 0.93 0.00 78785714
+ 1.00 0.93 0.00 85857143
+ 1.00 0.93 0.00 92928571
+ 1.00 0.93 0.00 100000000
+ 1.00 0.93 0.07 1000000
+ 1.00 0.93 0.07 8071429
+ 1.00 0.93 0.07 15142857
+ 1.00 0.93 0.07 22214286
+ 1.00 0.93 0.07 29285714
+ 1.00 0.93 0.07 36357143
+ 1.00 0.93 0.07 43428571
+ 1.00 0.93 0.07 50500000
+ 1.00 0.93 0.07 57571429
+ 1.00 0.93 0.07 64642857
+ 1.00 0.93 0.07 71714286
+ 1.00 0.93 0.07 78785714
+ 1.00 0.93 0.07 85857143
+ 1.00 0.93 0.07 92928571
+ 1.00 0.93 0.07 100000000
+ 1.00 0.93 0.14 1000000
+ 1.00 0.93 0.14 8071429
+ 1.00 0.93 0.14 15142857
+ 1.00 0.93 0.14 22214286
+ 1.00 0.93 0.14 29285714
+ 1.00 0.93 0.14 36357143
+ 1.00 0.93 0.14 43428571
+ 1.00 0.93 0.14 50500000
+ 1.00 0.93 0.14 57571429
+ 1.00 0.93 0.14 64642857
+ 1.00 0.93 0.14 71714286
+ 1.00 0.93 0.14 78785714
+ 1.00 0.93 0.14 85857143
+ 1.00 0.93 0.14 92928571
+ 1.00 0.93 0.14 100000000
+ 1.00 0.93 0.21 1000000
+ 1.00 0.93 0.21 8071429
+ 1.00 0.93 0.21 15142857
+ 1.00 0.93 0.21 22214286
+ 1.00 0.93 0.21 29285714
+ 1.00 0.93 0.21 36357143
+ 1.00 0.93 0.21 43428571
+ 1.00 0.93 0.21 50500000
+ 1.00 0.93 0.21 57571429
+ 1.00 0.93 0.21 64642857
+ 1.00 0.93 0.21 71714286
+ 1.00 0.93 0.21 78785714
+ 1.00 0.93 0.21 85857143
+ 1.00 0.93 0.21 92928571
+ 1.00 0.93 0.21 100000000
+ 1.00 0.93 0.29 1000000
+ 1.00 0.93 0.29 8071429
+ 1.00 0.93 0.29 15142857
+ 1.00 0.93 0.29 22214286
+ 1.00 0.93 0.29 29285714
+ 1.00 0.93 0.29 36357143
+ 1.00 0.93 0.29 43428571
+ 1.00 0.93 0.29 50500000
+ 1.00 0.93 0.29 57571429
+ 1.00 0.93 0.29 64642857
+ 1.00 0.93 0.29 71714286
+ 1.00 0.93 0.29 78785714
+ 1.00 0.93 0.29 85857143
+ 1.00 0.93 0.29 92928571
+ 1.00 0.93 0.29 100000000
+ 1.00 0.93 0.36 1000000
+ 1.00 0.93 0.36 8071429
+ 1.00 0.93 0.36 15142857
+ 1.00 0.93 0.36 22214286
+ 1.00 0.93 0.36 29285714
+ 1.00 0.93 0.36 36357143
+ 1.00 0.93 0.36 43428571
+ 1.00 0.93 0.36 50500000
+ 1.00 0.93 0.36 57571429
+ 1.00 0.93 0.36 64642857
+ 1.00 0.93 0.36 71714286
+ 1.00 0.93 0.36 78785714
+ 1.00 0.93 0.36 85857143
+ 1.00 0.93 0.36 92928571
+ 1.00 0.93 0.36 100000000
+ 1.00 0.93 0.43 1000000
+ 1.00 0.93 0.43 8071429
+ 1.00 0.93 0.43 15142857
+ 1.00 0.93 0.43 22214286
+ 1.00 0.93 0.43 29285714
+ 1.00 0.93 0.43 36357143
+ 1.00 0.93 0.43 43428571
+ 1.00 0.93 0.43 50500000
+ 1.00 0.93 0.43 57571429
+ 1.00 0.93 0.43 64642857
+ 1.00 0.93 0.43 71714286
+ 1.00 0.93 0.43 78785714
+ 1.00 0.93 0.43 85857143
+ 1.00 0.93 0.43 92928571
+ 1.00 0.93 0.43 100000000
+ 1.00 0.93 0.50 1000000
+ 1.00 0.93 0.50 8071429
+ 1.00 0.93 0.50 15142857
+ 1.00 0.93 0.50 22214286
+ 1.00 0.93 0.50 29285714
+ 1.00 0.93 0.50 36357143
+ 1.00 0.93 0.50 43428571
+ 1.00 0.93 0.50 50500000
+ 1.00 0.93 0.50 57571429
+ 1.00 0.93 0.50 64642857
+ 1.00 0.93 0.50 71714286
+ 1.00 0.93 0.50 78785714
+ 1.00 0.93 0.50 85857143
+ 1.00 0.93 0.50 92928571
+ 1.00 0.93 0.50 100000000
+ 1.00 0.93 0.57 1000000
+ 1.00 0.93 0.57 8071429
+ 1.00 0.93 0.57 15142857
+ 1.00 0.93 0.57 22214286
+ 1.00 0.93 0.57 29285714
+ 1.00 0.93 0.57 36357143
+ 1.00 0.93 0.57 43428571
+ 1.00 0.93 0.57 50500000
+ 1.00 0.93 0.57 57571429
+ 1.00 0.93 0.57 64642857
+ 1.00 0.93 0.57 71714286
+ 1.00 0.93 0.57 78785714
+ 1.00 0.93 0.57 85857143
+ 1.00 0.93 0.57 92928571
+ 1.00 0.93 0.57 100000000
+ 1.00 0.93 0.64 1000000
+ 1.00 0.93 0.64 8071429
+ 1.00 0.93 0.64 15142857
+ 1.00 0.93 0.64 22214286
+ 1.00 0.93 0.64 29285714
+ 1.00 0.93 0.64 36357143
+ 1.00 0.93 0.64 43428571
+ 1.00 0.93 0.64 50500000
+ 1.00 0.93 0.64 57571429
+ 1.00 0.93 0.64 64642857
+ 1.00 0.93 0.64 71714286
+ 1.00 0.93 0.64 78785714
+ 1.00 0.93 0.64 85857143
+ 1.00 0.93 0.64 92928571
+ 1.00 0.93 0.64 100000000
+ 1.00 0.93 0.71 1000000
+ 1.00 0.93 0.71 8071429
+ 1.00 0.93 0.71 15142857
+ 1.00 0.93 0.71 22214286
+ 1.00 0.93 0.71 29285714
+ 1.00 0.93 0.71 36357143
+ 1.00 0.93 0.71 43428571
+ 1.00 0.93 0.71 50500000
+ 1.00 0.93 0.71 57571429
+ 1.00 0.93 0.71 64642857
+ 1.00 0.93 0.71 71714286
+ 1.00 0.93 0.71 78785714
+ 1.00 0.93 0.71 85857143
+ 1.00 0.93 0.71 92928571
+ 1.00 0.93 0.71 100000000
+ 1.00 0.93 0.79 1000000
+ 1.00 0.93 0.79 8071429
+ 1.00 0.93 0.79 15142857
+ 1.00 0.93 0.79 22214286
+ 1.00 0.93 0.79 29285714
+ 1.00 0.93 0.79 36357143
+ 1.00 0.93 0.79 43428571
+ 1.00 0.93 0.79 50500000
+ 1.00 0.93 0.79 57571429
+ 1.00 0.93 0.79 64642857
+ 1.00 0.93 0.79 71714286
+ 1.00 0.93 0.79 78785714
+ 1.00 0.93 0.79 85857143
+ 1.00 0.93 0.79 92928571
+ 1.00 0.93 0.79 100000000
+ 1.00 0.93 0.86 1000000
+ 1.00 0.93 0.86 8071429
+ 1.00 0.93 0.86 15142857
+ 1.00 0.93 0.86 22214286
+ 1.00 0.93 0.86 29285714
+ 1.00 0.93 0.86 36357143
+ 1.00 0.93 0.86 43428571
+ 1.00 0.93 0.86 50500000
+ 1.00 0.93 0.86 57571429
+ 1.00 0.93 0.86 64642857
+ 1.00 0.93 0.86 71714286
+ 1.00 0.93 0.86 78785714
+ 1.00 0.93 0.86 85857143
+ 1.00 0.93 0.86 92928571
+ 1.00 0.93 0.86 100000000
+ 1.00 0.93 0.93 1000000
+ 1.00 0.93 0.93 8071429
+ 1.00 0.93 0.93 15142857
+ 1.00 0.93 0.93 22214286
+ 1.00 0.93 0.93 29285714
+ 1.00 0.93 0.93 36357143
+ 1.00 0.93 0.93 43428571
+ 1.00 0.93 0.93 50500000
+ 1.00 0.93 0.93 57571429
+ 1.00 0.93 0.93 64642857
+ 1.00 0.93 0.93 71714286
+ 1.00 0.93 0.93 78785714
+ 1.00 0.93 0.93 85857143
+ 1.00 0.93 0.93 92928571
+ 1.00 0.93 0.93 100000000
+ 1.00 0.93 1.00 1000000
+ 1.00 0.93 1.00 8071429
+ 1.00 0.93 1.00 15142857
+ 1.00 0.93 1.00 22214286
+ 1.00 0.93 1.00 29285714
+ 1.00 0.93 1.00 36357143
+ 1.00 0.93 1.00 43428571
+ 1.00 0.93 1.00 50500000
+ 1.00 0.93 1.00 57571429
+ 1.00 0.93 1.00 64642857
+ 1.00 0.93 1.00 71714286
+ 1.00 0.93 1.00 78785714
+ 1.00 0.93 1.00 85857143
+ 1.00 0.93 1.00 92928571
+ 1.00 0.93 1.00 100000000
+ 1.00 1.00 0.00 1000000
+ 1.00 1.00 0.00 8071429
+ 1.00 1.00 0.00 15142857
+ 1.00 1.00 0.00 22214286
+ 1.00 1.00 0.00 29285714
+ 1.00 1.00 0.00 36357143
+ 1.00 1.00 0.00 43428571
+ 1.00 1.00 0.00 50500000
+ 1.00 1.00 0.00 57571429
+ 1.00 1.00 0.00 64642857
+ 1.00 1.00 0.00 71714286
+ 1.00 1.00 0.00 78785714
+ 1.00 1.00 0.00 85857143
+ 1.00 1.00 0.00 92928571
+ 1.00 1.00 0.00 100000000
+ 1.00 1.00 0.07 1000000
+ 1.00 1.00 0.07 8071429
+ 1.00 1.00 0.07 15142857
+ 1.00 1.00 0.07 22214286
+ 1.00 1.00 0.07 29285714
+ 1.00 1.00 0.07 36357143
+ 1.00 1.00 0.07 43428571
+ 1.00 1.00 0.07 50500000
+ 1.00 1.00 0.07 57571429
+ 1.00 1.00 0.07 64642857
+ 1.00 1.00 0.07 71714286
+ 1.00 1.00 0.07 78785714
+ 1.00 1.00 0.07 85857143
+ 1.00 1.00 0.07 92928571
+ 1.00 1.00 0.07 100000000
+ 1.00 1.00 0.14 1000000
+ 1.00 1.00 0.14 8071429
+ 1.00 1.00 0.14 15142857
+ 1.00 1.00 0.14 22214286
+ 1.00 1.00 0.14 29285714
+ 1.00 1.00 0.14 36357143
+ 1.00 1.00 0.14 43428571
+ 1.00 1.00 0.14 50500000
+ 1.00 1.00 0.14 57571429
+ 1.00 1.00 0.14 64642857
+ 1.00 1.00 0.14 71714286
+ 1.00 1.00 0.14 78785714
+ 1.00 1.00 0.14 85857143
+ 1.00 1.00 0.14 92928571
+ 1.00 1.00 0.14 100000000
+ 1.00 1.00 0.21 1000000
+ 1.00 1.00 0.21 8071429
+ 1.00 1.00 0.21 15142857
+ 1.00 1.00 0.21 22214286
+ 1.00 1.00 0.21 29285714
+ 1.00 1.00 0.21 36357143
+ 1.00 1.00 0.21 43428571
+ 1.00 1.00 0.21 50500000
+ 1.00 1.00 0.21 57571429
+ 1.00 1.00 0.21 64642857
+ 1.00 1.00 0.21 71714286
+ 1.00 1.00 0.21 78785714
+ 1.00 1.00 0.21 85857143
+ 1.00 1.00 0.21 92928571
+ 1.00 1.00 0.21 100000000
+ 1.00 1.00 0.29 1000000
+ 1.00 1.00 0.29 8071429
+ 1.00 1.00 0.29 15142857
+ 1.00 1.00 0.29 22214286
+ 1.00 1.00 0.29 29285714
+ 1.00 1.00 0.29 36357143
+ 1.00 1.00 0.29 43428571
+ 1.00 1.00 0.29 50500000
+ 1.00 1.00 0.29 57571429
+ 1.00 1.00 0.29 64642857
+ 1.00 1.00 0.29 71714286
+ 1.00 1.00 0.29 78785714
+ 1.00 1.00 0.29 85857143
+ 1.00 1.00 0.29 92928571
+ 1.00 1.00 0.29 100000000
+ 1.00 1.00 0.36 1000000
+ 1.00 1.00 0.36 8071429
+ 1.00 1.00 0.36 15142857
+ 1.00 1.00 0.36 22214286
+ 1.00 1.00 0.36 29285714
+ 1.00 1.00 0.36 36357143
+ 1.00 1.00 0.36 43428571
+ 1.00 1.00 0.36 50500000
+ 1.00 1.00 0.36 57571429
+ 1.00 1.00 0.36 64642857
+ 1.00 1.00 0.36 71714286
+ 1.00 1.00 0.36 78785714
+ 1.00 1.00 0.36 85857143
+ 1.00 1.00 0.36 92928571
+ 1.00 1.00 0.36 100000000
+ 1.00 1.00 0.43 1000000
+ 1.00 1.00 0.43 8071429
+ 1.00 1.00 0.43 15142857
+ 1.00 1.00 0.43 22214286
+ 1.00 1.00 0.43 29285714
+ 1.00 1.00 0.43 36357143
+ 1.00 1.00 0.43 43428571
+ 1.00 1.00 0.43 50500000
+ 1.00 1.00 0.43 57571429
+ 1.00 1.00 0.43 64642857
+ 1.00 1.00 0.43 71714286
+ 1.00 1.00 0.43 78785714
+ 1.00 1.00 0.43 85857143
+ 1.00 1.00 0.43 92928571
+ 1.00 1.00 0.43 100000000
+ 1.00 1.00 0.50 1000000
+ 1.00 1.00 0.50 8071429
+ 1.00 1.00 0.50 15142857
+ 1.00 1.00 0.50 22214286
+ 1.00 1.00 0.50 29285714
+ 1.00 1.00 0.50 36357143
+ 1.00 1.00 0.50 43428571
+ 1.00 1.00 0.50 50500000
+ 1.00 1.00 0.50 57571429
+ 1.00 1.00 0.50 64642857
+ 1.00 1.00 0.50 71714286
+ 1.00 1.00 0.50 78785714
+ 1.00 1.00 0.50 85857143
+ 1.00 1.00 0.50 92928571
+ 1.00 1.00 0.50 100000000
+ 1.00 1.00 0.57 1000000
+ 1.00 1.00 0.57 8071429
+ 1.00 1.00 0.57 15142857
+ 1.00 1.00 0.57 22214286
+ 1.00 1.00 0.57 29285714
+ 1.00 1.00 0.57 36357143
+ 1.00 1.00 0.57 43428571
+ 1.00 1.00 0.57 50500000
+ 1.00 1.00 0.57 57571429
+ 1.00 1.00 0.57 64642857
+ 1.00 1.00 0.57 71714286
+ 1.00 1.00 0.57 78785714
+ 1.00 1.00 0.57 85857143
+ 1.00 1.00 0.57 92928571
+ 1.00 1.00 0.57 100000000
+ 1.00 1.00 0.64 1000000
+ 1.00 1.00 0.64 8071429
+ 1.00 1.00 0.64 15142857
+ 1.00 1.00 0.64 22214286
+ 1.00 1.00 0.64 29285714
+ 1.00 1.00 0.64 36357143
+ 1.00 1.00 0.64 43428571
+ 1.00 1.00 0.64 50500000
+ 1.00 1.00 0.64 57571429
+ 1.00 1.00 0.64 64642857
+ 1.00 1.00 0.64 71714286
+ 1.00 1.00 0.64 78785714
+ 1.00 1.00 0.64 85857143
+ 1.00 1.00 0.64 92928571
+ 1.00 1.00 0.64 100000000
+ 1.00 1.00 0.71 1000000
+ 1.00 1.00 0.71 8071429
+ 1.00 1.00 0.71 15142857
+ 1.00 1.00 0.71 22214286
+ 1.00 1.00 0.71 29285714
+ 1.00 1.00 0.71 36357143
+ 1.00 1.00 0.71 43428571
+ 1.00 1.00 0.71 50500000
+ 1.00 1.00 0.71 57571429
+ 1.00 1.00 0.71 64642857
+ 1.00 1.00 0.71 71714286
+ 1.00 1.00 0.71 78785714
+ 1.00 1.00 0.71 85857143
+ 1.00 1.00 0.71 92928571
+ 1.00 1.00 0.71 100000000
+ 1.00 1.00 0.79 1000000
+ 1.00 1.00 0.79 8071429
+ 1.00 1.00 0.79 15142857
+ 1.00 1.00 0.79 22214286
+ 1.00 1.00 0.79 29285714
+ 1.00 1.00 0.79 36357143
+ 1.00 1.00 0.79 43428571
+ 1.00 1.00 0.79 50500000
+ 1.00 1.00 0.79 57571429
+ 1.00 1.00 0.79 64642857
+ 1.00 1.00 0.79 71714286
+ 1.00 1.00 0.79 78785714
+ 1.00 1.00 0.79 85857143
+ 1.00 1.00 0.79 92928571
+ 1.00 1.00 0.79 100000000
+ 1.00 1.00 0.86 1000000
+ 1.00 1.00 0.86 8071429
+ 1.00 1.00 0.86 15142857
+ 1.00 1.00 0.86 22214286
+ 1.00 1.00 0.86 29285714
+ 1.00 1.00 0.86 36357143
+ 1.00 1.00 0.86 43428571
+ 1.00 1.00 0.86 50500000
+ 1.00 1.00 0.86 57571429
+ 1.00 1.00 0.86 64642857
+ 1.00 1.00 0.86 71714286
+ 1.00 1.00 0.86 78785714
+ 1.00 1.00 0.86 85857143
+ 1.00 1.00 0.86 92928571
+ 1.00 1.00 0.86 100000000
+ 1.00 1.00 0.93 1000000
+ 1.00 1.00 0.93 8071429
+ 1.00 1.00 0.93 15142857
+ 1.00 1.00 0.93 22214286
+ 1.00 1.00 0.93 29285714
+ 1.00 1.00 0.93 36357143
+ 1.00 1.00 0.93 43428571
+ 1.00 1.00 0.93 50500000
+ 1.00 1.00 0.93 57571429
+ 1.00 1.00 0.93 64642857
+ 1.00 1.00 0.93 71714286
+ 1.00 1.00 0.93 78785714
+ 1.00 1.00 0.93 85857143
+ 1.00 1.00 0.93 92928571
+ 1.00 1.00 0.93 100000000
+ 1.00 1.00 1.00 1000000
+ 1.00 1.00 1.00 8071429
+ 1.00 1.00 1.00 15142857
+ 1.00 1.00 1.00 22214286
+ 1.00 1.00 1.00 29285714
+ 1.00 1.00 1.00 36357143
+ 1.00 1.00 1.00 43428571
+ 1.00 1.00 1.00 50500000
+ 1.00 1.00 1.00 57571429
+ 1.00 1.00 1.00 64642857
+ 1.00 1.00 1.00 71714286
+ 1.00 1.00 1.00 78785714
+ 1.00 1.00 1.00 85857143
+ 1.00 1.00 1.00 92928571
+ 1.00 1.00 1.00 100000000
.enddata

*****************************

* PTM Low Power 45nm Metal Gate / High-K / Strained-Si
* nominal Vdd = 1.1V

.model  nmos  nmos  level = 54

+version = 4.0             binunit = 1               paramchk= 1               mobmod  = 0
+capmod  = 2               igcmod  = 1               igbmod  = 1               geomod  = 1
+diomod  = 1               rdsmod  = 0               rbodymod= 1               rgatemod= 1
+permod  = 1               acnqsmod= 0               trnqsmod= 0

+tnom    = 27              toxe    = 1.8e-009        toxp    = 1.5e-009        toxm    = 1.8e-009
+dtox    = 3e-010          epsrox  = 3.9             wint    = 5e-009          lint    = 0
+ll      = 0               wl      = 0               lln     = 1               wln     = 1
+lw      = 0               ww      = 0               lwn     = 1               wwn     = 1
+lwl     = 0               wwl     = 0               xpart   = 0               toxref  = 1.8e-009

+vth0    = 0.62261         k1      = 0.4             k2      = 0               k3      = 0
+k3b     = 0               w0      = 2.5e-006        dvt0    = 1               dvt1    = 2
+dvt2    = 0               dvt0w   = 0               dvt1w   = 0               dvt2w   = 0
+dsub    = 0.1             minv    = 0.05            voffl   = 0               dvtp0   = 1e-010
+dvtp1   = 0.1             lpe0    = 0               lpeb    = 0               xj      = 1.4e-008
+ngate   = 1e+023          ndep    = 3.24e+018       nsd     = 2e+020          phin    = 0
+cdsc    = 0               cdscb   = 0               cdscd   = 0               cit     = 0
+voff    = -0.13           nfactor = 1.6             eta0    = 0.0125          etab    = 0
+vfb     = -0.55           u0      = 0.049           ua      = 6e-010          ub      = 1.2e-018
+uc      = 0               vsat    = 130000          a0      = 1               ags     = 0
+a1      = 0               a2      = 1               b0      = 0               b1      = 0
+keta    = 0.04            dwg     = 0               dwb     = 0               pclm    = 0.02
+pdiblc1 = 0.001           pdiblc2 = 0.001           pdiblcb = -0.005          drout   = 0.5
+pvag    = 1e-020          delta   = 0.01            pscbe1  = 8.14e+008       pscbe2  = 1e-007
+fprout  = 0.2             pdits   = 0.08            pditsd  = 0.23            pditsl  = 2300000
+rsh     = 5               rdsw    = 210             rsw     = 80              rdw     = 80
+rdswmin = 0               rdwmin  = 0               rswmin  = 0               prwg    = 0
+prwb    = 0               wr      = 1               alpha0  = 0.074           alpha1  = 0.005
+beta0   = 30              agidl   = 0.0002          bgidl   = 2.1e+009        cgidl   = 0.0002
+egidl   = 0.8             aigbacc = 0.012           bigbacc = 0.0028          cigbacc = 0.002
+nigbacc = 1               aigbinv = 0.014           bigbinv = 0.004           cigbinv = 0.004
+eigbinv = 1.1             nigbinv = 3               aigc    = 0.015211        bigc    = 0.0027432
+cigc    = 0.002           aigsd   = 0.015211        bigsd   = 0.0027432       cigsd   = 0.002
+nigc    = 1               poxedge = 1               pigcd   = 1               ntox    = 1
+xrcrg1  = 12              xrcrg2  = 5

+cgso    = 1.1e-010        cgdo    = 1.1e-010        cgbo    = 2.56e-011       cgdl    = 2.653e-010
+cgsl    = 2.653e-010      ckappas = 0.03            ckappad = 0.03            acde    = 1
+moin    = 15              noff    = 0.9             voffcv  = 0.02

+kt1     = -0.11           kt1l    = 0               kt2     = 0.022           ute     = -1.5
+ua1     = 4.31e-009       ub1     = 7.61e-018       uc1     = -5.6e-011       prt     = 0
+at      = 33000

+fnoimod = 1               tnoimod = 0

+jss     = 0.0001          jsws    = 1e-011          jswgs   = 1e-010          njs     = 1
+ijthsfwd= 0.01            ijthsrev= 0.001           bvs     = 10              xjbvs   = 1
+jsd     = 0.0001          jswd    = 1e-011          jswgd   = 1e-010          njd     = 1
+ijthdfwd= 0.01            ijthdrev= 0.001           bvd     = 10              xjbvd   = 1
+pbs     = 1               cjs     = 0.0005          mjs     = 0.5             pbsws   = 1
+cjsws   = 5e-010          mjsws   = 0.33            pbswgs  = 1               cjswgs  = 3e-010
+mjswgs  = 0.33            pbd     = 1               cjd     = 0.0005          mjd     = 0.5
+pbswd   = 1               cjswd   = 5e-010          mjswd   = 0.33            pbswgd  = 1
+cjswgd  = 5e-010          mjswgd  = 0.33            tpb     = 0.005           tcj     = 0.001
+tpbsw   = 0.005           tcjsw   = 0.001           tpbswg  = 0.005           tcjswg  = 0.001
+xtis    = 3               xtid    = 3

+dmcg    = 0               dmci    = 0               dmdg    = 0               dmcgt   = 0
+dwj     = 0               xgw     = 0               xgl     = 0

+rshg    = 0.4             gbmin   = 1e-010          rbpb    = 5               rbpd    = 15
+rbps    = 15              rbdb    = 15              rbsb    = 15              ngcon   = 1

.model  pmos  pmos  level = 54

+version = 4.0             binunit = 1               paramchk= 1               mobmod  = 0
+capmod  = 2               igcmod  = 1               igbmod  = 1               geomod  = 1
+diomod  = 1               rdsmod  = 0               rbodymod= 1               rgatemod= 1
+permod  = 1               acnqsmod= 0               trnqsmod= 0

+tnom    = 27              toxe    = 1.82e-009       toxp    = 1.5e-009        toxm    = 1.82e-009
+dtox    = 3.2e-010        epsrox  = 3.9             wint    = 5e-009          lint    = 0
+ll      = 0               wl      = 0               lln     = 1               wln     = 1
+lw      = 0               ww      = 0               lwn     = 1               wwn     = 1
+lwl     = 0               wwl     = 0               xpart   = 0               toxref  = 1.82e-009

+vth0    = -0.587          k1      = 0.4             k2      = -0.01           k3      = 0
+k3b     = 0               w0      = 2.5e-006        dvt0    = 1               dvt1    = 2
+dvt2    = -0.032          dvt0w   = 0               dvt1w   = 0               dvt2w   = 0
+dsub    = 0.1             minv    = 0.05            voffl   = 0               dvtp0   = 1e-011
+dvtp1   = 0.05            lpe0    = 0               lpeb    = 0               xj      = 1.4e-008
+ngate   = 1e+023          ndep    = 2.44e+018       nsd     = 2e+020          phin    = 0
+cdsc    = 0               cdscb   = 0               cdscd   = 0               cit     = 0
+voff    = -0.126          nfactor = 1.8             eta0    = 0.0125          etab    = 0
+vfb     = 0.55            u0      = 0.021           ua      = 2e-009          ub      = 5e-019
+uc      = 0               vsat    = 90000           a0      = 1               ags     = 1e-020
+a1      = 0               a2      = 1               b0      = 0               b1      = 0
+keta    = -0.047          dwg     = 0               dwb     = 0               pclm    = 0.12
+pdiblc1 = 0.001           pdiblc2 = 0.001           pdiblcb = 3.4e-008        drout   = 0.56
+pvag    = 1e-020          delta   = 0.01            pscbe1  = 8.14e+008       pscbe2  = 9.58e-007
+fprout  = 0.2             pdits   = 0.08            pditsd  = 0.23            pditsl  = 2300000
+rsh     = 5               rdsw    = 250             rsw     = 75              rdw     = 75
+rdswmin = 0               rdwmin  = 0               rswmin  = 0               prwg    = 0
+prwb    = 0               wr      = 1               alpha0  = 0.074           alpha1  = 0.005
+beta0   = 30              agidl   = 0.0002          bgidl   = 2.1e+009        cgidl   = 0.0002
+egidl   = 0.8             aigbacc = 0.012           bigbacc = 0.0028          cigbacc = 0.002
+nigbacc = 1               aigbinv = 0.014           bigbinv = 0.004           cigbinv = 0.004
+eigbinv = 1.1             nigbinv = 3               aigc    = 0.0097          bigc    = 0.00125
+cigc    = 0.0008          aigsd   = 0.0097          bigsd   = 0.00125         cigsd   = 0.0008
+nigc    = 1               poxedge = 1               pigcd   = 1               ntox    = 1
+xrcrg1  = 12              xrcrg2  = 5

+cgso    = 1.1e-010        cgdo    = 1.1e-010        cgbo    = 2.56e-011       cgdl    = 2.653e-010
+cgsl    = 2.653e-010      ckappas = 0.03            ckappad = 0.03            acde    = 1
+moin    = 15              noff    = 0.9             voffcv  = 0.02

+kt1     = -0.11           kt1l    = 0               kt2     = 0.022           ute     = -1.5
+ua1     = 4.31e-009       ub1     = 7.61e-018       uc1     = -5.6e-011       prt     = 0
+at      = 33000

+fnoimod = 1               tnoimod = 0

+jss     = 0.0001          jsws    = 1e-011          jswgs   = 1e-010          njs     = 1
+ijthsfwd= 0.01            ijthsrev= 0.001           bvs     = 10              xjbvs   = 1
+jsd     = 0.0001          jswd    = 1e-011          jswgd   = 1e-010          njd     = 1
+ijthdfwd= 0.01            ijthdrev= 0.001           bvd     = 10              xjbvd   = 1
+pbs     = 1               cjs     = 0.0005          mjs     = 0.5             pbsws   = 1
+cjsws   = 5e-010          mjsws   = 0.33            pbswgs  = 1               cjswgs  = 3e-010
+mjswgs  = 0.33            pbd     = 1               cjd     = 0.0005          mjd     = 0.5
+pbswd   = 1               cjswd   = 5e-010          mjswd   = 0.33            pbswgd  = 1
+cjswgd  = 5e-010          mjswgd  = 0.33            tpb     = 0.005           tcj     = 0.001
+tpbsw   = 0.005           tcjsw   = 0.001           tpbswg  = 0.005           tcjswg  = 0.001
+xtis    = 3               xtid    = 3

+dmcg    = 0               dmci    = 0               dmdg    = 0               dmcgt   = 0
+dwj     = 0               xgw     = 0               xgl     = 0

+rshg    = 0.4             gbmin   = 1e-010          rbpb    = 5               rbpd    = 15
+rbps    = 15              rbdb    = 15              rbsb    = 15              ngcon   = 1

.end
