*****************************
* name drain gate source body class
mnmos vd vg vs gnd nmos w=90n l=50n

* name plus minus class
Rmem vs vc R='r'
* Rmem vs vc 1meg

Evd     vd     gnd vol='d'
Evg     vg     gnd vol='g'
Evc     vc     gnd vol='c'

****************************

* sources
* vsvd vd     gnd SIN(0.0, 1.0, 1,    0, 0, 0)
* vsvg vg     gnd SIN(0.0, 1.0, 10,   0, 0, 0)
* vsvs vscale gnd SIN(0.0, 1.0, 100,  0, 0, 0)
* vsvc vc     gnd SIN(0.0, 1.0, 1000, 0, 0, 0)

* vsvd vd     gnd pwl( 0 0 100m 0 100.1m 1 )
* vsvg vg     gnd pwl( 0 0 100m 0 100.1m 1 )
* vsvs vscale gnd pwl( 0 0 100m 0 100.1m 1 )
* vsvc vc     gnd pwl( 0 0 100m 0 100.1m 1 )

* vsvc vc     gnd pwl( 0 0 )

*****************************

.dc data=data1
.option post=1 POST_VERSION=9601 method=BDF
.probe i(Rmem) i(mnmos) r(Rmem)

* .print v(vd)

*****************************

.data data1
+ d g c r
+ -1.00 0.00 0.00 1000000
+ -1.00 0.04 0.00 1000000
+ -1.00 0.08 0.00 1000000
+ -1.00 0.12 0.00 1000000
+ -1.00 0.17 0.00 1000000
+ -1.00 0.21 0.00 1000000
+ -1.00 0.25 0.00 1000000
+ -1.00 0.29 0.00 1000000
+ -1.00 0.33 0.00 1000000
+ -1.00 0.38 0.00 1000000
+ -1.00 0.42 0.00 1000000
+ -1.00 0.46 0.00 1000000
+ -1.00 0.50 0.00 1000000
+ -1.00 0.54 0.00 1000000
+ -1.00 0.58 0.00 1000000
+ -1.00 0.62 0.00 1000000
+ -1.00 0.67 0.00 1000000
+ -1.00 0.71 0.00 1000000
+ -1.00 0.75 0.00 1000000
+ -1.00 0.79 0.00 1000000
+ -1.00 0.83 0.00 1000000
+ -1.00 0.88 0.00 1000000
+ -1.00 0.92 0.00 1000000
+ -1.00 0.96 0.00 1000000
+ -1.00 1.00 0.00 1000000
+ -0.96 0.00 0.00 1000000
+ -0.96 0.04 0.00 1000000
+ -0.96 0.08 0.00 1000000
+ -0.96 0.12 0.00 1000000
+ -0.96 0.17 0.00 1000000
+ -0.96 0.21 0.00 1000000
+ -0.96 0.25 0.00 1000000
+ -0.96 0.29 0.00 1000000
+ -0.96 0.33 0.00 1000000
+ -0.96 0.38 0.00 1000000
+ -0.96 0.42 0.00 1000000
+ -0.96 0.46 0.00 1000000
+ -0.96 0.50 0.00 1000000
+ -0.96 0.54 0.00 1000000
+ -0.96 0.58 0.00 1000000
+ -0.96 0.62 0.00 1000000
+ -0.96 0.67 0.00 1000000
+ -0.96 0.71 0.00 1000000
+ -0.96 0.75 0.00 1000000
+ -0.96 0.79 0.00 1000000
+ -0.96 0.83 0.00 1000000
+ -0.96 0.88 0.00 1000000
+ -0.96 0.92 0.00 1000000
+ -0.96 0.96 0.00 1000000
+ -0.96 1.00 0.00 1000000
+ -0.92 0.00 0.00 1000000
+ -0.92 0.04 0.00 1000000
+ -0.92 0.08 0.00 1000000
+ -0.92 0.12 0.00 1000000
+ -0.92 0.17 0.00 1000000
+ -0.92 0.21 0.00 1000000
+ -0.92 0.25 0.00 1000000
+ -0.92 0.29 0.00 1000000
+ -0.92 0.33 0.00 1000000
+ -0.92 0.38 0.00 1000000
+ -0.92 0.42 0.00 1000000
+ -0.92 0.46 0.00 1000000
+ -0.92 0.50 0.00 1000000
+ -0.92 0.54 0.00 1000000
+ -0.92 0.58 0.00 1000000
+ -0.92 0.62 0.00 1000000
+ -0.92 0.67 0.00 1000000
+ -0.92 0.71 0.00 1000000
+ -0.92 0.75 0.00 1000000
+ -0.92 0.79 0.00 1000000
+ -0.92 0.83 0.00 1000000
+ -0.92 0.88 0.00 1000000
+ -0.92 0.92 0.00 1000000
+ -0.92 0.96 0.00 1000000
+ -0.92 1.00 0.00 1000000
+ -0.88 0.00 0.00 1000000
+ -0.88 0.04 0.00 1000000
+ -0.88 0.08 0.00 1000000
+ -0.88 0.12 0.00 1000000
+ -0.88 0.17 0.00 1000000
+ -0.88 0.21 0.00 1000000
+ -0.88 0.25 0.00 1000000
+ -0.88 0.29 0.00 1000000
+ -0.88 0.33 0.00 1000000
+ -0.88 0.38 0.00 1000000
+ -0.88 0.42 0.00 1000000
+ -0.88 0.46 0.00 1000000
+ -0.88 0.50 0.00 1000000
+ -0.88 0.54 0.00 1000000
+ -0.88 0.58 0.00 1000000
+ -0.88 0.62 0.00 1000000
+ -0.88 0.67 0.00 1000000
+ -0.88 0.71 0.00 1000000
+ -0.88 0.75 0.00 1000000
+ -0.88 0.79 0.00 1000000
+ -0.88 0.83 0.00 1000000
+ -0.88 0.88 0.00 1000000
+ -0.88 0.92 0.00 1000000
+ -0.88 0.96 0.00 1000000
+ -0.88 1.00 0.00 1000000
+ -0.84 0.00 0.00 1000000
+ -0.84 0.04 0.00 1000000
+ -0.84 0.08 0.00 1000000
+ -0.84 0.12 0.00 1000000
+ -0.84 0.17 0.00 1000000
+ -0.84 0.21 0.00 1000000
+ -0.84 0.25 0.00 1000000
+ -0.84 0.29 0.00 1000000
+ -0.84 0.33 0.00 1000000
+ -0.84 0.38 0.00 1000000
+ -0.84 0.42 0.00 1000000
+ -0.84 0.46 0.00 1000000
+ -0.84 0.50 0.00 1000000
+ -0.84 0.54 0.00 1000000
+ -0.84 0.58 0.00 1000000
+ -0.84 0.62 0.00 1000000
+ -0.84 0.67 0.00 1000000
+ -0.84 0.71 0.00 1000000
+ -0.84 0.75 0.00 1000000
+ -0.84 0.79 0.00 1000000
+ -0.84 0.83 0.00 1000000
+ -0.84 0.88 0.00 1000000
+ -0.84 0.92 0.00 1000000
+ -0.84 0.96 0.00 1000000
+ -0.84 1.00 0.00 1000000
+ -0.80 0.00 0.00 1000000
+ -0.80 0.04 0.00 1000000
+ -0.80 0.08 0.00 1000000
+ -0.80 0.12 0.00 1000000
+ -0.80 0.17 0.00 1000000
+ -0.80 0.21 0.00 1000000
+ -0.80 0.25 0.00 1000000
+ -0.80 0.29 0.00 1000000
+ -0.80 0.33 0.00 1000000
+ -0.80 0.38 0.00 1000000
+ -0.80 0.42 0.00 1000000
+ -0.80 0.46 0.00 1000000
+ -0.80 0.50 0.00 1000000
+ -0.80 0.54 0.00 1000000
+ -0.80 0.58 0.00 1000000
+ -0.80 0.62 0.00 1000000
+ -0.80 0.67 0.00 1000000
+ -0.80 0.71 0.00 1000000
+ -0.80 0.75 0.00 1000000
+ -0.80 0.79 0.00 1000000
+ -0.80 0.83 0.00 1000000
+ -0.80 0.88 0.00 1000000
+ -0.80 0.92 0.00 1000000
+ -0.80 0.96 0.00 1000000
+ -0.80 1.00 0.00 1000000
+ -0.76 0.00 0.00 1000000
+ -0.76 0.04 0.00 1000000
+ -0.76 0.08 0.00 1000000
+ -0.76 0.12 0.00 1000000
+ -0.76 0.17 0.00 1000000
+ -0.76 0.21 0.00 1000000
+ -0.76 0.25 0.00 1000000
+ -0.76 0.29 0.00 1000000
+ -0.76 0.33 0.00 1000000
+ -0.76 0.38 0.00 1000000
+ -0.76 0.42 0.00 1000000
+ -0.76 0.46 0.00 1000000
+ -0.76 0.50 0.00 1000000
+ -0.76 0.54 0.00 1000000
+ -0.76 0.58 0.00 1000000
+ -0.76 0.62 0.00 1000000
+ -0.76 0.67 0.00 1000000
+ -0.76 0.71 0.00 1000000
+ -0.76 0.75 0.00 1000000
+ -0.76 0.79 0.00 1000000
+ -0.76 0.83 0.00 1000000
+ -0.76 0.88 0.00 1000000
+ -0.76 0.92 0.00 1000000
+ -0.76 0.96 0.00 1000000
+ -0.76 1.00 0.00 1000000
+ -0.71 0.00 0.00 1000000
+ -0.71 0.04 0.00 1000000
+ -0.71 0.08 0.00 1000000
+ -0.71 0.12 0.00 1000000
+ -0.71 0.17 0.00 1000000
+ -0.71 0.21 0.00 1000000
+ -0.71 0.25 0.00 1000000
+ -0.71 0.29 0.00 1000000
+ -0.71 0.33 0.00 1000000
+ -0.71 0.38 0.00 1000000
+ -0.71 0.42 0.00 1000000
+ -0.71 0.46 0.00 1000000
+ -0.71 0.50 0.00 1000000
+ -0.71 0.54 0.00 1000000
+ -0.71 0.58 0.00 1000000
+ -0.71 0.62 0.00 1000000
+ -0.71 0.67 0.00 1000000
+ -0.71 0.71 0.00 1000000
+ -0.71 0.75 0.00 1000000
+ -0.71 0.79 0.00 1000000
+ -0.71 0.83 0.00 1000000
+ -0.71 0.88 0.00 1000000
+ -0.71 0.92 0.00 1000000
+ -0.71 0.96 0.00 1000000
+ -0.71 1.00 0.00 1000000
+ -0.67 0.00 0.00 1000000
+ -0.67 0.04 0.00 1000000
+ -0.67 0.08 0.00 1000000
+ -0.67 0.12 0.00 1000000
+ -0.67 0.17 0.00 1000000
+ -0.67 0.21 0.00 1000000
+ -0.67 0.25 0.00 1000000
+ -0.67 0.29 0.00 1000000
+ -0.67 0.33 0.00 1000000
+ -0.67 0.38 0.00 1000000
+ -0.67 0.42 0.00 1000000
+ -0.67 0.46 0.00 1000000
+ -0.67 0.50 0.00 1000000
+ -0.67 0.54 0.00 1000000
+ -0.67 0.58 0.00 1000000
+ -0.67 0.62 0.00 1000000
+ -0.67 0.67 0.00 1000000
+ -0.67 0.71 0.00 1000000
+ -0.67 0.75 0.00 1000000
+ -0.67 0.79 0.00 1000000
+ -0.67 0.83 0.00 1000000
+ -0.67 0.88 0.00 1000000
+ -0.67 0.92 0.00 1000000
+ -0.67 0.96 0.00 1000000
+ -0.67 1.00 0.00 1000000
+ -0.63 0.00 0.00 1000000
+ -0.63 0.04 0.00 1000000
+ -0.63 0.08 0.00 1000000
+ -0.63 0.12 0.00 1000000
+ -0.63 0.17 0.00 1000000
+ -0.63 0.21 0.00 1000000
+ -0.63 0.25 0.00 1000000
+ -0.63 0.29 0.00 1000000
+ -0.63 0.33 0.00 1000000
+ -0.63 0.38 0.00 1000000
+ -0.63 0.42 0.00 1000000
+ -0.63 0.46 0.00 1000000
+ -0.63 0.50 0.00 1000000
+ -0.63 0.54 0.00 1000000
+ -0.63 0.58 0.00 1000000
+ -0.63 0.62 0.00 1000000
+ -0.63 0.67 0.00 1000000
+ -0.63 0.71 0.00 1000000
+ -0.63 0.75 0.00 1000000
+ -0.63 0.79 0.00 1000000
+ -0.63 0.83 0.00 1000000
+ -0.63 0.88 0.00 1000000
+ -0.63 0.92 0.00 1000000
+ -0.63 0.96 0.00 1000000
+ -0.63 1.00 0.00 1000000
+ -0.59 0.00 0.00 1000000
+ -0.59 0.04 0.00 1000000
+ -0.59 0.08 0.00 1000000
+ -0.59 0.12 0.00 1000000
+ -0.59 0.17 0.00 1000000
+ -0.59 0.21 0.00 1000000
+ -0.59 0.25 0.00 1000000
+ -0.59 0.29 0.00 1000000
+ -0.59 0.33 0.00 1000000
+ -0.59 0.38 0.00 1000000
+ -0.59 0.42 0.00 1000000
+ -0.59 0.46 0.00 1000000
+ -0.59 0.50 0.00 1000000
+ -0.59 0.54 0.00 1000000
+ -0.59 0.58 0.00 1000000
+ -0.59 0.62 0.00 1000000
+ -0.59 0.67 0.00 1000000
+ -0.59 0.71 0.00 1000000
+ -0.59 0.75 0.00 1000000
+ -0.59 0.79 0.00 1000000
+ -0.59 0.83 0.00 1000000
+ -0.59 0.88 0.00 1000000
+ -0.59 0.92 0.00 1000000
+ -0.59 0.96 0.00 1000000
+ -0.59 1.00 0.00 1000000
+ -0.55 0.00 0.00 1000000
+ -0.55 0.04 0.00 1000000
+ -0.55 0.08 0.00 1000000
+ -0.55 0.12 0.00 1000000
+ -0.55 0.17 0.00 1000000
+ -0.55 0.21 0.00 1000000
+ -0.55 0.25 0.00 1000000
+ -0.55 0.29 0.00 1000000
+ -0.55 0.33 0.00 1000000
+ -0.55 0.38 0.00 1000000
+ -0.55 0.42 0.00 1000000
+ -0.55 0.46 0.00 1000000
+ -0.55 0.50 0.00 1000000
+ -0.55 0.54 0.00 1000000
+ -0.55 0.58 0.00 1000000
+ -0.55 0.62 0.00 1000000
+ -0.55 0.67 0.00 1000000
+ -0.55 0.71 0.00 1000000
+ -0.55 0.75 0.00 1000000
+ -0.55 0.79 0.00 1000000
+ -0.55 0.83 0.00 1000000
+ -0.55 0.88 0.00 1000000
+ -0.55 0.92 0.00 1000000
+ -0.55 0.96 0.00 1000000
+ -0.55 1.00 0.00 1000000
+ -0.51 0.00 0.00 1000000
+ -0.51 0.04 0.00 1000000
+ -0.51 0.08 0.00 1000000
+ -0.51 0.12 0.00 1000000
+ -0.51 0.17 0.00 1000000
+ -0.51 0.21 0.00 1000000
+ -0.51 0.25 0.00 1000000
+ -0.51 0.29 0.00 1000000
+ -0.51 0.33 0.00 1000000
+ -0.51 0.38 0.00 1000000
+ -0.51 0.42 0.00 1000000
+ -0.51 0.46 0.00 1000000
+ -0.51 0.50 0.00 1000000
+ -0.51 0.54 0.00 1000000
+ -0.51 0.58 0.00 1000000
+ -0.51 0.62 0.00 1000000
+ -0.51 0.67 0.00 1000000
+ -0.51 0.71 0.00 1000000
+ -0.51 0.75 0.00 1000000
+ -0.51 0.79 0.00 1000000
+ -0.51 0.83 0.00 1000000
+ -0.51 0.88 0.00 1000000
+ -0.51 0.92 0.00 1000000
+ -0.51 0.96 0.00 1000000
+ -0.51 1.00 0.00 1000000
+ -0.47 0.00 0.00 1000000
+ -0.47 0.04 0.00 1000000
+ -0.47 0.08 0.00 1000000
+ -0.47 0.12 0.00 1000000
+ -0.47 0.17 0.00 1000000
+ -0.47 0.21 0.00 1000000
+ -0.47 0.25 0.00 1000000
+ -0.47 0.29 0.00 1000000
+ -0.47 0.33 0.00 1000000
+ -0.47 0.38 0.00 1000000
+ -0.47 0.42 0.00 1000000
+ -0.47 0.46 0.00 1000000
+ -0.47 0.50 0.00 1000000
+ -0.47 0.54 0.00 1000000
+ -0.47 0.58 0.00 1000000
+ -0.47 0.62 0.00 1000000
+ -0.47 0.67 0.00 1000000
+ -0.47 0.71 0.00 1000000
+ -0.47 0.75 0.00 1000000
+ -0.47 0.79 0.00 1000000
+ -0.47 0.83 0.00 1000000
+ -0.47 0.88 0.00 1000000
+ -0.47 0.92 0.00 1000000
+ -0.47 0.96 0.00 1000000
+ -0.47 1.00 0.00 1000000
+ -0.43 0.00 0.00 1000000
+ -0.43 0.04 0.00 1000000
+ -0.43 0.08 0.00 1000000
+ -0.43 0.12 0.00 1000000
+ -0.43 0.17 0.00 1000000
+ -0.43 0.21 0.00 1000000
+ -0.43 0.25 0.00 1000000
+ -0.43 0.29 0.00 1000000
+ -0.43 0.33 0.00 1000000
+ -0.43 0.38 0.00 1000000
+ -0.43 0.42 0.00 1000000
+ -0.43 0.46 0.00 1000000
+ -0.43 0.50 0.00 1000000
+ -0.43 0.54 0.00 1000000
+ -0.43 0.58 0.00 1000000
+ -0.43 0.62 0.00 1000000
+ -0.43 0.67 0.00 1000000
+ -0.43 0.71 0.00 1000000
+ -0.43 0.75 0.00 1000000
+ -0.43 0.79 0.00 1000000
+ -0.43 0.83 0.00 1000000
+ -0.43 0.88 0.00 1000000
+ -0.43 0.92 0.00 1000000
+ -0.43 0.96 0.00 1000000
+ -0.43 1.00 0.00 1000000
+ -0.39 0.00 0.00 1000000
+ -0.39 0.04 0.00 1000000
+ -0.39 0.08 0.00 1000000
+ -0.39 0.12 0.00 1000000
+ -0.39 0.17 0.00 1000000
+ -0.39 0.21 0.00 1000000
+ -0.39 0.25 0.00 1000000
+ -0.39 0.29 0.00 1000000
+ -0.39 0.33 0.00 1000000
+ -0.39 0.38 0.00 1000000
+ -0.39 0.42 0.00 1000000
+ -0.39 0.46 0.00 1000000
+ -0.39 0.50 0.00 1000000
+ -0.39 0.54 0.00 1000000
+ -0.39 0.58 0.00 1000000
+ -0.39 0.62 0.00 1000000
+ -0.39 0.67 0.00 1000000
+ -0.39 0.71 0.00 1000000
+ -0.39 0.75 0.00 1000000
+ -0.39 0.79 0.00 1000000
+ -0.39 0.83 0.00 1000000
+ -0.39 0.88 0.00 1000000
+ -0.39 0.92 0.00 1000000
+ -0.39 0.96 0.00 1000000
+ -0.39 1.00 0.00 1000000
+ -0.35 0.00 0.00 1000000
+ -0.35 0.04 0.00 1000000
+ -0.35 0.08 0.00 1000000
+ -0.35 0.12 0.00 1000000
+ -0.35 0.17 0.00 1000000
+ -0.35 0.21 0.00 1000000
+ -0.35 0.25 0.00 1000000
+ -0.35 0.29 0.00 1000000
+ -0.35 0.33 0.00 1000000
+ -0.35 0.38 0.00 1000000
+ -0.35 0.42 0.00 1000000
+ -0.35 0.46 0.00 1000000
+ -0.35 0.50 0.00 1000000
+ -0.35 0.54 0.00 1000000
+ -0.35 0.58 0.00 1000000
+ -0.35 0.62 0.00 1000000
+ -0.35 0.67 0.00 1000000
+ -0.35 0.71 0.00 1000000
+ -0.35 0.75 0.00 1000000
+ -0.35 0.79 0.00 1000000
+ -0.35 0.83 0.00 1000000
+ -0.35 0.88 0.00 1000000
+ -0.35 0.92 0.00 1000000
+ -0.35 0.96 0.00 1000000
+ -0.35 1.00 0.00 1000000
+ -0.31 0.00 0.00 1000000
+ -0.31 0.04 0.00 1000000
+ -0.31 0.08 0.00 1000000
+ -0.31 0.12 0.00 1000000
+ -0.31 0.17 0.00 1000000
+ -0.31 0.21 0.00 1000000
+ -0.31 0.25 0.00 1000000
+ -0.31 0.29 0.00 1000000
+ -0.31 0.33 0.00 1000000
+ -0.31 0.38 0.00 1000000
+ -0.31 0.42 0.00 1000000
+ -0.31 0.46 0.00 1000000
+ -0.31 0.50 0.00 1000000
+ -0.31 0.54 0.00 1000000
+ -0.31 0.58 0.00 1000000
+ -0.31 0.62 0.00 1000000
+ -0.31 0.67 0.00 1000000
+ -0.31 0.71 0.00 1000000
+ -0.31 0.75 0.00 1000000
+ -0.31 0.79 0.00 1000000
+ -0.31 0.83 0.00 1000000
+ -0.31 0.88 0.00 1000000
+ -0.31 0.92 0.00 1000000
+ -0.31 0.96 0.00 1000000
+ -0.31 1.00 0.00 1000000
+ -0.27 0.00 0.00 1000000
+ -0.27 0.04 0.00 1000000
+ -0.27 0.08 0.00 1000000
+ -0.27 0.12 0.00 1000000
+ -0.27 0.17 0.00 1000000
+ -0.27 0.21 0.00 1000000
+ -0.27 0.25 0.00 1000000
+ -0.27 0.29 0.00 1000000
+ -0.27 0.33 0.00 1000000
+ -0.27 0.38 0.00 1000000
+ -0.27 0.42 0.00 1000000
+ -0.27 0.46 0.00 1000000
+ -0.27 0.50 0.00 1000000
+ -0.27 0.54 0.00 1000000
+ -0.27 0.58 0.00 1000000
+ -0.27 0.62 0.00 1000000
+ -0.27 0.67 0.00 1000000
+ -0.27 0.71 0.00 1000000
+ -0.27 0.75 0.00 1000000
+ -0.27 0.79 0.00 1000000
+ -0.27 0.83 0.00 1000000
+ -0.27 0.88 0.00 1000000
+ -0.27 0.92 0.00 1000000
+ -0.27 0.96 0.00 1000000
+ -0.27 1.00 0.00 1000000
+ -0.22 0.00 0.00 1000000
+ -0.22 0.04 0.00 1000000
+ -0.22 0.08 0.00 1000000
+ -0.22 0.12 0.00 1000000
+ -0.22 0.17 0.00 1000000
+ -0.22 0.21 0.00 1000000
+ -0.22 0.25 0.00 1000000
+ -0.22 0.29 0.00 1000000
+ -0.22 0.33 0.00 1000000
+ -0.22 0.38 0.00 1000000
+ -0.22 0.42 0.00 1000000
+ -0.22 0.46 0.00 1000000
+ -0.22 0.50 0.00 1000000
+ -0.22 0.54 0.00 1000000
+ -0.22 0.58 0.00 1000000
+ -0.22 0.62 0.00 1000000
+ -0.22 0.67 0.00 1000000
+ -0.22 0.71 0.00 1000000
+ -0.22 0.75 0.00 1000000
+ -0.22 0.79 0.00 1000000
+ -0.22 0.83 0.00 1000000
+ -0.22 0.88 0.00 1000000
+ -0.22 0.92 0.00 1000000
+ -0.22 0.96 0.00 1000000
+ -0.22 1.00 0.00 1000000
+ -0.18 0.00 0.00 1000000
+ -0.18 0.04 0.00 1000000
+ -0.18 0.08 0.00 1000000
+ -0.18 0.12 0.00 1000000
+ -0.18 0.17 0.00 1000000
+ -0.18 0.21 0.00 1000000
+ -0.18 0.25 0.00 1000000
+ -0.18 0.29 0.00 1000000
+ -0.18 0.33 0.00 1000000
+ -0.18 0.38 0.00 1000000
+ -0.18 0.42 0.00 1000000
+ -0.18 0.46 0.00 1000000
+ -0.18 0.50 0.00 1000000
+ -0.18 0.54 0.00 1000000
+ -0.18 0.58 0.00 1000000
+ -0.18 0.62 0.00 1000000
+ -0.18 0.67 0.00 1000000
+ -0.18 0.71 0.00 1000000
+ -0.18 0.75 0.00 1000000
+ -0.18 0.79 0.00 1000000
+ -0.18 0.83 0.00 1000000
+ -0.18 0.88 0.00 1000000
+ -0.18 0.92 0.00 1000000
+ -0.18 0.96 0.00 1000000
+ -0.18 1.00 0.00 1000000
+ -0.14 0.00 0.00 1000000
+ -0.14 0.04 0.00 1000000
+ -0.14 0.08 0.00 1000000
+ -0.14 0.12 0.00 1000000
+ -0.14 0.17 0.00 1000000
+ -0.14 0.21 0.00 1000000
+ -0.14 0.25 0.00 1000000
+ -0.14 0.29 0.00 1000000
+ -0.14 0.33 0.00 1000000
+ -0.14 0.38 0.00 1000000
+ -0.14 0.42 0.00 1000000
+ -0.14 0.46 0.00 1000000
+ -0.14 0.50 0.00 1000000
+ -0.14 0.54 0.00 1000000
+ -0.14 0.58 0.00 1000000
+ -0.14 0.62 0.00 1000000
+ -0.14 0.67 0.00 1000000
+ -0.14 0.71 0.00 1000000
+ -0.14 0.75 0.00 1000000
+ -0.14 0.79 0.00 1000000
+ -0.14 0.83 0.00 1000000
+ -0.14 0.88 0.00 1000000
+ -0.14 0.92 0.00 1000000
+ -0.14 0.96 0.00 1000000
+ -0.14 1.00 0.00 1000000
+ -0.10 0.00 0.00 1000000
+ -0.10 0.04 0.00 1000000
+ -0.10 0.08 0.00 1000000
+ -0.10 0.12 0.00 1000000
+ -0.10 0.17 0.00 1000000
+ -0.10 0.21 0.00 1000000
+ -0.10 0.25 0.00 1000000
+ -0.10 0.29 0.00 1000000
+ -0.10 0.33 0.00 1000000
+ -0.10 0.38 0.00 1000000
+ -0.10 0.42 0.00 1000000
+ -0.10 0.46 0.00 1000000
+ -0.10 0.50 0.00 1000000
+ -0.10 0.54 0.00 1000000
+ -0.10 0.58 0.00 1000000
+ -0.10 0.62 0.00 1000000
+ -0.10 0.67 0.00 1000000
+ -0.10 0.71 0.00 1000000
+ -0.10 0.75 0.00 1000000
+ -0.10 0.79 0.00 1000000
+ -0.10 0.83 0.00 1000000
+ -0.10 0.88 0.00 1000000
+ -0.10 0.92 0.00 1000000
+ -0.10 0.96 0.00 1000000
+ -0.10 1.00 0.00 1000000
+ -0.06 0.00 0.00 1000000
+ -0.06 0.04 0.00 1000000
+ -0.06 0.08 0.00 1000000
+ -0.06 0.12 0.00 1000000
+ -0.06 0.17 0.00 1000000
+ -0.06 0.21 0.00 1000000
+ -0.06 0.25 0.00 1000000
+ -0.06 0.29 0.00 1000000
+ -0.06 0.33 0.00 1000000
+ -0.06 0.38 0.00 1000000
+ -0.06 0.42 0.00 1000000
+ -0.06 0.46 0.00 1000000
+ -0.06 0.50 0.00 1000000
+ -0.06 0.54 0.00 1000000
+ -0.06 0.58 0.00 1000000
+ -0.06 0.62 0.00 1000000
+ -0.06 0.67 0.00 1000000
+ -0.06 0.71 0.00 1000000
+ -0.06 0.75 0.00 1000000
+ -0.06 0.79 0.00 1000000
+ -0.06 0.83 0.00 1000000
+ -0.06 0.88 0.00 1000000
+ -0.06 0.92 0.00 1000000
+ -0.06 0.96 0.00 1000000
+ -0.06 1.00 0.00 1000000
+ -0.02 0.00 0.00 1000000
+ -0.02 0.04 0.00 1000000
+ -0.02 0.08 0.00 1000000
+ -0.02 0.12 0.00 1000000
+ -0.02 0.17 0.00 1000000
+ -0.02 0.21 0.00 1000000
+ -0.02 0.25 0.00 1000000
+ -0.02 0.29 0.00 1000000
+ -0.02 0.33 0.00 1000000
+ -0.02 0.38 0.00 1000000
+ -0.02 0.42 0.00 1000000
+ -0.02 0.46 0.00 1000000
+ -0.02 0.50 0.00 1000000
+ -0.02 0.54 0.00 1000000
+ -0.02 0.58 0.00 1000000
+ -0.02 0.62 0.00 1000000
+ -0.02 0.67 0.00 1000000
+ -0.02 0.71 0.00 1000000
+ -0.02 0.75 0.00 1000000
+ -0.02 0.79 0.00 1000000
+ -0.02 0.83 0.00 1000000
+ -0.02 0.88 0.00 1000000
+ -0.02 0.92 0.00 1000000
+ -0.02 0.96 0.00 1000000
+ -0.02 1.00 0.00 1000000
+ 0.02 0.00 0.00 1000000
+ 0.02 0.04 0.00 1000000
+ 0.02 0.08 0.00 1000000
+ 0.02 0.12 0.00 1000000
+ 0.02 0.17 0.00 1000000
+ 0.02 0.21 0.00 1000000
+ 0.02 0.25 0.00 1000000
+ 0.02 0.29 0.00 1000000
+ 0.02 0.33 0.00 1000000
+ 0.02 0.38 0.00 1000000
+ 0.02 0.42 0.00 1000000
+ 0.02 0.46 0.00 1000000
+ 0.02 0.50 0.00 1000000
+ 0.02 0.54 0.00 1000000
+ 0.02 0.58 0.00 1000000
+ 0.02 0.62 0.00 1000000
+ 0.02 0.67 0.00 1000000
+ 0.02 0.71 0.00 1000000
+ 0.02 0.75 0.00 1000000
+ 0.02 0.79 0.00 1000000
+ 0.02 0.83 0.00 1000000
+ 0.02 0.88 0.00 1000000
+ 0.02 0.92 0.00 1000000
+ 0.02 0.96 0.00 1000000
+ 0.02 1.00 0.00 1000000
+ 0.06 0.00 0.00 1000000
+ 0.06 0.04 0.00 1000000
+ 0.06 0.08 0.00 1000000
+ 0.06 0.12 0.00 1000000
+ 0.06 0.17 0.00 1000000
+ 0.06 0.21 0.00 1000000
+ 0.06 0.25 0.00 1000000
+ 0.06 0.29 0.00 1000000
+ 0.06 0.33 0.00 1000000
+ 0.06 0.38 0.00 1000000
+ 0.06 0.42 0.00 1000000
+ 0.06 0.46 0.00 1000000
+ 0.06 0.50 0.00 1000000
+ 0.06 0.54 0.00 1000000
+ 0.06 0.58 0.00 1000000
+ 0.06 0.62 0.00 1000000
+ 0.06 0.67 0.00 1000000
+ 0.06 0.71 0.00 1000000
+ 0.06 0.75 0.00 1000000
+ 0.06 0.79 0.00 1000000
+ 0.06 0.83 0.00 1000000
+ 0.06 0.88 0.00 1000000
+ 0.06 0.92 0.00 1000000
+ 0.06 0.96 0.00 1000000
+ 0.06 1.00 0.00 1000000
+ 0.10 0.00 0.00 1000000
+ 0.10 0.04 0.00 1000000
+ 0.10 0.08 0.00 1000000
+ 0.10 0.12 0.00 1000000
+ 0.10 0.17 0.00 1000000
+ 0.10 0.21 0.00 1000000
+ 0.10 0.25 0.00 1000000
+ 0.10 0.29 0.00 1000000
+ 0.10 0.33 0.00 1000000
+ 0.10 0.38 0.00 1000000
+ 0.10 0.42 0.00 1000000
+ 0.10 0.46 0.00 1000000
+ 0.10 0.50 0.00 1000000
+ 0.10 0.54 0.00 1000000
+ 0.10 0.58 0.00 1000000
+ 0.10 0.62 0.00 1000000
+ 0.10 0.67 0.00 1000000
+ 0.10 0.71 0.00 1000000
+ 0.10 0.75 0.00 1000000
+ 0.10 0.79 0.00 1000000
+ 0.10 0.83 0.00 1000000
+ 0.10 0.88 0.00 1000000
+ 0.10 0.92 0.00 1000000
+ 0.10 0.96 0.00 1000000
+ 0.10 1.00 0.00 1000000
+ 0.14 0.00 0.00 1000000
+ 0.14 0.04 0.00 1000000
+ 0.14 0.08 0.00 1000000
+ 0.14 0.12 0.00 1000000
+ 0.14 0.17 0.00 1000000
+ 0.14 0.21 0.00 1000000
+ 0.14 0.25 0.00 1000000
+ 0.14 0.29 0.00 1000000
+ 0.14 0.33 0.00 1000000
+ 0.14 0.38 0.00 1000000
+ 0.14 0.42 0.00 1000000
+ 0.14 0.46 0.00 1000000
+ 0.14 0.50 0.00 1000000
+ 0.14 0.54 0.00 1000000
+ 0.14 0.58 0.00 1000000
+ 0.14 0.62 0.00 1000000
+ 0.14 0.67 0.00 1000000
+ 0.14 0.71 0.00 1000000
+ 0.14 0.75 0.00 1000000
+ 0.14 0.79 0.00 1000000
+ 0.14 0.83 0.00 1000000
+ 0.14 0.88 0.00 1000000
+ 0.14 0.92 0.00 1000000
+ 0.14 0.96 0.00 1000000
+ 0.14 1.00 0.00 1000000
+ 0.18 0.00 0.00 1000000
+ 0.18 0.04 0.00 1000000
+ 0.18 0.08 0.00 1000000
+ 0.18 0.12 0.00 1000000
+ 0.18 0.17 0.00 1000000
+ 0.18 0.21 0.00 1000000
+ 0.18 0.25 0.00 1000000
+ 0.18 0.29 0.00 1000000
+ 0.18 0.33 0.00 1000000
+ 0.18 0.38 0.00 1000000
+ 0.18 0.42 0.00 1000000
+ 0.18 0.46 0.00 1000000
+ 0.18 0.50 0.00 1000000
+ 0.18 0.54 0.00 1000000
+ 0.18 0.58 0.00 1000000
+ 0.18 0.62 0.00 1000000
+ 0.18 0.67 0.00 1000000
+ 0.18 0.71 0.00 1000000
+ 0.18 0.75 0.00 1000000
+ 0.18 0.79 0.00 1000000
+ 0.18 0.83 0.00 1000000
+ 0.18 0.88 0.00 1000000
+ 0.18 0.92 0.00 1000000
+ 0.18 0.96 0.00 1000000
+ 0.18 1.00 0.00 1000000
+ 0.22 0.00 0.00 1000000
+ 0.22 0.04 0.00 1000000
+ 0.22 0.08 0.00 1000000
+ 0.22 0.12 0.00 1000000
+ 0.22 0.17 0.00 1000000
+ 0.22 0.21 0.00 1000000
+ 0.22 0.25 0.00 1000000
+ 0.22 0.29 0.00 1000000
+ 0.22 0.33 0.00 1000000
+ 0.22 0.38 0.00 1000000
+ 0.22 0.42 0.00 1000000
+ 0.22 0.46 0.00 1000000
+ 0.22 0.50 0.00 1000000
+ 0.22 0.54 0.00 1000000
+ 0.22 0.58 0.00 1000000
+ 0.22 0.62 0.00 1000000
+ 0.22 0.67 0.00 1000000
+ 0.22 0.71 0.00 1000000
+ 0.22 0.75 0.00 1000000
+ 0.22 0.79 0.00 1000000
+ 0.22 0.83 0.00 1000000
+ 0.22 0.88 0.00 1000000
+ 0.22 0.92 0.00 1000000
+ 0.22 0.96 0.00 1000000
+ 0.22 1.00 0.00 1000000
+ 0.27 0.00 0.00 1000000
+ 0.27 0.04 0.00 1000000
+ 0.27 0.08 0.00 1000000
+ 0.27 0.12 0.00 1000000
+ 0.27 0.17 0.00 1000000
+ 0.27 0.21 0.00 1000000
+ 0.27 0.25 0.00 1000000
+ 0.27 0.29 0.00 1000000
+ 0.27 0.33 0.00 1000000
+ 0.27 0.38 0.00 1000000
+ 0.27 0.42 0.00 1000000
+ 0.27 0.46 0.00 1000000
+ 0.27 0.50 0.00 1000000
+ 0.27 0.54 0.00 1000000
+ 0.27 0.58 0.00 1000000
+ 0.27 0.62 0.00 1000000
+ 0.27 0.67 0.00 1000000
+ 0.27 0.71 0.00 1000000
+ 0.27 0.75 0.00 1000000
+ 0.27 0.79 0.00 1000000
+ 0.27 0.83 0.00 1000000
+ 0.27 0.88 0.00 1000000
+ 0.27 0.92 0.00 1000000
+ 0.27 0.96 0.00 1000000
+ 0.27 1.00 0.00 1000000
+ 0.31 0.00 0.00 1000000
+ 0.31 0.04 0.00 1000000
+ 0.31 0.08 0.00 1000000
+ 0.31 0.12 0.00 1000000
+ 0.31 0.17 0.00 1000000
+ 0.31 0.21 0.00 1000000
+ 0.31 0.25 0.00 1000000
+ 0.31 0.29 0.00 1000000
+ 0.31 0.33 0.00 1000000
+ 0.31 0.38 0.00 1000000
+ 0.31 0.42 0.00 1000000
+ 0.31 0.46 0.00 1000000
+ 0.31 0.50 0.00 1000000
+ 0.31 0.54 0.00 1000000
+ 0.31 0.58 0.00 1000000
+ 0.31 0.62 0.00 1000000
+ 0.31 0.67 0.00 1000000
+ 0.31 0.71 0.00 1000000
+ 0.31 0.75 0.00 1000000
+ 0.31 0.79 0.00 1000000
+ 0.31 0.83 0.00 1000000
+ 0.31 0.88 0.00 1000000
+ 0.31 0.92 0.00 1000000
+ 0.31 0.96 0.00 1000000
+ 0.31 1.00 0.00 1000000
+ 0.35 0.00 0.00 1000000
+ 0.35 0.04 0.00 1000000
+ 0.35 0.08 0.00 1000000
+ 0.35 0.12 0.00 1000000
+ 0.35 0.17 0.00 1000000
+ 0.35 0.21 0.00 1000000
+ 0.35 0.25 0.00 1000000
+ 0.35 0.29 0.00 1000000
+ 0.35 0.33 0.00 1000000
+ 0.35 0.38 0.00 1000000
+ 0.35 0.42 0.00 1000000
+ 0.35 0.46 0.00 1000000
+ 0.35 0.50 0.00 1000000
+ 0.35 0.54 0.00 1000000
+ 0.35 0.58 0.00 1000000
+ 0.35 0.62 0.00 1000000
+ 0.35 0.67 0.00 1000000
+ 0.35 0.71 0.00 1000000
+ 0.35 0.75 0.00 1000000
+ 0.35 0.79 0.00 1000000
+ 0.35 0.83 0.00 1000000
+ 0.35 0.88 0.00 1000000
+ 0.35 0.92 0.00 1000000
+ 0.35 0.96 0.00 1000000
+ 0.35 1.00 0.00 1000000
+ 0.39 0.00 0.00 1000000
+ 0.39 0.04 0.00 1000000
+ 0.39 0.08 0.00 1000000
+ 0.39 0.12 0.00 1000000
+ 0.39 0.17 0.00 1000000
+ 0.39 0.21 0.00 1000000
+ 0.39 0.25 0.00 1000000
+ 0.39 0.29 0.00 1000000
+ 0.39 0.33 0.00 1000000
+ 0.39 0.38 0.00 1000000
+ 0.39 0.42 0.00 1000000
+ 0.39 0.46 0.00 1000000
+ 0.39 0.50 0.00 1000000
+ 0.39 0.54 0.00 1000000
+ 0.39 0.58 0.00 1000000
+ 0.39 0.62 0.00 1000000
+ 0.39 0.67 0.00 1000000
+ 0.39 0.71 0.00 1000000
+ 0.39 0.75 0.00 1000000
+ 0.39 0.79 0.00 1000000
+ 0.39 0.83 0.00 1000000
+ 0.39 0.88 0.00 1000000
+ 0.39 0.92 0.00 1000000
+ 0.39 0.96 0.00 1000000
+ 0.39 1.00 0.00 1000000
+ 0.43 0.00 0.00 1000000
+ 0.43 0.04 0.00 1000000
+ 0.43 0.08 0.00 1000000
+ 0.43 0.12 0.00 1000000
+ 0.43 0.17 0.00 1000000
+ 0.43 0.21 0.00 1000000
+ 0.43 0.25 0.00 1000000
+ 0.43 0.29 0.00 1000000
+ 0.43 0.33 0.00 1000000
+ 0.43 0.38 0.00 1000000
+ 0.43 0.42 0.00 1000000
+ 0.43 0.46 0.00 1000000
+ 0.43 0.50 0.00 1000000
+ 0.43 0.54 0.00 1000000
+ 0.43 0.58 0.00 1000000
+ 0.43 0.62 0.00 1000000
+ 0.43 0.67 0.00 1000000
+ 0.43 0.71 0.00 1000000
+ 0.43 0.75 0.00 1000000
+ 0.43 0.79 0.00 1000000
+ 0.43 0.83 0.00 1000000
+ 0.43 0.88 0.00 1000000
+ 0.43 0.92 0.00 1000000
+ 0.43 0.96 0.00 1000000
+ 0.43 1.00 0.00 1000000
+ 0.47 0.00 0.00 1000000
+ 0.47 0.04 0.00 1000000
+ 0.47 0.08 0.00 1000000
+ 0.47 0.12 0.00 1000000
+ 0.47 0.17 0.00 1000000
+ 0.47 0.21 0.00 1000000
+ 0.47 0.25 0.00 1000000
+ 0.47 0.29 0.00 1000000
+ 0.47 0.33 0.00 1000000
+ 0.47 0.38 0.00 1000000
+ 0.47 0.42 0.00 1000000
+ 0.47 0.46 0.00 1000000
+ 0.47 0.50 0.00 1000000
+ 0.47 0.54 0.00 1000000
+ 0.47 0.58 0.00 1000000
+ 0.47 0.62 0.00 1000000
+ 0.47 0.67 0.00 1000000
+ 0.47 0.71 0.00 1000000
+ 0.47 0.75 0.00 1000000
+ 0.47 0.79 0.00 1000000
+ 0.47 0.83 0.00 1000000
+ 0.47 0.88 0.00 1000000
+ 0.47 0.92 0.00 1000000
+ 0.47 0.96 0.00 1000000
+ 0.47 1.00 0.00 1000000
+ 0.51 0.00 0.00 1000000
+ 0.51 0.04 0.00 1000000
+ 0.51 0.08 0.00 1000000
+ 0.51 0.12 0.00 1000000
+ 0.51 0.17 0.00 1000000
+ 0.51 0.21 0.00 1000000
+ 0.51 0.25 0.00 1000000
+ 0.51 0.29 0.00 1000000
+ 0.51 0.33 0.00 1000000
+ 0.51 0.38 0.00 1000000
+ 0.51 0.42 0.00 1000000
+ 0.51 0.46 0.00 1000000
+ 0.51 0.50 0.00 1000000
+ 0.51 0.54 0.00 1000000
+ 0.51 0.58 0.00 1000000
+ 0.51 0.62 0.00 1000000
+ 0.51 0.67 0.00 1000000
+ 0.51 0.71 0.00 1000000
+ 0.51 0.75 0.00 1000000
+ 0.51 0.79 0.00 1000000
+ 0.51 0.83 0.00 1000000
+ 0.51 0.88 0.00 1000000
+ 0.51 0.92 0.00 1000000
+ 0.51 0.96 0.00 1000000
+ 0.51 1.00 0.00 1000000
+ 0.55 0.00 0.00 1000000
+ 0.55 0.04 0.00 1000000
+ 0.55 0.08 0.00 1000000
+ 0.55 0.12 0.00 1000000
+ 0.55 0.17 0.00 1000000
+ 0.55 0.21 0.00 1000000
+ 0.55 0.25 0.00 1000000
+ 0.55 0.29 0.00 1000000
+ 0.55 0.33 0.00 1000000
+ 0.55 0.38 0.00 1000000
+ 0.55 0.42 0.00 1000000
+ 0.55 0.46 0.00 1000000
+ 0.55 0.50 0.00 1000000
+ 0.55 0.54 0.00 1000000
+ 0.55 0.58 0.00 1000000
+ 0.55 0.62 0.00 1000000
+ 0.55 0.67 0.00 1000000
+ 0.55 0.71 0.00 1000000
+ 0.55 0.75 0.00 1000000
+ 0.55 0.79 0.00 1000000
+ 0.55 0.83 0.00 1000000
+ 0.55 0.88 0.00 1000000
+ 0.55 0.92 0.00 1000000
+ 0.55 0.96 0.00 1000000
+ 0.55 1.00 0.00 1000000
+ 0.59 0.00 0.00 1000000
+ 0.59 0.04 0.00 1000000
+ 0.59 0.08 0.00 1000000
+ 0.59 0.12 0.00 1000000
+ 0.59 0.17 0.00 1000000
+ 0.59 0.21 0.00 1000000
+ 0.59 0.25 0.00 1000000
+ 0.59 0.29 0.00 1000000
+ 0.59 0.33 0.00 1000000
+ 0.59 0.38 0.00 1000000
+ 0.59 0.42 0.00 1000000
+ 0.59 0.46 0.00 1000000
+ 0.59 0.50 0.00 1000000
+ 0.59 0.54 0.00 1000000
+ 0.59 0.58 0.00 1000000
+ 0.59 0.62 0.00 1000000
+ 0.59 0.67 0.00 1000000
+ 0.59 0.71 0.00 1000000
+ 0.59 0.75 0.00 1000000
+ 0.59 0.79 0.00 1000000
+ 0.59 0.83 0.00 1000000
+ 0.59 0.88 0.00 1000000
+ 0.59 0.92 0.00 1000000
+ 0.59 0.96 0.00 1000000
+ 0.59 1.00 0.00 1000000
+ 0.63 0.00 0.00 1000000
+ 0.63 0.04 0.00 1000000
+ 0.63 0.08 0.00 1000000
+ 0.63 0.12 0.00 1000000
+ 0.63 0.17 0.00 1000000
+ 0.63 0.21 0.00 1000000
+ 0.63 0.25 0.00 1000000
+ 0.63 0.29 0.00 1000000
+ 0.63 0.33 0.00 1000000
+ 0.63 0.38 0.00 1000000
+ 0.63 0.42 0.00 1000000
+ 0.63 0.46 0.00 1000000
+ 0.63 0.50 0.00 1000000
+ 0.63 0.54 0.00 1000000
+ 0.63 0.58 0.00 1000000
+ 0.63 0.62 0.00 1000000
+ 0.63 0.67 0.00 1000000
+ 0.63 0.71 0.00 1000000
+ 0.63 0.75 0.00 1000000
+ 0.63 0.79 0.00 1000000
+ 0.63 0.83 0.00 1000000
+ 0.63 0.88 0.00 1000000
+ 0.63 0.92 0.00 1000000
+ 0.63 0.96 0.00 1000000
+ 0.63 1.00 0.00 1000000
+ 0.67 0.00 0.00 1000000
+ 0.67 0.04 0.00 1000000
+ 0.67 0.08 0.00 1000000
+ 0.67 0.12 0.00 1000000
+ 0.67 0.17 0.00 1000000
+ 0.67 0.21 0.00 1000000
+ 0.67 0.25 0.00 1000000
+ 0.67 0.29 0.00 1000000
+ 0.67 0.33 0.00 1000000
+ 0.67 0.38 0.00 1000000
+ 0.67 0.42 0.00 1000000
+ 0.67 0.46 0.00 1000000
+ 0.67 0.50 0.00 1000000
+ 0.67 0.54 0.00 1000000
+ 0.67 0.58 0.00 1000000
+ 0.67 0.62 0.00 1000000
+ 0.67 0.67 0.00 1000000
+ 0.67 0.71 0.00 1000000
+ 0.67 0.75 0.00 1000000
+ 0.67 0.79 0.00 1000000
+ 0.67 0.83 0.00 1000000
+ 0.67 0.88 0.00 1000000
+ 0.67 0.92 0.00 1000000
+ 0.67 0.96 0.00 1000000
+ 0.67 1.00 0.00 1000000
+ 0.71 0.00 0.00 1000000
+ 0.71 0.04 0.00 1000000
+ 0.71 0.08 0.00 1000000
+ 0.71 0.12 0.00 1000000
+ 0.71 0.17 0.00 1000000
+ 0.71 0.21 0.00 1000000
+ 0.71 0.25 0.00 1000000
+ 0.71 0.29 0.00 1000000
+ 0.71 0.33 0.00 1000000
+ 0.71 0.38 0.00 1000000
+ 0.71 0.42 0.00 1000000
+ 0.71 0.46 0.00 1000000
+ 0.71 0.50 0.00 1000000
+ 0.71 0.54 0.00 1000000
+ 0.71 0.58 0.00 1000000
+ 0.71 0.62 0.00 1000000
+ 0.71 0.67 0.00 1000000
+ 0.71 0.71 0.00 1000000
+ 0.71 0.75 0.00 1000000
+ 0.71 0.79 0.00 1000000
+ 0.71 0.83 0.00 1000000
+ 0.71 0.88 0.00 1000000
+ 0.71 0.92 0.00 1000000
+ 0.71 0.96 0.00 1000000
+ 0.71 1.00 0.00 1000000
+ 0.76 0.00 0.00 1000000
+ 0.76 0.04 0.00 1000000
+ 0.76 0.08 0.00 1000000
+ 0.76 0.12 0.00 1000000
+ 0.76 0.17 0.00 1000000
+ 0.76 0.21 0.00 1000000
+ 0.76 0.25 0.00 1000000
+ 0.76 0.29 0.00 1000000
+ 0.76 0.33 0.00 1000000
+ 0.76 0.38 0.00 1000000
+ 0.76 0.42 0.00 1000000
+ 0.76 0.46 0.00 1000000
+ 0.76 0.50 0.00 1000000
+ 0.76 0.54 0.00 1000000
+ 0.76 0.58 0.00 1000000
+ 0.76 0.62 0.00 1000000
+ 0.76 0.67 0.00 1000000
+ 0.76 0.71 0.00 1000000
+ 0.76 0.75 0.00 1000000
+ 0.76 0.79 0.00 1000000
+ 0.76 0.83 0.00 1000000
+ 0.76 0.88 0.00 1000000
+ 0.76 0.92 0.00 1000000
+ 0.76 0.96 0.00 1000000
+ 0.76 1.00 0.00 1000000
+ 0.80 0.00 0.00 1000000
+ 0.80 0.04 0.00 1000000
+ 0.80 0.08 0.00 1000000
+ 0.80 0.12 0.00 1000000
+ 0.80 0.17 0.00 1000000
+ 0.80 0.21 0.00 1000000
+ 0.80 0.25 0.00 1000000
+ 0.80 0.29 0.00 1000000
+ 0.80 0.33 0.00 1000000
+ 0.80 0.38 0.00 1000000
+ 0.80 0.42 0.00 1000000
+ 0.80 0.46 0.00 1000000
+ 0.80 0.50 0.00 1000000
+ 0.80 0.54 0.00 1000000
+ 0.80 0.58 0.00 1000000
+ 0.80 0.62 0.00 1000000
+ 0.80 0.67 0.00 1000000
+ 0.80 0.71 0.00 1000000
+ 0.80 0.75 0.00 1000000
+ 0.80 0.79 0.00 1000000
+ 0.80 0.83 0.00 1000000
+ 0.80 0.88 0.00 1000000
+ 0.80 0.92 0.00 1000000
+ 0.80 0.96 0.00 1000000
+ 0.80 1.00 0.00 1000000
+ 0.84 0.00 0.00 1000000
+ 0.84 0.04 0.00 1000000
+ 0.84 0.08 0.00 1000000
+ 0.84 0.12 0.00 1000000
+ 0.84 0.17 0.00 1000000
+ 0.84 0.21 0.00 1000000
+ 0.84 0.25 0.00 1000000
+ 0.84 0.29 0.00 1000000
+ 0.84 0.33 0.00 1000000
+ 0.84 0.38 0.00 1000000
+ 0.84 0.42 0.00 1000000
+ 0.84 0.46 0.00 1000000
+ 0.84 0.50 0.00 1000000
+ 0.84 0.54 0.00 1000000
+ 0.84 0.58 0.00 1000000
+ 0.84 0.62 0.00 1000000
+ 0.84 0.67 0.00 1000000
+ 0.84 0.71 0.00 1000000
+ 0.84 0.75 0.00 1000000
+ 0.84 0.79 0.00 1000000
+ 0.84 0.83 0.00 1000000
+ 0.84 0.88 0.00 1000000
+ 0.84 0.92 0.00 1000000
+ 0.84 0.96 0.00 1000000
+ 0.84 1.00 0.00 1000000
+ 0.88 0.00 0.00 1000000
+ 0.88 0.04 0.00 1000000
+ 0.88 0.08 0.00 1000000
+ 0.88 0.12 0.00 1000000
+ 0.88 0.17 0.00 1000000
+ 0.88 0.21 0.00 1000000
+ 0.88 0.25 0.00 1000000
+ 0.88 0.29 0.00 1000000
+ 0.88 0.33 0.00 1000000
+ 0.88 0.38 0.00 1000000
+ 0.88 0.42 0.00 1000000
+ 0.88 0.46 0.00 1000000
+ 0.88 0.50 0.00 1000000
+ 0.88 0.54 0.00 1000000
+ 0.88 0.58 0.00 1000000
+ 0.88 0.62 0.00 1000000
+ 0.88 0.67 0.00 1000000
+ 0.88 0.71 0.00 1000000
+ 0.88 0.75 0.00 1000000
+ 0.88 0.79 0.00 1000000
+ 0.88 0.83 0.00 1000000
+ 0.88 0.88 0.00 1000000
+ 0.88 0.92 0.00 1000000
+ 0.88 0.96 0.00 1000000
+ 0.88 1.00 0.00 1000000
+ 0.92 0.00 0.00 1000000
+ 0.92 0.04 0.00 1000000
+ 0.92 0.08 0.00 1000000
+ 0.92 0.12 0.00 1000000
+ 0.92 0.17 0.00 1000000
+ 0.92 0.21 0.00 1000000
+ 0.92 0.25 0.00 1000000
+ 0.92 0.29 0.00 1000000
+ 0.92 0.33 0.00 1000000
+ 0.92 0.38 0.00 1000000
+ 0.92 0.42 0.00 1000000
+ 0.92 0.46 0.00 1000000
+ 0.92 0.50 0.00 1000000
+ 0.92 0.54 0.00 1000000
+ 0.92 0.58 0.00 1000000
+ 0.92 0.62 0.00 1000000
+ 0.92 0.67 0.00 1000000
+ 0.92 0.71 0.00 1000000
+ 0.92 0.75 0.00 1000000
+ 0.92 0.79 0.00 1000000
+ 0.92 0.83 0.00 1000000
+ 0.92 0.88 0.00 1000000
+ 0.92 0.92 0.00 1000000
+ 0.92 0.96 0.00 1000000
+ 0.92 1.00 0.00 1000000
+ 0.96 0.00 0.00 1000000
+ 0.96 0.04 0.00 1000000
+ 0.96 0.08 0.00 1000000
+ 0.96 0.12 0.00 1000000
+ 0.96 0.17 0.00 1000000
+ 0.96 0.21 0.00 1000000
+ 0.96 0.25 0.00 1000000
+ 0.96 0.29 0.00 1000000
+ 0.96 0.33 0.00 1000000
+ 0.96 0.38 0.00 1000000
+ 0.96 0.42 0.00 1000000
+ 0.96 0.46 0.00 1000000
+ 0.96 0.50 0.00 1000000
+ 0.96 0.54 0.00 1000000
+ 0.96 0.58 0.00 1000000
+ 0.96 0.62 0.00 1000000
+ 0.96 0.67 0.00 1000000
+ 0.96 0.71 0.00 1000000
+ 0.96 0.75 0.00 1000000
+ 0.96 0.79 0.00 1000000
+ 0.96 0.83 0.00 1000000
+ 0.96 0.88 0.00 1000000
+ 0.96 0.92 0.00 1000000
+ 0.96 0.96 0.00 1000000
+ 0.96 1.00 0.00 1000000
+ 1.00 0.00 0.00 1000000
+ 1.00 0.04 0.00 1000000
+ 1.00 0.08 0.00 1000000
+ 1.00 0.12 0.00 1000000
+ 1.00 0.17 0.00 1000000
+ 1.00 0.21 0.00 1000000
+ 1.00 0.25 0.00 1000000
+ 1.00 0.29 0.00 1000000
+ 1.00 0.33 0.00 1000000
+ 1.00 0.38 0.00 1000000
+ 1.00 0.42 0.00 1000000
+ 1.00 0.46 0.00 1000000
+ 1.00 0.50 0.00 1000000
+ 1.00 0.54 0.00 1000000
+ 1.00 0.58 0.00 1000000
+ 1.00 0.62 0.00 1000000
+ 1.00 0.67 0.00 1000000
+ 1.00 0.71 0.00 1000000
+ 1.00 0.75 0.00 1000000
+ 1.00 0.79 0.00 1000000
+ 1.00 0.83 0.00 1000000
+ 1.00 0.88 0.00 1000000
+ 1.00 0.92 0.00 1000000
+ 1.00 0.96 0.00 1000000
+ 1.00 1.00 0.00 1000000
.enddata

*****************************

* PTM Low Power 45nm Metal Gate / High-K / Strained-Si
* nominal Vdd = 1.1V

.model  nmos  nmos  level = 54

+version = 4.0             binunit = 1               paramchk= 1               mobmod  = 0
+capmod  = 2               igcmod  = 1               igbmod  = 1               geomod  = 1
+diomod  = 1               rdsmod  = 0               rbodymod= 1               rgatemod= 1
+permod  = 1               acnqsmod= 0               trnqsmod= 0

+tnom    = 27              toxe    = 1.8e-009        toxp    = 1.5e-009        toxm    = 1.8e-009
+dtox    = 3e-010          epsrox  = 3.9             wint    = 5e-009          lint    = 0
+ll      = 0               wl      = 0               lln     = 1               wln     = 1
+lw      = 0               ww      = 0               lwn     = 1               wwn     = 1
+lwl     = 0               wwl     = 0               xpart   = 0               toxref  = 1.8e-009

+vth0    = 0.62261         k1      = 0.4             k2      = 0               k3      = 0
+k3b     = 0               w0      = 2.5e-006        dvt0    = 1               dvt1    = 2
+dvt2    = 0               dvt0w   = 0               dvt1w   = 0               dvt2w   = 0
+dsub    = 0.1             minv    = 0.05            voffl   = 0               dvtp0   = 1e-010
+dvtp1   = 0.1             lpe0    = 0               lpeb    = 0               xj      = 1.4e-008
+ngate   = 1e+023          ndep    = 3.24e+018       nsd     = 2e+020          phin    = 0
+cdsc    = 0               cdscb   = 0               cdscd   = 0               cit     = 0
+voff    = -0.13           nfactor = 1.6             eta0    = 0.0125          etab    = 0
+vfb     = -0.55           u0      = 0.049           ua      = 6e-010          ub      = 1.2e-018
+uc      = 0               vsat    = 130000          a0      = 1               ags     = 0
+a1      = 0               a2      = 1               b0      = 0               b1      = 0
+keta    = 0.04            dwg     = 0               dwb     = 0               pclm    = 0.02
+pdiblc1 = 0.001           pdiblc2 = 0.001           pdiblcb = -0.005          drout   = 0.5
+pvag    = 1e-020          delta   = 0.01            pscbe1  = 8.14e+008       pscbe2  = 1e-007
+fprout  = 0.2             pdits   = 0.08            pditsd  = 0.23            pditsl  = 2300000
+rsh     = 5               rdsw    = 210             rsw     = 80              rdw     = 80
+rdswmin = 0               rdwmin  = 0               rswmin  = 0               prwg    = 0
+prwb    = 0               wr      = 1               alpha0  = 0.074           alpha1  = 0.005
+beta0   = 30              agidl   = 0.0002          bgidl   = 2.1e+009        cgidl   = 0.0002
+egidl   = 0.8             aigbacc = 0.012           bigbacc = 0.0028          cigbacc = 0.002
+nigbacc = 1               aigbinv = 0.014           bigbinv = 0.004           cigbinv = 0.004
+eigbinv = 1.1             nigbinv = 3               aigc    = 0.015211        bigc    = 0.0027432
+cigc    = 0.002           aigsd   = 0.015211        bigsd   = 0.0027432       cigsd   = 0.002
+nigc    = 1               poxedge = 1               pigcd   = 1               ntox    = 1
+xrcrg1  = 12              xrcrg2  = 5

+cgso    = 1.1e-010        cgdo    = 1.1e-010        cgbo    = 2.56e-011       cgdl    = 2.653e-010
+cgsl    = 2.653e-010      ckappas = 0.03            ckappad = 0.03            acde    = 1
+moin    = 15              noff    = 0.9             voffcv  = 0.02

+kt1     = -0.11           kt1l    = 0               kt2     = 0.022           ute     = -1.5
+ua1     = 4.31e-009       ub1     = 7.61e-018       uc1     = -5.6e-011       prt     = 0
+at      = 33000

+fnoimod = 1               tnoimod = 0

+jss     = 0.0001          jsws    = 1e-011          jswgs   = 1e-010          njs     = 1
+ijthsfwd= 0.01            ijthsrev= 0.001           bvs     = 10              xjbvs   = 1
+jsd     = 0.0001          jswd    = 1e-011          jswgd   = 1e-010          njd     = 1
+ijthdfwd= 0.01            ijthdrev= 0.001           bvd     = 10              xjbvd   = 1
+pbs     = 1               cjs     = 0.0005          mjs     = 0.5             pbsws   = 1
+cjsws   = 5e-010          mjsws   = 0.33            pbswgs  = 1               cjswgs  = 3e-010
+mjswgs  = 0.33            pbd     = 1               cjd     = 0.0005          mjd     = 0.5
+pbswd   = 1               cjswd   = 5e-010          mjswd   = 0.33            pbswgd  = 1
+cjswgd  = 5e-010          mjswgd  = 0.33            tpb     = 0.005           tcj     = 0.001
+tpbsw   = 0.005           tcjsw   = 0.001           tpbswg  = 0.005           tcjswg  = 0.001
+xtis    = 3               xtid    = 3

+dmcg    = 0               dmci    = 0               dmdg    = 0               dmcgt   = 0
+dwj     = 0               xgw     = 0               xgl     = 0

+rshg    = 0.4             gbmin   = 1e-010          rbpb    = 5               rbpd    = 15
+rbps    = 15              rbdb    = 15              rbsb    = 15              ngcon   = 1

.model  pmos  pmos  level = 54

+version = 4.0             binunit = 1               paramchk= 1               mobmod  = 0
+capmod  = 2               igcmod  = 1               igbmod  = 1               geomod  = 1
+diomod  = 1               rdsmod  = 0               rbodymod= 1               rgatemod= 1
+permod  = 1               acnqsmod= 0               trnqsmod= 0

+tnom    = 27              toxe    = 1.82e-009       toxp    = 1.5e-009        toxm    = 1.82e-009
+dtox    = 3.2e-010        epsrox  = 3.9             wint    = 5e-009          lint    = 0
+ll      = 0               wl      = 0               lln     = 1               wln     = 1
+lw      = 0               ww      = 0               lwn     = 1               wwn     = 1
+lwl     = 0               wwl     = 0               xpart   = 0               toxref  = 1.82e-009

+vth0    = -0.587          k1      = 0.4             k2      = -0.01           k3      = 0
+k3b     = 0               w0      = 2.5e-006        dvt0    = 1               dvt1    = 2
+dvt2    = -0.032          dvt0w   = 0               dvt1w   = 0               dvt2w   = 0
+dsub    = 0.1             minv    = 0.05            voffl   = 0               dvtp0   = 1e-011
+dvtp1   = 0.05            lpe0    = 0               lpeb    = 0               xj      = 1.4e-008
+ngate   = 1e+023          ndep    = 2.44e+018       nsd     = 2e+020          phin    = 0
+cdsc    = 0               cdscb   = 0               cdscd   = 0               cit     = 0
+voff    = -0.126          nfactor = 1.8             eta0    = 0.0125          etab    = 0
+vfb     = 0.55            u0      = 0.021           ua      = 2e-009          ub      = 5e-019
+uc      = 0               vsat    = 90000           a0      = 1               ags     = 1e-020
+a1      = 0               a2      = 1               b0      = 0               b1      = 0
+keta    = -0.047          dwg     = 0               dwb     = 0               pclm    = 0.12
+pdiblc1 = 0.001           pdiblc2 = 0.001           pdiblcb = 3.4e-008        drout   = 0.56
+pvag    = 1e-020          delta   = 0.01            pscbe1  = 8.14e+008       pscbe2  = 9.58e-007
+fprout  = 0.2             pdits   = 0.08            pditsd  = 0.23            pditsl  = 2300000
+rsh     = 5               rdsw    = 250             rsw     = 75              rdw     = 75
+rdswmin = 0               rdwmin  = 0               rswmin  = 0               prwg    = 0
+prwb    = 0               wr      = 1               alpha0  = 0.074           alpha1  = 0.005
+beta0   = 30              agidl   = 0.0002          bgidl   = 2.1e+009        cgidl   = 0.0002
+egidl   = 0.8             aigbacc = 0.012           bigbacc = 0.0028          cigbacc = 0.002
+nigbacc = 1               aigbinv = 0.014           bigbinv = 0.004           cigbinv = 0.004
+eigbinv = 1.1             nigbinv = 3               aigc    = 0.0097          bigc    = 0.00125
+cigc    = 0.0008          aigsd   = 0.0097          bigsd   = 0.00125         cigsd   = 0.0008
+nigc    = 1               poxedge = 1               pigcd   = 1               ntox    = 1
+xrcrg1  = 12              xrcrg2  = 5

+cgso    = 1.1e-010        cgdo    = 1.1e-010        cgbo    = 2.56e-011       cgdl    = 2.653e-010
+cgsl    = 2.653e-010      ckappas = 0.03            ckappad = 0.03            acde    = 1
+moin    = 15              noff    = 0.9             voffcv  = 0.02

+kt1     = -0.11           kt1l    = 0               kt2     = 0.022           ute     = -1.5
+ua1     = 4.31e-009       ub1     = 7.61e-018       uc1     = -5.6e-011       prt     = 0
+at      = 33000

+fnoimod = 1               tnoimod = 0

+jss     = 0.0001          jsws    = 1e-011          jswgs   = 1e-010          njs     = 1
+ijthsfwd= 0.01            ijthsrev= 0.001           bvs     = 10              xjbvs   = 1
+jsd     = 0.0001          jswd    = 1e-011          jswgd   = 1e-010          njd     = 1
+ijthdfwd= 0.01            ijthdrev= 0.001           bvd     = 10              xjbvd   = 1
+pbs     = 1               cjs     = 0.0005          mjs     = 0.5             pbsws   = 1
+cjsws   = 5e-010          mjsws   = 0.33            pbswgs  = 1               cjswgs  = 3e-010
+mjswgs  = 0.33            pbd     = 1               cjd     = 0.0005          mjd     = 0.5
+pbswd   = 1               cjswd   = 5e-010          mjswd   = 0.33            pbswgd  = 1
+cjswgd  = 5e-010          mjswgd  = 0.33            tpb     = 0.005           tcj     = 0.001
+tpbsw   = 0.005           tcjsw   = 0.001           tpbswg  = 0.005           tcjswg  = 0.001
+xtis    = 3               xtid    = 3

+dmcg    = 0               dmci    = 0               dmdg    = 0               dmcgt   = 0
+dwj     = 0               xgw     = 0               xgl     = 0

+rshg    = 0.4             gbmin   = 1e-010          rbpb    = 5               rbpd    = 15
+rbps    = 15              rbdb    = 15              rbsb    = 15              ngcon   = 1

.end
